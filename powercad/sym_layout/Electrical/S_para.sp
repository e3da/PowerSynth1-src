* 2018-11-11 00:08:20
R1_2 1 2 0.00693632711364
L1_2 2 3 2.99610962607e-09
C1_2 2 gnd 2.13398825042e-13F
R1_28 4 5 0.00161329802044
L1_28 5 1 6.24946887687e-10
C1_28 5 gnd 1.17016341635e-13F
R1_5 1 6 0.000153874748106
L1_5 6 7 1.0934054912e-10
C1_5 6 gnd 2.77185829026e-13F
R1_31 8 9 0.000961197114173
L1_31 9 1 4.92082212779e-10
C1_31 9 gnd 1.84139798716e-13F
R2_3 3 10 0.00693632711364
L2_3 10 11 2.99610962607e-09
C2_3 10 gnd 2.13398825042e-13F
R2_6 3 12 0.000155405948119
L2_6 12 13 1.23166283776e-10
C2_6 12 gnd 4.14849068913e-13F
R3_4 11 14 0.00693632711364
L3_4 14 15 2.99610962607e-09
C3_4 14 gnd 2.13398825042e-13F
R3_7 11 16 0.000155405948119
L3_7 16 17 1.23166283776e-10
C3_7 16 gnd 4.14849068913e-13F
R4_8 15 18 0.000222141119823
L4_8 18 19 1.35878793897e-10
C4_8 18 gnd 2.08472233737e-13F
R5_34 20 21 0.00130692277351
L5_34 21 7 5.70882572194e-10
C5_34 21 gnd 1.39388566443e-13F
R5_6 7 22 0.00439553626256
L5_6 22 13 2.4846055588e-09
C5_6 22 gnd 4.10954805471e-13F
R5_9 7 23 0.000153874748106
L5_9 23 24 1.0934054912e-10
C5_9 23 gnd 2.77185829026e-13F
R6_10 13 25 0.000155405948119
L6_10 25 26 1.23166283776e-10
C6_10 25 gnd 4.14849068913e-13F
R6_7 13 27 0.00439553626256
L6_7 27 17 2.4846055588e-09
C6_7 27 gnd 4.10954805471e-13F
R7_11 17 28 0.000155405948119
L7_11 28 29 1.23166283776e-10
C7_11 28 gnd 4.14849068913e-13F
R7_8 17 30 0.00439553626256
L7_8 30 19 2.4846055588e-09
C7_8 30 gnd 4.10954805471e-13F
R8_12 19 31 0.000222141119823
L8_12 31 32 1.35878793897e-10
C8_12 31 gnd 2.08472233737e-13F
R9_37 33 34 0.00130692277351
L9_37 34 24 5.70882572194e-10
C9_37 34 gnd 1.39388566443e-13F
R9_10 24 35 0.00439553626256
L9_10 35 26 2.4846055588e-09
C9_10 35 gnd 4.10954805471e-13F
R9_13 24 36 0.000153874748106
L9_13 36 37 1.0934054912e-10
C9_13 36 gnd 2.77185829026e-13F
R10_11 26 38 0.00439553626256
L10_11 38 29 2.4846055588e-09
C10_11 38 gnd 4.10954805471e-13F
R10_14 26 39 0.000155405948119
L10_14 39 40 1.23166283776e-10
C10_14 39 gnd 4.14849068913e-13F
R11_15 29 41 0.000155405948119
L11_15 41 42 1.23166283776e-10
C11_15 41 gnd 4.14849068913e-13F
R11_12 29 43 0.00439553626256
L11_12 43 32 2.4846055588e-09
C11_12 43 gnd 4.10954805471e-13F
R12_16 32 44 0.000222141119823
L12_16 44 45 1.35878793897e-10
C12_16 44 gnd 2.08472233737e-13F
R13_40 46 47 0.00229183898312
L13_40 47 37 7.56528043053e-10
C13_40 47 gnd 7.22685636863e-14F
R13_14 37 48 0.00693632711364
L13_14 48 40 2.99610962607e-09
C13_14 48 gnd 2.13398825042e-13F
R14_15 40 49 0.00693632711364
L14_15 49 42 2.99610962607e-09
C14_15 49 gnd 2.13398825042e-13F
R15_16 42 50 0.00693632711364
L15_16 50 45 2.99610962607e-09
C15_16 50 gnd 2.13398825042e-13F
R17_18 51 52 0.00161329802044
L17_18 52 53 6.24946887687e-10
C17_18 52 gnd 1.17016341635e-13F
R17_21 51 54 0.00161329802044
L17_21 54 55 6.24946887687e-10
C17_21 54 gnd 1.17016341635e-13F
R18_19 53 56 0.00161329802044
L18_19 56 57 6.24946887687e-10
C18_19 56 gnd 1.17016341635e-13F
R18_22 53 58 0.000752470042979
L18_22 58 59 4.35905994571e-10
C18_22 58 gnd 2.28904057924e-13F
R19_20 57 60 0.00161329802044
L19_20 60 61 6.24946887687e-10
C19_20 60 gnd 1.17016341635e-13F
R19_23 57 62 0.000752470042979
L19_23 62 63 4.35905994571e-10
C19_23 62 gnd 2.28904057924e-13F
R20_24 61 64 0.00161329802044
L20_24 64 65 6.24946887687e-10
C20_24 64 gnd 1.17016341635e-13F
R21_22 55 66 0.000752470042979
L21_22 66 59 4.35905994571e-10
C21_22 66 gnd 2.28904057924e-13F
R21_25 55 67 0.00161329802044
L21_25 67 68 6.24946887687e-10
C21_25 67 gnd 1.17016341635e-13F
R22_26 59 69 0.000752470042979
L22_26 69 70 4.35905994571e-10
C22_26 69 gnd 2.28904057924e-13F
R22_23 59 71 0.000752470042979
L22_23 71 63 4.35905994571e-10
C22_23 71 gnd 2.28904057924e-13F
R23_27 63 72 0.000752470042979
L23_27 72 73 4.35905994571e-10
C23_27 72 gnd 2.28904057924e-13F
R23_24 63 74 0.000752470042979
L23_24 74 65 4.35905994571e-10
C23_24 74 gnd 2.28904057924e-13F
R24_28 65 75 0.00161329802044
L24_28 75 4 6.24946887687e-10
C24_28 75 gnd 1.17016341635e-13F
R25_26 68 76 0.000752470042979
L25_26 76 70 4.35905994571e-10
C25_26 76 gnd 2.28904057924e-13F
R25_29 68 77 0.00161329802044
L25_29 77 78 6.24946887687e-10
C25_29 77 gnd 1.17016341635e-13F
R26_27 70 79 0.000752470042979
L26_27 79 73 4.35905994571e-10
C26_27 79 gnd 2.28904057924e-13F
R26_30 70 80 0.000752470042979
L26_30 80 81 4.35905994571e-10
C26_30 80 gnd 2.28904057924e-13F
R27_31 73 82 0.000752470042979
L27_31 82 8 4.35905994571e-10
C27_31 82 gnd 2.28904057924e-13F
R27_28 73 83 0.000752470042979
L27_28 83 4 4.35905994571e-10
C27_28 83 gnd 2.28904057924e-13F
R29_32 78 84 0.000867655276287
L29_32 84 85 2.78621041275e-10
C29_32 84 gnd 7.13926459436e-14F
R29_30 78 86 0.000961197114173
L29_30 86 81 4.92082212779e-10
C29_30 86 gnd 1.84139798716e-13F
R30_33 81 87 0.00035800188864
L30_33 87 88 1.75299237175e-10
C30_33 87 gnd 1.39865232573e-13F
R30_31 81 89 0.000961197114173
L30_31 89 8 4.92082212779e-10
C30_31 89 gnd 1.84139798716e-13F
R31_34 8 90 0.00035800188864
L31_34 90 20 1.75299237175e-10
C31_34 90 gnd 1.39865232573e-13F
R32_33 85 91 0.00130692277351
L32_33 91 88 5.70882572194e-10
C32_33 91 gnd 1.39388566443e-13F
R32_35 85 92 0.000867655276287
L32_35 92 93 2.78621041275e-10
C32_35 92 gnd 7.13926459436e-14F
R33_34 88 94 0.00130692277351
L33_34 94 20 5.70882572194e-10
C33_34 94 gnd 1.39388566443e-13F
R33_36 88 95 0.00035800188864
L33_36 95 96 1.75299237175e-10
C33_36 95 gnd 1.39865232573e-13F
R34_37 20 97 0.00035800188864
L34_37 97 33 1.75299237175e-10
C34_37 97 gnd 1.39865232573e-13F
R35_36 93 98 0.00130692277351
L35_36 98 96 5.70882572194e-10
C35_36 98 gnd 1.39388566443e-13F
R35_38 93 99 0.000867655276287
L35_38 99 100 2.78621041275e-10
C35_38 99 gnd 7.13926459436e-14F
R36_37 96 101 0.00130692277351
L36_37 101 33 5.70882572194e-10
C36_37 101 gnd 1.39388566443e-13F
R36_39 96 102 0.00035800188864
L36_39 102 103 1.75299237175e-10
C36_39 102 gnd 1.39865232573e-13F
R37_40 33 104 0.00035800188864
L37_40 104 46 1.75299237175e-10
C37_40 104 gnd 1.39865232573e-13F
R38_39 100 105 0.00229183898312
L38_39 105 103 7.56528043053e-10
C38_39 105 gnd 7.22685636863e-14F
R39_40 103 106 0.00229183898312
L39_40 106 46 7.56528043053e-10
C39_40 106 gnd 7.22685636863e-14F
R41_42 107 108 0.00950620731167
L41_42 108 109 4.27989429243e-09
C41_42 108 gnd 2.83963955719e-13F
R41_45 107 110 0.000153874748106
L41_45 110 111 1.0934054912e-10
C41_45 110 gnd 2.77185829026e-13F
R42_43 109 112 0.00950620731167
L42_43 112 113 4.27989429243e-09
C42_43 112 gnd 2.83963955719e-13F
R42_46 109 114 0.00134813854029
L42_46 114 115 8.67449879291e-10
C42_46 114 gnd 5.52736885425e-13F
R43_44 113 116 0.00950620731167
L43_44 116 117 4.27989429243e-09
C43_44 116 gnd 2.83963955719e-13F
R43_47 113 118 0.00134813854029
L43_47 118 119 8.67449879291e-10
C43_47 118 gnd 5.52736885425e-13F
R44_48 117 120 0.000153874748106
L44_48 120 121 1.0934054912e-10
C44_48 120 gnd 2.77185829026e-13F
R45_46 111 122 0.0057742967321
L45_46 122 115 3.54027758996e-09
C45_46 122 gnd 5.46737924985e-13F
R45_49 111 123 0.000153874748106
L45_49 123 124 1.0934054912e-10
C45_49 123 gnd 2.77185829026e-13F
R46_50 115 125 0.00134813854029
L46_50 125 126 8.67449879291e-10
C46_50 125 gnd 5.52736885425e-13F
R46_47 115 127 0.0057742967321
L46_47 127 119 3.54027758996e-09
C46_47 127 gnd 5.46737924985e-13F
R47_48 119 128 0.0057742967321
L47_48 128 121 3.54027758996e-09
C47_48 128 gnd 5.46737924985e-13F
R47_51 119 129 0.00134813854029
L47_51 129 130 8.67449879291e-10
C47_51 129 gnd 5.52736885425e-13F
R48_52 121 131 0.000153874748106
L48_52 131 132 1.0934054912e-10
C48_52 131 gnd 2.77185829026e-13F
R49_50 124 133 0.0057742967321
L49_50 133 126 3.54027758996e-09
C49_50 133 gnd 5.46737924985e-13F
R49_53 124 134 0.000153874748106
L49_53 134 135 1.0934054912e-10
C49_53 134 gnd 2.77185829026e-13F
R50_51 126 136 0.0057742967321
L50_51 136 130 3.54027758996e-09
C50_51 136 gnd 5.46737924985e-13F
R50_54 126 137 0.00134813854029
L50_54 137 138 8.67449879291e-10
C50_54 137 gnd 5.52736885425e-13F
R51_55 130 139 0.00134813854029
L51_55 139 140 8.67449879291e-10
C51_55 139 gnd 5.52736885425e-13F
R51_52 130 141 0.0057742967321
L51_52 141 132 3.54027758996e-09
C51_52 141 gnd 5.46737924985e-13F
R52_56 132 142 0.000153874748106
L52_56 142 143 1.0934054912e-10
C52_56 142 gnd 2.77185829026e-13F
R53_54 135 144 0.00950620731167
L53_54 144 138 4.27989429243e-09
C53_54 144 gnd 2.83963955719e-13F
R54_55 138 145 0.00950620731167
L54_55 145 140 4.27989429243e-09
C54_55 145 gnd 2.83963955719e-13F
R55_56 140 146 0.00950620731167
L55_56 146 143 4.27989429243e-09
C55_56 146 gnd 2.83963955719e-13F
K0 L1_5 L44_48 0.0703
K1 L1_5 L19_23 0.1442
K2 L1_5 L8_12 0.0638
K3 L1_5 L32_35 0.1071
K4 L1_5 L34_37 0.3086
K5 L1_5 L21_25 0.1046
K6 L1_5 L52_56 0.0664
K7 L1_5 L27_31 0.2994
K8 L1_5 L37_40 0.2357
K9 L1_5 L3_7 0.0975
K10 L1_5 L7_11 0.0969
K11 L1_5 L4_8 0.064
K12 L1_5 L2_6 0.2734
K13 L1_5 L22_26 0.152
K14 L1_5 L36_39 0.1624
K15 L1_5 L43_47 0.0398
K16 L1_5 L50_54 0.051
K17 L1_5 L47_51 0.0371
K18 L1_5 L33_36 0.1787
K19 L1_5 L41_45 0.1606
K20 L1_5 L10_14 0.206
K21 L1_5 L25_29 0.1172
K22 L1_5 L18_22 0.1229
K23 L1_5 L42_46 0.0726
K24 L1_5 L49_53 0.1252
K25 L1_5 L35_38 0.1015
K26 L1_5 L26_30 0.1833
K27 L1_5 L31_34 0.374
K28 L1_5 L6_10 0.2438
K29 L1_5 L30_33 0.1857
K30 L1_5 L51_55 0.0345
K31 L1_5 L48_52 0.0685
K32 L1_5 L45_49 0.1412
K33 L1_5 L17_21 0.0899
K34 L1_5 L46_50 0.06
K35 L1_5 L29_32 0.1092
K36 L1_5 L23_27 0.1986
K37 L1_5 L12_16 0.0632
K38 L1_5 L11_15 0.0949
K39 L23_27 L44_48 0.0462
K40 L23_27 L8_12 0.0431
K41 L23_27 L32_35 0.0972
K42 L23_27 L21_25 0.1836
K43 L23_27 L2_6 0.1015
K44 L23_27 L52_56 0.0437
K45 L23_27 L6_10 0.0946
K46 L23_27 L7_11 0.059
K47 L23_27 L22_26 0.425
K48 L23_27 L20_24 0.2736
K49 L23_27 L4_8 0.0437
K50 L23_27 L36_39 0.1148
K51 L23_27 L43_47 0.0225
K52 L23_27 L50_54 0.0279
K53 L23_27 L47_51 0.0214
K54 L23_27 L5_9 0.1624
K55 L23_27 L17_21 0.1602
K56 L23_27 L33_36 0.14
K57 L23_27 L41_45 0.1057
K58 L23_27 L10_14 0.0876
K59 L23_27 L25_29 0.1602
K60 L23_27 L18_22 0.2863
K61 L23_27 L42_46 0.0345
K62 L23_27 L49_53 0.0832
K63 L23_27 L35_38 0.083
K64 L23_27 L26_30 0.2863
K65 L23_27 L3_7 0.0605
K66 L23_27 L30_33 0.1778
K67 L23_27 L51_55 0.0203
K68 L23_27 L9_13 0.1365
K69 L23_27 L48_52 0.045
K70 L23_27 L45_49 0.0931
K71 L23_27 L1_28 0.2736
K72 L23_27 L24_28 0.451
K73 L23_27 L46_50 0.0309
K74 L23_27 L29_32 0.1153
K75 L23_27 L12_16 0.0423
K76 L23_27 L11_15 0.0573
K77 L13_14 L6_7 0.1984
K78 L13_14 L19_20 0.075
K79 L13_14 L54_55 0.1887
K80 L13_14 L32_33 0.0967
K81 L13_14 L46_47 0.305
K82 L13_14 L21_22 0.0815
K83 L13_14 L7_8 0.094
K84 L13_14 L23_24 0.1046
K85 L13_14 L26_27 0.1112
K86 L13_14 L3_4 0.084
K87 L13_14 L2_3 0.163
K88 L13_14 L1_31 0.1603
K89 L13_14 L55_56 0.0973
K90 L13_14 L50_51 0.2408
K91 L13_14 L5_6 0.3956
K92 L13_14 L22_23 0.093
K93 L13_14 L36_37 0.139
K94 L13_14 L33_34 0.1293
K95 L13_14 L25_26 0.0929
K96 L13_14 L17_18 0.0617
K97 L13_14 L43_44 0.1078
K98 L13_14 L10_11 0.2283
K99 L13_14 L41_42 0.262
K100 L13_14 L35_36 0.1002
K101 L13_14 L42_43 0.3456
K102 L13_14 L49_50 0.2038
K103 L13_14 L53_54 0.1645
K104 L13_14 L5_34 0.1879
K105 L13_14 L47_48 0.1157
K106 L13_14 L27_28 0.1323
K107 L13_14 L9_10 0.6814
K108 L13_14 L51_52 0.111
K109 L13_14 L30_31 0.1236
K110 L13_14 L11_12 0.0955
K111 L13_14 L29_30 0.0975
K112 L13_14 L45_46 0.2445
K113 L13_14 L18_19 0.0686
K114 L13_14 L9_37 0.2372
K115 L13_14 L1_2 0.2765
K116 L23_24 L6_7 0.0867
K117 L23_24 L19_20 0.4511
K118 L23_24 L54_55 0.0696
K119 L23_24 L32_33 0.1024
K120 L23_24 L46_47 0.088
K121 L23_24 L15_16 0.0501
K122 L23_24 L41_42 0.1038
K123 L23_24 L7_8 0.0577
K124 L23_24 L14_15 0.0714
K125 L23_24 L26_27 0.2863
K126 L23_24 L3_4 0.0534
K127 L23_24 L39_40 0.0768
K128 L23_24 L2_3 0.0821
K129 L23_24 L1_31 0.1922
K130 L23_24 L55_56 0.051
K131 L23_24 L50_51 0.0811
K132 L23_24 L5_6 0.1474
K133 L23_24 L43_44 0.0562
K134 L23_24 L36_37 0.1
K135 L23_24 L33_34 0.1206
K136 L23_24 L25_26 0.174
K137 L23_24 L17_18 0.1531
K138 L23_24 L38_39 0.0699
K139 L23_24 L10_11 0.082
K140 L23_24 L35_36 0.0889
K141 L23_24 L42_43 0.0852
K142 L23_24 L49_50 0.0938
K143 L23_24 L1_2 0.1516
K144 L23_24 L53_54 0.0791
K145 L23_24 L5_34 0.129
K146 L23_24 L47_48 0.0601
K147 L23_24 L13_40 0.0795
K148 L23_24 L27_28 0.425
K149 L23_24 L9_10 0.1271
K150 L23_24 L51_52 0.0578
K151 L23_24 L30_31 0.1701
K152 L23_24 L11_12 0.0562
K153 L23_24 L29_30 0.1318
K154 L23_24 L45_46 0.1045
K155 L23_24 L18_19 0.2736
K156 L23_24 L9_37 0.1047
K157 L6_10 L44_48 0.1005
K158 L6_10 L19_23 0.0831
K159 L6_10 L8_12 0.0915
K160 L6_10 L32_35 0.0576
K161 L6_10 L34_37 0.1078
K162 L6_10 L21_25 0.0587
K163 L6_10 L52_56 0.0903
K164 L6_10 L27_31 0.1058
K165 L6_10 L37_40 0.1062
K166 L6_10 L3_7 0.1954
K167 L6_10 L7_11 0.2146
K168 L6_10 L22_26 0.0793
K169 L6_10 L20_24 0.0773
K170 L6_10 L4_8 0.0908
K171 L6_10 L36_39 0.0837
K172 L6_10 L43_47 0.0702
K173 L6_10 L50_54 0.05
K174 L6_10 L47_51 0.0585
K175 L6_10 L5_9 0.2734
K176 L6_10 L17_21 0.0545
K177 L6_10 L33_36 0.0845
K178 L6_10 L41_45 0.1005
K179 L6_10 L25_29 0.0621
K180 L6_10 L18_22 0.0722
K181 L6_10 L42_46 0.0702
K182 L6_10 L49_53 0.0903
K183 L6_10 L35_38 0.0573
K184 L6_10 L26_30 0.0854
K185 L6_10 L31_34 0.1062
K186 L6_10 L30_33 0.0837
K187 L6_10 L51_55 0.05
K188 L6_10 L9_13 0.2438
K189 L6_10 L48_52 0.0956
K190 L6_10 L45_49 0.0956
K191 L6_10 L1_28 0.1067
K192 L6_10 L24_28 0.0912
K193 L6_10 L46_50 0.0585
K194 L6_10 L29_32 0.0573
K195 L6_10 L12_16 0.0908
K196 L6_10 L11_15 0.1954
K197 L1_31 L6_7 0.0924
K198 L1_31 L19_20 0.1132
K199 L1_31 L54_55 0.085
K200 L1_31 L32_33 0.1523
K201 L1_31 L46_47 0.1102
K202 L1_31 L15_16 0.0508
K203 L1_31 L21_22 0.1318
K204 L1_31 L14_15 0.0797
K205 L1_31 L26_27 0.2837
K206 L1_31 L39_40 0.136
K207 L1_31 L55_56 0.0543
K208 L1_31 L50_51 0.1002
K209 L1_31 L5_6 0.255
K210 L1_31 L22_23 0.1701
K211 L1_31 L36_37 0.1953
K212 L1_31 L33_34 0.2764
K213 L1_31 L25_26 0.1674
K214 L1_31 L17_18 0.0909
K215 L1_31 L43_44 0.0588
K216 L1_31 L10_11 0.09
K217 L1_31 L41_42 0.1589
K218 L1_31 L35_36 0.1339
K219 L1_31 L42_43 0.1079
K220 L1_31 L49_50 0.1301
K221 L1_31 L53_54 0.1063
K222 L1_31 L5_34 0.4616
K223 L1_31 L47_48 0.0633
K224 L1_31 L13_40 0.155
K225 L1_31 L27_28 0.4357
K226 L1_31 L9_10 0.2044
K227 L1_31 L51_52 0.0612
K228 L1_31 L38_39 0.1038
K229 L1_31 L11_12 0.0564
K230 L1_31 L45_46 0.1526
K231 L1_31 L18_19 0.1062
K232 L1_31 L9_37 0.242
K233 L1_31 L7_8 0.057
K234 L22_26 L44_48 0.0423
K235 L22_26 L19_23 0.2863
K236 L22_26 L8_12 0.0391
K237 L22_26 L32_35 0.1152
K238 L22_26 L21_25 0.4511
K239 L22_26 L20_24 0.1602
K240 L22_26 L52_56 0.0404
K241 L22_26 L27_31 0.2863
K242 L22_26 L37_40 0.1148
K243 L22_26 L7_11 0.0522
K244 L22_26 L2_6 0.0831
K245 L22_26 L4_8 0.0396
K246 L22_26 L43_47 0.0202
K247 L22_26 L50_54 0.0262
K248 L22_26 L47_51 0.0194
K249 L22_26 L5_9 0.1337
K250 L22_26 L17_21 0.2736
K251 L22_26 L34_37 0.14
K252 L22_26 L41_45 0.1085
K253 L22_26 L10_14 0.0751
K254 L22_26 L25_29 0.2736
K255 L22_26 L42_46 0.0315
K256 L22_26 L49_53 0.0845
K257 L22_26 L35_38 0.0934
K258 L22_26 L31_34 0.1778
K259 L22_26 L3_7 0.0532
K260 L22_26 L51_55 0.0185
K261 L22_26 L9_13 0.118
K262 L22_26 L48_52 0.0414
K263 L22_26 L45_49 0.095
K264 L22_26 L1_28 0.1602
K265 L22_26 L24_28 0.1836
K266 L22_26 L46_50 0.0287
K267 L22_26 L29_32 0.1495
K268 L22_26 L12_16 0.0385
K269 L22_26 L11_15 0.051
K270 L5_6 L19_20 0.1023
K271 L5_6 L54_55 0.1568
K272 L5_6 L46_47 0.2288
K273 L5_6 L15_16 0.094
K274 L5_6 L21_22 0.1027
K275 L5_6 L1_2 0.6814
K276 L5_6 L14_15 0.1984
K277 L5_6 L26_27 0.1482
K278 L5_6 L3_4 0.0955
K279 L5_6 L39_40 0.1233
K280 L5_6 L2_3 0.2283
K281 L5_6 L55_56 0.0971
K282 L5_6 L50_51 0.1931
K283 L5_6 L22_23 0.1233
K284 L5_6 L36_37 0.1503
K285 L5_6 L25_26 0.1155
K286 L5_6 L17_18 0.0778
K287 L5_6 L43_44 0.1109
K288 L5_6 L10_11 0.2421
K289 L5_6 L41_42 0.2035
K290 L5_6 L35_36 0.1092
K291 L5_6 L42_43 0.2405
K292 L5_6 L49_50 0.1731
K293 L5_6 L53_54 0.143
K294 L5_6 L30_31 0.1599
K295 L5_6 L47_48 0.1175
K296 L5_6 L13_40 0.1792
K297 L5_6 L27_28 0.197
K298 L5_6 L9_10 0.6456
K299 L5_6 L51_52 0.1114
K300 L5_6 L38_39 0.0923
K301 L5_6 L11_12 0.1045
K302 L5_6 L29_30 0.1169
K303 L5_6 L45_46 0.1992
K304 L5_6 L18_19 0.0898
K305 L5_6 L9_37 0.2457
K306 L22_23 L6_7 0.0745
K307 L22_23 L19_20 0.2736
K308 L22_23 L54_55 0.0648
K309 L22_23 L32_33 0.1206
K310 L22_23 L46_47 0.0802
K311 L22_23 L15_16 0.0453
K312 L22_23 L41_42 0.1038
K313 L22_23 L7_8 0.0517
K314 L22_23 L14_15 0.0629
K315 L22_23 L26_27 0.425
K316 L22_23 L3_4 0.0477
K317 L22_23 L39_40 0.0795
K318 L22_23 L2_3 0.0698
K319 L22_23 L55_56 0.0471
K320 L22_23 L50_51 0.0749
K321 L22_23 L43_44 0.0511
K322 L22_23 L36_37 0.1047
K323 L22_23 L33_34 0.129
K324 L22_23 L25_26 0.2863
K325 L22_23 L17_18 0.2736
K326 L22_23 L38_39 0.0768
K327 L22_23 L10_11 0.0715
K328 L22_23 L35_36 0.1
K329 L22_23 L42_43 0.0769
K330 L22_23 L49_50 0.0938
K331 L22_23 L1_2 0.122
K332 L22_23 L53_54 0.0791
K333 L22_23 L5_34 0.1206
K334 L22_23 L47_48 0.0549
K335 L22_23 L13_40 0.0768
K336 L22_23 L27_28 0.2863
K337 L22_23 L9_10 0.1106
K338 L22_23 L51_52 0.0531
K339 L22_23 L30_31 0.1922
K340 L22_23 L11_12 0.0507
K341 L22_23 L29_30 0.1701
K342 L22_23 L45_46 0.1045
K343 L22_23 L18_19 0.4511
K344 L22_23 L9_37 0.1
K345 L5_9 L44_48 0.0718
K346 L5_9 L19_23 0.123
K347 L5_9 L8_12 0.064
K348 L5_9 L32_35 0.1092
K349 L5_9 L34_37 0.374
K350 L5_9 L21_25 0.0957
K351 L5_9 L52_56 0.0685
K352 L5_9 L27_31 0.2312
K353 L5_9 L37_40 0.3086
K354 L5_9 L3_7 0.0969
K355 L5_9 L7_11 0.0975
K356 L5_9 L4_8 0.0638
K357 L5_9 L2_6 0.2438
K358 L5_9 L36_39 0.1787
K359 L5_9 L43_47 0.0426
K360 L5_9 L50_54 0.06
K361 L5_9 L47_51 0.0398
K362 L5_9 L33_36 0.1857
K363 L5_9 L41_45 0.1839
K364 L5_9 L10_14 0.2438
K365 L5_9 L25_29 0.1102
K366 L5_9 L18_22 0.1089
K367 L5_9 L42_46 0.0914
K368 L5_9 L49_53 0.1412
K369 L5_9 L35_38 0.1071
K370 L5_9 L26_30 0.165
K371 L5_9 L31_34 0.3086
K372 L5_9 L30_33 0.1787
K373 L5_9 L51_55 0.0371
K374 L5_9 L48_52 0.0703
K375 L5_9 L45_49 0.1606
K376 L5_9 L17_21 0.0817
K377 L5_9 L46_50 0.0726
K378 L5_9 L29_32 0.1071
K379 L5_9 L12_16 0.0638
K380 L5_9 L11_15 0.0969
K381 L34_37 L44_48 0.0474
K382 L34_37 L8_12 0.0421
K383 L34_37 L32_35 0.159
K384 L34_37 L21_25 0.1024
K385 L34_37 L2_6 0.1062
K386 L34_37 L52_56 0.0458
K387 L34_37 L7_11 0.0593
K388 L34_37 L20_24 0.0872
K389 L34_37 L4_8 0.042
K390 L34_37 L36_39 0.3186
K391 L34_37 L43_47 0.0254
K392 L34_37 L50_54 0.0423
K393 L34_37 L47_51 0.0245
K394 L34_37 L17_21 0.0793
K395 L34_37 L33_36 0.4133
K396 L34_37 L41_45 0.2088
K397 L34_37 L10_14 0.1062
K398 L34_37 L25_29 0.1363
K399 L34_37 L18_22 0.1024
K400 L34_37 L42_46 0.0595
K401 L34_37 L49_53 0.1357
K402 L34_37 L35_38 0.1497
K403 L34_37 L26_30 0.2148
K404 L34_37 L3_7 0.0591
K405 L34_37 L30_33 0.3186
K406 L34_37 L51_55 0.0234
K407 L34_37 L9_13 0.3086
K408 L34_37 L48_52 0.0467
K409 L34_37 L45_49 0.1649
K410 L34_37 L1_28 0.1951
K411 L34_37 L24_28 0.1213
K412 L34_37 L46_50 0.0495
K413 L34_37 L29_32 0.1497
K414 L34_37 L12_16 0.042
K415 L34_37 L11_15 0.0591
K416 L41_45 L44_48 0.0552
K417 L41_45 L19_23 0.0862
K418 L41_45 L8_12 0.0475
K419 L41_45 L2_6 0.0956
K420 L41_45 L27_31 0.1359
K421 L41_45 L7_11 0.064
K422 L41_45 L20_24 0.0696
K423 L41_45 L4_8 0.0469
K424 L41_45 L36_39 0.3334
K425 L41_45 L43_47 0.0288
K426 L41_45 L50_54 0.0689
K427 L41_45 L47_51 0.0287
K428 L41_45 L33_36 0.2312
K429 L41_45 L52_56 0.0548
K430 L41_45 L10_14 0.1045
K431 L41_45 L18_22 0.0878
K432 L41_45 L42_46 0.0883
K433 L41_45 L26_30 0.1418
K434 L41_45 L31_34 0.1649
K435 L41_45 L3_7 0.0627
K436 L41_45 L30_33 0.1763
K437 L41_45 L51_55 0.0283
K438 L41_45 L9_13 0.2106
K439 L41_45 L48_52 0.0551
K440 L41_45 L1_28 0.105
K441 L41_45 L24_28 0.084
K442 L41_45 L46_50 0.0798
K443 L41_45 L37_40 0.2818
K444 L41_45 L12_16 0.0479
K445 L41_45 L11_15 0.0649
K446 L43_44 L6_7 0.2035
K447 L43_44 L19_20 0.0447
K448 L43_44 L54_55 0.1656
K449 L43_44 L32_33 0.0446
K450 L43_44 L46_47 0.2191
K451 L43_44 L15_16 0.4029
K452 L43_44 L21_22 0.0467
K453 L43_44 L7_8 0.2638
K454 L43_44 L14_15 0.262
K455 L43_44 L26_27 0.0537
K456 L43_44 L3_4 0.2035
K457 L43_44 L39_40 0.0442
K458 L43_44 L2_3 0.1645
K459 L43_44 L55_56 0.3169
K460 L43_44 L50_51 0.1969
K461 L43_44 L36_37 0.0505
K462 L43_44 L33_34 0.0498
K463 L43_44 L25_26 0.0487
K464 L43_44 L17_18 0.0378
K465 L43_44 L38_39 0.0394
K466 L43_44 L10_11 0.2442
K467 L43_44 L35_36 0.0451
K468 L43_44 L49_50 0.0886
K469 L43_44 L1_2 0.0973
K470 L43_44 L53_54 0.0797
K471 L43_44 L5_34 0.0562
K472 L43_44 L47_48 0.7235
K473 L43_44 L13_40 0.0503
K474 L43_44 L27_28 0.0597
K475 L43_44 L9_10 0.1155
K476 L43_44 L51_52 0.4429
K477 L43_44 L30_31 0.0524
K478 L43_44 L11_12 0.3443
K479 L43_44 L29_30 0.0472
K480 L43_44 L45_46 0.0894
K481 L43_44 L18_19 0.041
K482 L43_44 L9_37 0.0573
K483 L53_54 L6_7 0.0971
K484 L53_54 L19_20 0.0589
K485 L53_54 L32_33 0.1105
K486 L53_54 L46_47 0.1969
K487 L53_54 L15_16 0.0648
K488 L53_54 L21_22 0.0773
K489 L53_54 L7_8 0.0682
K490 L53_54 L14_15 0.0973
K491 L53_54 L26_27 0.0941
K492 L53_54 L3_4 0.0608
K493 L53_54 L39_40 0.1387
K494 L53_54 L2_3 0.0846
K495 L53_54 L51_52 0.0894
K496 L53_54 L50_51 0.219
K497 L53_54 L36_37 0.1383
K498 L53_54 L33_34 0.1167
K499 L53_54 L25_26 0.0911
K500 L53_54 L17_18 0.0578
K501 L53_54 L38_39 0.1275
K502 L53_54 L10_11 0.1027
K503 L53_54 L41_42 0.3169
K504 L53_54 L35_36 0.1289
K505 L53_54 L42_43 0.1656
K506 L53_54 L49_50 0.7235
K507 L53_54 L1_2 0.1192
K508 L53_54 L5_34 0.1167
K509 L53_54 L47_48 0.0886
K510 L53_54 L13_40 0.1387
K511 L53_54 L27_28 0.0941
K512 L53_54 L9_10 0.1626
K513 L53_54 L30_31 0.1063
K514 L53_54 L11_12 0.0699
K515 L53_54 L29_30 0.1019
K516 L53_54 L45_46 0.4429
K517 L53_54 L18_19 0.0589
K518 L53_54 L9_37 0.1383
K519 L26_30 L44_48 0.0437
K520 L26_30 L19_23 0.174
K521 L26_30 L8_12 0.0398
K522 L26_30 L32_35 0.1853
K523 L26_30 L21_25 0.2736
K524 L26_30 L20_24 0.1215
K525 L26_30 L52_56 0.042
K526 L26_30 L27_31 0.425
K527 L26_30 L37_40 0.1633
K528 L26_30 L7_11 0.0537
K529 L26_30 L2_6 0.0878
K530 L26_30 L4_8 0.04
K531 L26_30 L43_47 0.0215
K532 L26_30 L50_54 0.0305
K533 L26_30 L47_51 0.0207
K534 L26_30 L17_21 0.1531
K535 L26_30 L10_14 0.0819
K536 L26_30 L25_29 0.4511
K537 L26_30 L42_46 0.0376
K538 L26_30 L49_53 0.1036
K539 L26_30 L35_38 0.1361
K540 L26_30 L31_34 0.3012
K541 L26_30 L3_7 0.0543
K542 L26_30 L51_55 0.0199
K543 L26_30 L9_13 0.1456
K544 L26_30 L48_52 0.0429
K545 L26_30 L45_49 0.1197
K546 L26_30 L1_28 0.1836
K547 L26_30 L24_28 0.1602
K548 L26_30 L46_50 0.0337
K549 L26_30 L29_32 0.2793
K550 L26_30 L12_16 0.0394
K551 L26_30 L11_15 0.0529
K552 L31_34 L44_48 0.0467
K553 L31_34 L8_12 0.042
K554 L31_34 L32_35 0.1497
K555 L31_34 L21_25 0.1214
K556 L31_34 L2_6 0.1078
K557 L31_34 L52_56 0.0448
K558 L31_34 L7_11 0.0591
K559 L31_34 L20_24 0.105
K560 L31_34 L4_8 0.0421
K561 L31_34 L36_39 0.2229
K562 L31_34 L43_47 0.0245
K563 L31_34 L50_54 0.0369
K564 L31_34 L47_51 0.0234
K565 L31_34 L17_21 0.092
K566 L31_34 L33_36 0.3186
K567 L31_34 L10_14 0.102
K568 L31_34 L25_29 0.1592
K569 L31_34 L18_22 0.1222
K570 L31_34 L42_46 0.0495
K571 L31_34 L49_53 0.1151
K572 L31_34 L35_38 0.1295
K573 L31_34 L3_7 0.0593
K574 L31_34 L30_33 0.4133
K575 L31_34 L51_55 0.0224
K576 L31_34 L9_13 0.2357
K577 L31_34 L48_52 0.0458
K578 L31_34 L45_49 0.1357
K579 L31_34 L1_28 0.294
K580 L31_34 L24_28 0.1575
K581 L31_34 L46_50 0.0423
K582 L31_34 L29_32 0.159
K583 L31_34 L12_16 0.0418
K584 L31_34 L11_15 0.0584
K585 L30_31 L6_7 0.0765
K586 L30_31 L19_20 0.1062
K587 L30_31 L54_55 0.0759
K588 L30_31 L32_33 0.2764
K589 L30_31 L46_47 0.0946
K590 L30_31 L15_16 0.0453
K591 L30_31 L21_22 0.1701
K592 L30_31 L14_15 0.0671
K593 L30_31 L26_27 0.4357
K594 L30_31 L39_40 0.155
K595 L30_31 L55_56 0.0491
K596 L30_31 L50_51 0.0881
K597 L30_31 L36_37 0.242
K598 L30_31 L33_34 0.4616
K599 L30_31 L25_26 0.2837
K600 L30_31 L17_18 0.1062
K601 L30_31 L10_11 0.0751
K602 L30_31 L41_42 0.1589
K603 L30_31 L35_36 0.1953
K604 L30_31 L42_43 0.0907
K605 L30_31 L49_50 0.1301
K606 L30_31 L5_34 0.2764
K607 L30_31 L47_48 0.0566
K608 L30_31 L13_40 0.136
K609 L30_31 L27_28 0.2837
K610 L30_31 L9_10 0.1468
K611 L30_31 L51_52 0.0552
K612 L30_31 L38_39 0.136
K613 L30_31 L11_12 0.0502
K614 L30_31 L45_46 0.1526
K615 L30_31 L18_19 0.1132
K616 L30_31 L9_37 0.1953
K617 L30_31 L7_8 0.0506
K618 L30_33 L44_48 0.0423
K619 L30_33 L19_23 0.1222
K620 L30_33 L8_12 0.0379
K621 L30_33 L32_35 0.3028
K622 L30_33 L21_25 0.1575
K623 L30_33 L20_24 0.092
K624 L30_33 L52_56 0.0409
K625 L30_33 L27_31 0.3012
K626 L30_33 L37_40 0.2229
K627 L30_33 L7_11 0.0515
K628 L30_33 L2_6 0.0845
K629 L30_33 L4_8 0.038
K630 L30_33 L43_47 0.0212
K631 L30_33 L50_54 0.033
K632 L30_33 L47_51 0.0206
K633 L30_33 L17_21 0.105
K634 L30_33 L10_14 0.0817
K635 L30_33 L25_29 0.294
K636 L30_33 L42_46 0.0415
K637 L30_33 L49_53 0.119
K638 L30_33 L35_38 0.1946
K639 L30_33 L3_7 0.0517
K640 L30_33 L51_55 0.0198
K641 L30_33 L9_13 0.1624
K642 L30_33 L48_52 0.0416
K643 L30_33 L45_49 0.1422
K644 L30_33 L1_28 0.1592
K645 L30_33 L24_28 0.1214
K646 L30_33 L46_50 0.0369
K647 L30_33 L29_32 0.4274
K648 L30_33 L12_16 0.0377
K649 L30_33 L11_15 0.0511
K650 L36_37 L6_7 0.0712
K651 L36_37 L19_20 0.0684
K652 L36_37 L54_55 0.0823
K653 L36_37 L32_33 0.2718
K654 L36_37 L15_16 0.0429
K655 L36_37 L21_22 0.1
K656 L36_37 L7_8 0.047
K657 L36_37 L14_15 0.065
K658 L36_37 L26_27 0.1528
K659 L36_37 L3_4 0.0426
K660 L36_37 L39_40 0.5122
K661 L36_37 L2_3 0.0641
K662 L36_37 L55_56 0.0483
K663 L36_37 L50_51 0.0953
K664 L36_37 L46_47 0.1016
K665 L36_37 L33_34 0.4781
K666 L36_37 L25_26 0.1393
K667 L36_37 L17_18 0.0684
K668 L36_37 L38_39 0.259
K669 L36_37 L41_42 0.2498
K670 L36_37 L42_43 0.0963
K671 L36_37 L49_50 0.1765
K672 L36_37 L1_2 0.1293
K673 L36_37 L5_34 0.2718
K674 L36_37 L47_48 0.0549
K675 L36_37 L13_40 0.259
K676 L36_37 L27_28 0.1393
K677 L36_37 L51_52 0.0539
K678 L36_37 L29_30 0.1953
K679 L36_37 L45_46 0.2229
K680 L36_37 L18_19 0.0705
K681 L17_21 L44_48 0.0321
K682 L17_21 L19_23 0.1836
K683 L17_21 L8_12 0.0298
K684 L17_21 L2_6 0.0571
K685 L17_21 L27_31 0.1215
K686 L17_21 L7_11 0.0386
K687 L17_21 L20_24 0.106
K688 L17_21 L4_8 0.0303
K689 L17_21 L36_39 0.0745
K690 L17_21 L43_47 0.0147
K691 L17_21 L50_54 0.0183
K692 L17_21 L47_51 0.0141
K693 L17_21 L33_36 0.0872
K694 L17_21 L52_56 0.0306
K695 L17_21 L10_14 0.0519
K696 L17_21 L18_22 0.4511
K697 L17_21 L42_46 0.0212
K698 L17_21 L3_7 0.0395
K699 L17_21 L51_55 0.0136
K700 L17_21 L9_13 0.0744
K701 L17_21 L48_52 0.0314
K702 L17_21 L1_28 0.0835
K703 L17_21 L24_28 0.0988
K704 L17_21 L46_50 0.0196
K705 L17_21 L37_40 0.0694
K706 L17_21 L12_16 0.0293
K707 L17_21 L11_15 0.0377
K708 L46_50 L44_48 0.0287
K709 L46_50 L19_23 0.0262
K710 L46_50 L8_12 0.0234
K711 L46_50 L32_35 0.0284
K712 L46_50 L21_25 0.0224
K713 L46_50 L2_6 0.05
K714 L46_50 L52_56 0.0287
K715 L46_50 L27_31 0.0375
K716 L46_50 L37_40 0.0595
K717 L46_50 L7_11 0.0347
K718 L46_50 L20_24 0.0226
K719 L46_50 L4_8 0.0227
K720 L46_50 L36_39 0.0469
K721 L46_50 L43_47 0.0215
K722 L46_50 L47_51 0.0231
K723 L46_50 L33_36 0.0415
K724 L46_50 L10_14 0.0702
K725 L46_50 L25_29 0.0257
K726 L46_50 L18_22 0.0248
K727 L46_50 L49_53 0.0798
K728 L46_50 L35_38 0.031
K729 L46_50 L3_7 0.0326
K730 L46_50 L51_55 0.0215
K731 L46_50 L9_13 0.0914
K732 L46_50 L48_52 0.0288
K733 L46_50 L45_49 0.0883
K734 L46_50 L1_28 0.0332
K735 L46_50 L24_28 0.0269
K736 L46_50 L29_32 0.026
K737 L46_50 L12_16 0.024
K738 L46_50 L11_15 0.0368
K739 L1_2 L6_7 0.2283
K740 L1_2 L19_20 0.1034
K741 L1_2 L54_55 0.1289
K742 L1_2 L32_33 0.1002
K743 L1_2 L46_47 0.1827
K744 L1_2 L15_16 0.084
K745 L1_2 L21_22 0.0989
K746 L1_2 L14_15 0.163
K747 L1_2 L26_27 0.1455
K748 L1_2 L39_40 0.1042
K749 L1_2 L55_56 0.0846
K750 L1_2 L50_51 0.157
K751 L1_2 L33_34 0.139
K752 L1_2 L25_26 0.1097
K753 L1_2 L17_18 0.0751
K754 L1_2 L10_11 0.1984
K755 L1_2 L41_42 0.1645
K756 L1_2 L35_36 0.0967
K757 L1_2 L42_43 0.1887
K758 L1_2 L49_50 0.1432
K759 L1_2 L5_34 0.2372
K760 L1_2 L47_48 0.1028
K761 L1_2 L13_40 0.1395
K762 L1_2 L27_28 0.2086
K763 L1_2 L9_10 0.3956
K764 L1_2 L51_52 0.0972
K765 L1_2 L38_39 0.0807
K766 L1_2 L11_12 0.094
K767 L1_2 L45_46 0.1628
K768 L1_2 L18_19 0.0886
K769 L1_2 L9_37 0.1879
K770 L1_2 L7_8 0.0955
K771 L19_23 L44_48 0.0442
K772 L19_23 L8_12 0.0418
K773 L19_23 L32_35 0.0753
K774 L19_23 L21_25 0.1602
K775 L19_23 L2_6 0.0899
K776 L19_23 L52_56 0.0415
K777 L19_23 L7_11 0.056
K778 L19_23 L20_24 0.451
K779 L19_23 L4_8 0.0426
K780 L19_23 L36_39 0.0879
K781 L19_23 L43_47 0.0206
K782 L19_23 L50_54 0.024
K783 L19_23 L47_51 0.0196
K784 L19_23 L33_36 0.1024
K785 L19_23 L10_14 0.0768
K786 L19_23 L25_29 0.1215
K787 L19_23 L18_22 0.425
K788 L19_23 L42_46 0.0289
K789 L19_23 L49_53 0.0706
K790 L19_23 L35_38 0.0659
K791 L19_23 L3_7 0.0579
K792 L19_23 L51_55 0.0186
K793 L19_23 L9_13 0.107
K794 L19_23 L48_52 0.0429
K795 L19_23 L45_49 0.0776
K796 L19_23 L1_28 0.1531
K797 L19_23 L24_28 0.2736
K798 L19_23 L29_32 0.0874
K799 L19_23 L12_16 0.0408
K800 L19_23 L11_15 0.0539
K801 L19_20 L6_7 0.0675
K802 L19_20 L32_33 0.0716
K803 L19_20 L46_47 0.0664
K804 L19_20 L15_16 0.0403
K805 L19_20 L21_22 0.1531
K806 L19_20 L7_8 0.0466
K807 L19_20 L14_15 0.0552
K808 L19_20 L26_27 0.1602
K809 L19_20 L3_4 0.0433
K810 L19_20 L39_40 0.0536
K811 L19_20 L2_3 0.0642
K812 L19_20 L51_52 0.0458
K813 L19_20 L55_56 0.0404
K814 L19_20 L50_51 0.0616
K815 L19_20 L33_34 0.0797
K816 L19_20 L25_26 0.1215
K817 L19_20 L38_39 0.0501
K818 L19_20 L10_11 0.0635
K819 L19_20 L41_42 0.0749
K820 L19_20 L35_36 0.063
K821 L19_20 L42_43 0.064
K822 L19_20 L49_50 0.0693
K823 L19_20 L5_34 0.083
K824 L19_20 L47_48 0.0477
K825 L19_20 L13_40 0.0549
K826 L19_20 L27_28 0.1836
K827 L19_20 L9_10 0.09
K828 L19_20 L11_12 0.0453
K829 L19_20 L29_30 0.0909
K830 L19_20 L45_46 0.0762
K831 L19_20 L54_55 0.0531
K832 L19_20 L9_37 0.0705
K833 L8_12 L32_35 0.0281
K834 L8_12 L21_25 0.0305
K835 L8_12 L2_6 0.0908
K836 L8_12 L27_31 0.044
K837 L8_12 L37_40 0.042
K838 L8_12 L3_7 0.2414
K839 L8_12 L7_11 0.2756
K840 L8_12 L20_24 0.0375
K841 L8_12 L36_39 0.0379
K842 L8_12 L43_47 0.0504
K843 L8_12 L50_54 0.0227
K844 L8_12 L47_51 0.045
K845 L8_12 L33_36 0.038
K846 L8_12 L10_14 0.0908
K847 L8_12 L25_29 0.031
K848 L8_12 L18_22 0.0381
K849 L8_12 L42_46 0.024
K850 L8_12 L49_53 0.0463
K851 L8_12 L35_38 0.028
K852 L8_12 L51_55 0.0403
K853 L8_12 L9_13 0.0638
K854 L8_12 L45_49 0.0469
K855 L8_12 L1_28 0.0399
K856 L8_12 L24_28 0.0389
K857 L8_12 L29_32 0.028
K858 L8_12 L11_15 0.2414
K859 L37_40 L44_48 0.0479
K860 L37_40 L32_35 0.1497
K861 L37_40 L21_25 0.0874
K862 L37_40 L2_6 0.102
K863 L37_40 L52_56 0.0467
K864 L37_40 L7_11 0.0591
K865 L37_40 L20_24 0.0745
K866 L37_40 L4_8 0.0418
K867 L37_40 L36_39 0.4133
K868 L37_40 L43_47 0.0261
K869 L37_40 L50_54 0.0495
K870 L37_40 L47_51 0.0254
K871 L37_40 L33_36 0.3186
K872 L37_40 L10_14 0.1078
K873 L37_40 L25_29 0.1146
K874 L37_40 L18_22 0.0879
K875 L37_40 L42_46 0.0746
K876 L37_40 L49_53 0.1649
K877 L37_40 L35_38 0.159
K878 L37_40 L3_7 0.0584
K879 L37_40 L51_55 0.0245
K880 L37_40 L9_13 0.374
K881 L37_40 L48_52 0.0474
K882 L37_40 L45_49 0.2088
K883 L37_40 L1_28 0.1433
K884 L37_40 L24_28 0.0983
K885 L37_40 L29_32 0.1295
K886 L37_40 L12_16 0.0421
K887 L37_40 L11_15 0.0593
K888 L26_27 L6_7 0.0788
K889 L26_27 L54_55 0.0725
K890 L26_27 L32_33 0.1799
K891 L26_27 L46_47 0.0903
K892 L26_27 L15_16 0.047
K893 L26_27 L21_22 0.2863
K894 L26_27 L7_8 0.053
K895 L26_27 L14_15 0.0676
K896 L26_27 L3_4 0.0487
K897 L26_27 L39_40 0.1096
K898 L26_27 L2_3 0.0731
K899 L26_27 L55_56 0.0498
K900 L26_27 L50_51 0.0841
K901 L26_27 L33_34 0.2112
K902 L26_27 L41_42 0.1306
K903 L26_27 L17_18 0.1602
K904 L26_27 L38_39 0.1027
K905 L26_27 L10_11 0.0764
K906 L26_27 L35_36 0.1393
K907 L26_27 L42_43 0.0867
K908 L26_27 L49_50 0.1131
K909 L26_27 L5_34 0.1799
K910 L26_27 L51_52 0.0561
K911 L26_27 L13_40 0.1027
K912 L26_27 L47_48 0.0578
K913 L26_27 L9_10 0.1328
K914 L26_27 L11_12 0.0523
K915 L26_27 L29_30 0.2837
K916 L26_27 L45_46 0.1289
K917 L26_27 L18_19 0.1836
K918 L26_27 L9_37 0.1393
K919 L7_11 L44_48 0.1985
K920 L7_11 L32_35 0.0374
K921 L7_11 L21_25 0.04
K922 L7_11 L2_6 0.1954
K923 L7_11 L52_56 0.1427
K924 L7_11 L27_31 0.0613
K925 L7_11 L20_24 0.0511
K926 L7_11 L4_8 0.2414
K927 L7_11 L36_39 0.0515
K928 L7_11 L43_47 0.081
K929 L7_11 L50_54 0.0326
K930 L7_11 L47_51 0.0653
K931 L7_11 L33_36 0.0517
K932 L7_11 L10_14 0.1954
K933 L7_11 L25_29 0.041
K934 L7_11 L18_22 0.05
K935 L7_11 L42_46 0.0368
K936 L7_11 L49_53 0.0612
K937 L7_11 L35_38 0.0373
K938 L7_11 L51_55 0.0545
K939 L7_11 L9_13 0.0969
K940 L7_11 L48_52 0.1665
K941 L7_11 L45_49 0.0627
K942 L7_11 L24_28 0.0545
K943 L7_11 L29_32 0.0373
K944 L7_11 L12_16 0.2414
K945 L7_11 L1_28 0.0572
K946 L20_24 L44_48 0.0393
K947 L20_24 L32_35 0.0569
K948 L20_24 L21_25 0.0988
K949 L20_24 L52_56 0.0367
K950 L20_24 L27_31 0.1531
K951 L20_24 L3_7 0.0532
K952 L20_24 L4_8 0.0384
K953 L20_24 L2_6 0.0853
K954 L20_24 L36_39 0.0694
K955 L20_24 L43_47 0.0185
K956 L20_24 L50_54 0.0206
K957 L20_24 L47_51 0.0174
K958 L20_24 L33_36 0.0793
K959 L20_24 L10_14 0.0702
K960 L20_24 L25_29 0.0835
K961 L20_24 L18_22 0.1836
K962 L20_24 L42_46 0.025
K963 L20_24 L49_53 0.0576
K964 L20_24 L35_38 0.0509
K965 L20_24 L51_55 0.0164
K966 L20_24 L48_52 0.038
K967 L20_24 L45_49 0.0631
K968 L20_24 L29_32 0.064
K969 L20_24 L12_16 0.0366
K970 L20_24 L11_15 0.0489
K971 L43_47 L44_48 0.0883
K972 L43_47 L32_35 0.0156
K973 L43_47 L21_25 0.0156
K974 L43_47 L2_6 0.0585
K975 L43_47 L52_56 0.0689
K976 L43_47 L27_31 0.0244
K977 L43_47 L4_8 0.045
K978 L43_47 L36_39 0.0223
K979 L43_47 L50_54 0.0194
K980 L43_47 L33_36 0.0218
K981 L43_47 L10_14 0.0881
K982 L43_47 L25_29 0.0164
K983 L43_47 L18_22 0.0188
K984 L43_47 L42_46 0.0231
K985 L43_47 L49_53 0.0283
K986 L43_47 L35_38 0.0159
K987 L43_47 L3_7 0.0653
K988 L43_47 L9_13 0.0451
K989 L43_47 L48_52 0.0798
K990 L43_47 L45_49 0.0287
K991 L43_47 L1_28 0.0226
K992 L43_47 L24_28 0.0204
K993 L43_47 L29_32 0.0153
K994 L43_47 L12_16 0.0564
K995 L43_47 L11_15 0.1067
K996 L46_47 L6_7 0.2288
K997 L46_47 L54_55 0.4429
K998 L46_47 L32_33 0.0805
K999 L46_47 L15_16 0.1433
K1000 L46_47 L21_22 0.0728
K1001 L46_47 L7_8 0.1393
K1002 L46_47 L14_15 0.305
K1003 L46_47 L3_4 0.1199
K1004 L46_47 L39_40 0.092
K1005 L46_47 L2_3 0.1827
K1006 L46_47 L55_56 0.1969
K1007 L46_47 L50_51 0.6955
K1008 L46_47 L33_34 0.0953
K1009 L46_47 L25_26 0.08
K1010 L46_47 L17_18 0.0566
K1011 L46_47 L38_39 0.075
K1012 L46_47 L10_11 0.28
K1013 L46_47 L41_42 0.2191
K1014 L46_47 L35_36 0.0841
K1015 L46_47 L42_43 0.7235
K1016 L46_47 L49_50 0.2346
K1017 L46_47 L5_34 0.1148
K1018 L46_47 L51_52 0.2346
K1019 L46_47 L13_40 0.1182
K1020 L46_47 L27_28 0.1017
K1021 L46_47 L9_10 0.28
K1022 L46_47 L11_12 0.1497
K1023 L46_47 L29_30 0.0818
K1024 L46_47 L18_19 0.0615
K1025 L46_47 L9_37 0.1268
K1026 L33_34 L54_55 0.0766
K1027 L33_34 L15_16 0.0426
K1028 L33_34 L21_22 0.1206
K1029 L33_34 L14_15 0.0641
K1030 L33_34 L3_4 0.0429
K1031 L33_34 L39_40 0.2331
K1032 L33_34 L2_3 0.065
K1033 L33_34 L55_56 0.0471
K1034 L33_34 L50_51 0.0889
K1035 L33_34 L25_26 0.1799
K1036 L33_34 L17_18 0.0797
K1037 L33_34 L10_11 0.0712
K1038 L33_34 L41_42 0.1896
K1039 L33_34 L35_36 0.2718
K1040 L33_34 L42_43 0.091
K1041 L33_34 L49_50 0.1456
K1042 L33_34 L47_48 0.0539
K1043 L33_34 L13_40 0.1784
K1044 L33_34 L27_28 0.1799
K1045 L33_34 L9_10 0.1503
K1046 L33_34 L51_52 0.0528
K1047 L33_34 L38_39 0.1784
K1048 L33_34 L11_12 0.047
K1049 L33_34 L29_30 0.2764
K1050 L33_34 L45_46 0.1765
K1051 L33_34 L18_19 0.083
K1052 L33_34 L9_37 0.2718
K1053 L33_36 L44_48 0.0428
K1054 L33_36 L32_35 0.4274
K1055 L33_36 L21_25 0.1213
K1056 L33_36 L52_56 0.0416
K1057 L33_36 L27_31 0.2148
K1058 L33_36 L2_6 0.0837
K1059 L33_36 L4_8 0.0379
K1060 L33_36 L50_54 0.0369
K1061 L33_36 L47_51 0.0212
K1062 L33_36 L10_14 0.0837
K1063 L33_36 L25_29 0.1951
K1064 L33_36 L42_46 0.0469
K1065 L33_36 L49_53 0.1422
K1066 L33_36 L35_38 0.3028
K1067 L33_36 L3_7 0.0515
K1068 L33_36 L51_55 0.0206
K1069 L33_36 L9_13 0.1787
K1070 L33_36 L48_52 0.0423
K1071 L33_36 L45_49 0.1763
K1072 L33_36 L1_28 0.1363
K1073 L33_36 L24_28 0.1024
K1074 L33_36 L29_32 0.3028
K1075 L33_36 L12_16 0.0379
K1076 L33_36 L11_15 0.0515
K1077 L18_22 L44_48 0.0407
K1078 L18_22 L32_35 0.0828
K1079 L18_22 L21_25 0.2736
K1080 L18_22 L52_56 0.0386
K1081 L18_22 L27_31 0.174
K1082 L18_22 L2_6 0.0765
K1083 L18_22 L4_8 0.0387
K1084 L18_22 L50_54 0.0229
K1085 L18_22 L47_51 0.018
K1086 L18_22 L10_14 0.068
K1087 L18_22 L25_29 0.1531
K1088 L18_22 L42_46 0.027
K1089 L18_22 L49_53 0.0714
K1090 L18_22 L35_38 0.0708
K1091 L18_22 L3_7 0.0514
K1092 L18_22 L51_55 0.0172
K1093 L18_22 L9_13 0.0972
K1094 L18_22 L48_52 0.0397
K1095 L18_22 L45_49 0.0787
K1096 L18_22 L1_28 0.1215
K1097 L18_22 L24_28 0.1602
K1098 L18_22 L29_32 0.0997
K1099 L18_22 L12_16 0.0374
K1100 L18_22 L11_15 0.0486
K1101 L51_52 L6_7 0.1731
K1102 L51_52 L54_55 0.219
K1103 L51_52 L32_33 0.0476
K1104 L51_52 L15_16 0.2641
K1105 L51_52 L21_22 0.049
K1106 L51_52 L7_8 0.2049
K1107 L51_52 L14_15 0.2038
K1108 L51_52 L3_4 0.1651
K1109 L51_52 L39_40 0.0475
K1110 L51_52 L2_3 0.1432
K1111 L51_52 L55_56 0.7235
K1112 L51_52 L25_26 0.0513
K1113 L51_52 L17_18 0.0394
K1114 L51_52 L38_39 0.0426
K1115 L51_52 L10_11 0.1992
K1116 L51_52 L41_42 0.0886
K1117 L51_52 L35_36 0.0485
K1118 L51_52 L42_43 0.1969
K1119 L51_52 L5_34 0.059
K1120 L51_52 L47_48 0.6955
K1121 L51_52 L13_40 0.0537
K1122 L51_52 L27_28 0.0616
K1123 L51_52 L9_10 0.1175
K1124 L51_52 L11_12 0.2469
K1125 L51_52 L29_30 0.0501
K1126 L51_52 L45_46 0.0981
K1127 L51_52 L18_19 0.0425
K1128 L51_52 L9_37 0.0607
K1129 L51_55 L44_48 0.0689
K1130 L51_55 L32_35 0.0149
K1131 L51_55 L21_25 0.0145
K1132 L51_55 L2_6 0.0436
K1133 L51_55 L52_56 0.0883
K1134 L51_55 L27_31 0.0221
K1135 L51_55 L4_8 0.0363
K1136 L51_55 L36_39 0.0212
K1137 L51_55 L50_54 0.0231
K1138 L51_55 L10_14 0.0585
K1139 L51_55 L25_29 0.0154
K1140 L51_55 L42_46 0.0194
K1141 L51_55 L49_53 0.0288
K1142 L51_55 L35_38 0.0153
K1143 L51_55 L3_7 0.0467
K1144 L51_55 L9_13 0.0398
K1145 L51_55 L48_52 0.0798
K1146 L51_55 L45_49 0.0287
K1147 L51_55 L1_28 0.02
K1148 L51_55 L24_28 0.0181
K1149 L51_55 L29_32 0.0145
K1150 L51_55 L12_16 0.045
K1151 L51_55 L11_15 0.0653
K1152 L27_28 L6_7 0.0938
K1153 L27_28 L54_55 0.0794
K1154 L27_28 L32_33 0.1321
K1155 L27_28 L15_16 0.0524
K1156 L27_28 L21_22 0.174
K1157 L27_28 L7_8 0.0595
K1158 L27_28 L14_15 0.0786
K1159 L27_28 L3_4 0.0548
K1160 L27_28 L39_40 0.1027
K1161 L27_28 L2_3 0.0878
K1162 L27_28 L55_56 0.0545
K1163 L27_28 L50_51 0.0931
K1164 L27_28 L41_42 0.1306
K1165 L27_28 L17_18 0.1215
K1166 L27_28 L38_39 0.0878
K1167 L27_28 L10_11 0.0898
K1168 L27_28 L35_36 0.1132
K1169 L27_28 L42_43 0.0991
K1170 L27_28 L49_50 0.1131
K1171 L27_28 L5_34 0.2112
K1172 L27_28 L13_40 0.1096
K1173 L27_28 L47_48 0.0639
K1174 L27_28 L9_10 0.1644
K1175 L27_28 L11_12 0.0585
K1176 L27_28 L29_30 0.1674
K1177 L27_28 L45_46 0.1289
K1178 L27_28 L18_19 0.1602
K1179 L27_28 L9_37 0.1528
K1180 L48_52 L32_35 0.0313
K1181 L48_52 L21_25 0.0325
K1182 L48_52 L2_6 0.0903
K1183 L48_52 L27_31 0.047
K1184 L48_52 L3_7 0.1427
K1185 L48_52 L36_39 0.0428
K1186 L48_52 L50_54 0.0287
K1187 L48_52 L47_51 0.0883
K1188 L48_52 L10_14 0.1005
K1189 L48_52 L25_29 0.0336
K1190 L48_52 L42_46 0.0287
K1191 L48_52 L49_53 0.0551
K1192 L48_52 L35_38 0.0316
K1193 L48_52 L9_13 0.0718
K1194 L48_52 L45_49 0.0552
K1195 L48_52 L1_28 0.0422
K1196 L48_52 L24_28 0.0402
K1197 L48_52 L29_32 0.0309
K1198 L48_52 L11_15 0.1985
K1199 L47_48 L6_7 0.1992
K1200 L47_48 L54_55 0.1969
K1201 L47_48 L32_33 0.0485
K1202 L47_48 L15_16 0.3448
K1203 L47_48 L21_22 0.0504
K1204 L47_48 L7_8 0.2469
K1205 L47_48 L14_15 0.2445
K1206 L47_48 L3_4 0.1946
K1207 L47_48 L39_40 0.0482
K1208 L47_48 L2_3 0.1628
K1209 L47_48 L55_56 0.4429
K1210 L47_48 L50_51 0.2346
K1211 L47_48 L25_26 0.0526
K1212 L47_48 L17_18 0.0406
K1213 L47_48 L38_39 0.0431
K1214 L47_48 L10_11 0.2339
K1215 L47_48 L41_42 0.0894
K1216 L47_48 L35_36 0.0492
K1217 L47_48 L42_43 0.2191
K1218 L47_48 L49_50 0.0981
K1219 L47_48 L5_34 0.0607
K1220 L47_48 L13_40 0.0547
K1221 L47_48 L9_10 0.1232
K1222 L47_48 L11_12 0.3093
K1223 L47_48 L29_30 0.0511
K1224 L47_48 L18_19 0.044
K1225 L47_48 L9_37 0.0621
K1226 L29_32 L44_48 0.0313
K1227 L29_32 L2_6 0.0576
K1228 L29_32 L27_31 0.1512
K1229 L29_32 L4_8 0.0281
K1230 L29_32 L36_39 0.1946
K1231 L29_32 L50_54 0.0238
K1232 L29_32 L47_51 0.0149
K1233 L29_32 L52_56 0.0304
K1234 L29_32 L10_14 0.0563
K1235 L29_32 L42_46 0.0284
K1236 L29_32 L3_7 0.0374
K1237 L29_32 L9_13 0.1015
K1238 L29_32 L1_28 0.0912
K1239 L29_32 L24_28 0.078
K1240 L29_32 L12_16 0.0279
K1241 L29_32 L11_15 0.037
K1242 L29_30 L6_7 0.0653
K1243 L29_30 L54_55 0.0675
K1244 L29_30 L32_33 0.4616
K1245 L29_30 L15_16 0.0409
K1246 L29_30 L21_22 0.1922
K1247 L29_30 L14_15 0.0579
K1248 L29_30 L39_40 0.136
K1249 L29_30 L55_56 0.0447
K1250 L29_30 L50_51 0.0775
K1251 L29_30 L25_26 0.4357
K1252 L29_30 L17_18 0.1132
K1253 L29_30 L10_11 0.0645
K1254 L29_30 L41_42 0.1472
K1255 L29_30 L35_36 0.242
K1256 L29_30 L42_43 0.0773
K1257 L29_30 L49_50 0.1237
K1258 L29_30 L5_34 0.1523
K1259 L29_30 L13_40 0.1038
K1260 L29_30 L9_10 0.1119
K1261 L29_30 L38_39 0.155
K1262 L29_30 L11_12 0.0452
K1263 L29_30 L45_46 0.1432
K1264 L29_30 L18_19 0.1062
K1265 L29_30 L9_37 0.1339
K1266 L29_30 L7_8 0.0455
K1267 L44_48 L32_35 0.0316
K1268 L44_48 L21_25 0.0332
K1269 L44_48 L2_6 0.0956
K1270 L44_48 L27_31 0.0481
K1271 L44_48 L3_7 0.1665
K1272 L44_48 L36_39 0.0432
K1273 L44_48 L50_54 0.0283
K1274 L44_48 L47_51 0.0798
K1275 L44_48 L10_14 0.1045
K1276 L44_48 L25_29 0.0342
K1277 L44_48 L42_46 0.0288
K1278 L44_48 L49_53 0.0548
K1279 L44_48 L35_38 0.0319
K1280 L44_48 L9_13 0.073
K1281 L44_48 L45_49 0.0551
K1282 L44_48 L1_28 0.0434
K1283 L44_48 L24_28 0.0414
K1284 L44_48 L11_15 0.2444
K1285 L15_16 L6_7 0.1984
K1286 L15_16 L54_55 0.1153
K1287 L15_16 L32_33 0.0383
K1288 L15_16 L21_22 0.0413
K1289 L15_16 L7_8 0.3956
K1290 L15_16 L3_4 0.2765
K1291 L15_16 L2_3 0.163
K1292 L15_16 L55_56 0.2035
K1293 L15_16 L50_51 0.134
K1294 L15_16 L25_26 0.0426
K1295 L15_16 L17_18 0.0336
K1296 L15_16 L10_11 0.2283
K1297 L15_16 L41_42 0.0673
K1298 L15_16 L35_36 0.0385
K1299 L15_16 L42_43 0.1359
K1300 L15_16 L49_50 0.0723
K1301 L15_16 L5_34 0.048
K1302 L15_16 L9_10 0.0955
K1303 L15_16 L11_12 0.6814
K1304 L15_16 L45_46 0.0734
K1305 L15_16 L18_19 0.0367
K1306 L15_16 L9_37 0.0483
K1307 L27_31 L32_35 0.1295
K1308 L27_31 L21_25 0.1602
K1309 L27_31 L2_6 0.1109
K1310 L27_31 L52_56 0.0458
K1311 L27_31 L4_8 0.0444
K1312 L27_31 L36_39 0.1633
K1313 L27_31 L50_54 0.0332
K1314 L27_31 L47_51 0.0233
K1315 L27_31 L10_14 0.0993
K1316 L27_31 L25_29 0.1836
K1317 L27_31 L42_46 0.0428
K1318 L27_31 L49_53 0.1011
K1319 L27_31 L35_38 0.1088
K1320 L27_31 L3_7 0.0622
K1321 L27_31 L9_13 0.1851
K1322 L27_31 L45_49 0.1161
K1323 L27_31 L1_28 0.451
K1324 L27_31 L24_28 0.2736
K1325 L27_31 L12_16 0.0435
K1326 L27_31 L11_15 0.0601
K1327 L3_4 L6_7 0.2283
K1328 L3_4 L54_55 0.0955
K1329 L3_4 L32_33 0.0385
K1330 L3_4 L21_22 0.0431
K1331 L3_4 L14_15 0.163
K1332 L3_4 L39_40 0.0367
K1333 L3_4 L55_56 0.1345
K1334 L3_4 L50_51 0.1111
K1335 L3_4 L25_26 0.0438
K1336 L3_4 L17_18 0.0353
K1337 L3_4 L10_11 0.1984
K1338 L3_4 L41_42 0.0648
K1339 L3_4 L35_36 0.0383
K1340 L3_4 L42_43 0.1153
K1341 L3_4 L49_50 0.0683
K1342 L3_4 L5_34 0.0483
K1343 L3_4 L13_40 0.0413
K1344 L3_4 L9_10 0.094
K1345 L3_4 L38_39 0.0331
K1346 L3_4 L11_12 0.3956
K1347 L3_4 L45_46 0.07
K1348 L3_4 L18_19 0.0389
K1349 L3_4 L9_37 0.048
K1350 L3_4 L7_8 0.6814
K1351 L3_7 L32_35 0.0373
K1352 L3_7 L21_25 0.0407
K1353 L3_7 L2_6 0.2146
K1354 L3_7 L52_56 0.1244
K1355 L3_7 L4_8 0.2756
K1356 L3_7 L36_39 0.0511
K1357 L3_7 L50_54 0.0305
K1358 L3_7 L47_51 0.0545
K1359 L3_7 L10_14 0.17
K1360 L3_7 L25_29 0.0414
K1361 L3_7 L42_46 0.0347
K1362 L3_7 L49_53 0.0595
K1363 L3_7 L35_38 0.037
K1364 L3_7 L9_13 0.0949
K1365 L3_7 L45_49 0.0612
K1366 L3_7 L24_28 0.0563
K1367 L3_7 L12_16 0.1994
K1368 L3_7 L1_28 0.0582
K1369 L2_3 L6_7 0.6814
K1370 L2_3 L54_55 0.1289
K1371 L2_3 L32_33 0.0554
K1372 L2_3 L21_22 0.0605
K1373 L2_3 L14_15 0.2765
K1374 L2_3 L39_40 0.0548
K1375 L2_3 L55_56 0.1192
K1376 L2_3 L50_51 0.157
K1377 L2_3 L25_26 0.0626
K1378 L2_3 L17_18 0.0488
K1379 L2_3 L10_11 0.3956
K1380 L2_3 L41_42 0.0973
K1381 L2_3 L35_36 0.0549
K1382 L2_3 L42_43 0.1887
K1383 L2_3 L49_50 0.0972
K1384 L2_3 L5_34 0.0787
K1385 L2_3 L13_40 0.0654
K1386 L2_3 L9_10 0.1984
K1387 L2_3 L38_39 0.0471
K1388 L2_3 L11_12 0.1984
K1389 L2_3 L45_46 0.1028
K1390 L2_3 L18_19 0.0556
K1391 L2_3 L9_37 0.0771
K1392 L2_3 L7_8 0.2283
K1393 L4_8 L32_35 0.028
K1394 L4_8 L21_25 0.0308
K1395 L4_8 L2_6 0.0915
K1396 L4_8 L36_39 0.0377
K1397 L4_8 L50_54 0.0219
K1398 L4_8 L47_51 0.0403
K1399 L4_8 L10_14 0.0887
K1400 L4_8 L25_29 0.0311
K1401 L4_8 L42_46 0.0234
K1402 L4_8 L49_53 0.0455
K1403 L4_8 L35_38 0.0279
K1404 L4_8 L9_13 0.0632
K1405 L4_8 L45_49 0.0463
K1406 L4_8 L1_28 0.0403
K1407 L4_8 L24_28 0.0396
K1408 L4_8 L11_15 0.1994
K1409 L2_6 L32_35 0.0573
K1410 L2_6 L21_25 0.0609
K1411 L2_6 L52_56 0.085
K1412 L2_6 L36_39 0.0817
K1413 L2_6 L50_54 0.0436
K1414 L2_6 L47_51 0.05
K1415 L2_6 L25_29 0.0634
K1416 L2_6 L42_46 0.0585
K1417 L2_6 L49_53 0.085
K1418 L2_6 L35_38 0.0563
K1419 L2_6 L9_13 0.206
K1420 L2_6 L45_49 0.0903
K1421 L2_6 L1_28 0.1146
K1422 L2_6 L24_28 0.1005
K1423 L2_6 L12_16 0.0887
K1424 L2_6 L11_15 0.17
K1425 L55_56 L6_7 0.143
K1426 L55_56 L32_33 0.0427
K1427 L55_56 L21_22 0.0436
K1428 L55_56 L7_8 0.1649
K1429 L55_56 L14_15 0.1645
K1430 L55_56 L39_40 0.0426
K1431 L55_56 L50_51 0.219
K1432 L55_56 L25_26 0.0457
K1433 L55_56 L17_18 0.0351
K1434 L55_56 L38_39 0.0383
K1435 L55_56 L10_11 0.1626
K1436 L55_56 L41_42 0.0797
K1437 L55_56 L35_36 0.0435
K1438 L55_56 L42_43 0.1656
K1439 L55_56 L49_50 0.0894
K1440 L55_56 L5_34 0.0525
K1441 L55_56 L13_40 0.048
K1442 L55_56 L9_10 0.1027
K1443 L55_56 L11_12 0.1943
K1444 L55_56 L45_46 0.0886
K1445 L55_56 L18_19 0.0376
K1446 L55_56 L9_37 0.0541
K1447 L47_51 L32_35 0.0153
K1448 L47_51 L21_25 0.015
K1449 L47_51 L52_56 0.0798
K1450 L47_51 L36_39 0.0218
K1451 L47_51 L50_54 0.0215
K1452 L47_51 L10_14 0.0702
K1453 L47_51 L25_29 0.0159
K1454 L47_51 L42_46 0.0215
K1455 L47_51 L49_53 0.0287
K1456 L47_51 L35_38 0.0156
K1457 L47_51 L9_13 0.0426
K1458 L47_51 L45_49 0.0288
K1459 L47_51 L1_28 0.0213
K1460 L47_51 L24_28 0.0193
K1461 L47_51 L12_16 0.0504
K1462 L47_51 L11_15 0.081
K1463 L25_26 L6_7 0.0679
K1464 L25_26 L54_55 0.0659
K1465 L25_26 L32_33 0.2112
K1466 L25_26 L21_22 0.425
K1467 L25_26 L7_8 0.0478
K1468 L25_26 L14_15 0.0591
K1469 L25_26 L39_40 0.1027
K1470 L25_26 L50_51 0.0756
K1471 L25_26 L41_42 0.1238
K1472 L25_26 L17_18 0.1836
K1473 L25_26 L38_39 0.1096
K1474 L25_26 L10_11 0.0663
K1475 L25_26 L35_36 0.1528
K1476 L25_26 L42_43 0.0759
K1477 L25_26 L49_50 0.109
K1478 L25_26 L5_34 0.1321
K1479 L25_26 L13_40 0.0878
K1480 L25_26 L9_10 0.1079
K1481 L25_26 L11_12 0.0472
K1482 L25_26 L45_46 0.1232
K1483 L25_26 L18_19 0.1602
K1484 L25_26 L9_37 0.1132
K1485 L52_56 L32_35 0.0309
K1486 L52_56 L21_25 0.0318
K1487 L52_56 L36_39 0.0423
K1488 L52_56 L50_54 0.0288
K1489 L52_56 L10_14 0.0956
K1490 L52_56 L25_29 0.033
K1491 L52_56 L42_46 0.0283
K1492 L52_56 L49_53 0.0552
K1493 L52_56 L35_38 0.0313
K1494 L52_56 L9_13 0.0703
K1495 L52_56 L45_49 0.0551
K1496 L52_56 L1_28 0.041
K1497 L52_56 L24_28 0.0389
K1498 L52_56 L11_15 0.1665
K1499 L17_18 L6_7 0.0522
K1500 L17_18 L32_33 0.083
K1501 L17_18 L21_22 0.4511
K1502 L17_18 L7_8 0.0383
K1503 L17_18 L14_15 0.0445
K1504 L17_18 L39_40 0.0536
K1505 L17_18 L50_51 0.0535
K1506 L17_18 L38_39 0.0549
K1507 L17_18 L10_11 0.0503
K1508 L17_18 L41_42 0.0727
K1509 L17_18 L35_36 0.0705
K1510 L17_18 L42_43 0.0537
K1511 L17_18 L49_50 0.0678
K1512 L17_18 L5_34 0.0716
K1513 L17_18 L13_40 0.0501
K1514 L17_18 L9_10 0.0718
K1515 L17_18 L11_12 0.0375
K1516 L17_18 L45_46 0.0743
K1517 L17_18 L54_55 0.0467
K1518 L17_18 L9_37 0.063
K1519 L10_14 L32_35 0.0573
K1520 L10_14 L21_25 0.0562
K1521 L10_14 L36_39 0.0845
K1522 L10_14 L50_54 0.0585
K1523 L10_14 L25_29 0.0602
K1524 L10_14 L42_46 0.0881
K1525 L10_14 L49_53 0.0956
K1526 L10_14 L35_38 0.0576
K1527 L10_14 L9_13 0.2734
K1528 L10_14 L45_49 0.1005
K1529 L10_14 L1_28 0.0974
K1530 L10_14 L24_28 0.0825
K1531 L10_14 L12_16 0.0915
K1532 L10_14 L11_15 0.2146
K1533 L25_29 L36_39 0.1433
K1534 L25_29 L50_54 0.0236
K1535 L25_29 L42_46 0.0281
K1536 L25_29 L9_13 0.1016
K1537 L25_29 L1_28 0.106
K1538 L25_29 L24_28 0.0988
K1539 L25_29 L12_16 0.0307
K1540 L25_29 L11_15 0.0405
K1541 L10_11 L6_7 0.6456
K1542 L10_11 L54_55 0.1825
K1543 L10_11 L32_33 0.0607
K1544 L10_11 L21_22 0.063
K1545 L10_11 L7_8 0.2421
K1546 L10_11 L14_15 0.6814
K1547 L10_11 L39_40 0.062
K1548 L10_11 L50_51 0.2288
K1549 L10_11 L38_39 0.0529
K1550 L10_11 L41_42 0.1155
K1551 L10_11 L42_43 0.3046
K1552 L10_11 L49_50 0.1175
K1553 L10_11 L5_34 0.0861
K1554 L10_11 L13_40 0.0751
K1555 L10_11 L45_46 0.1232
K1556 L10_11 L18_19 0.0563
K1557 L42_46 L32_35 0.031
K1558 L42_46 L21_25 0.0243
K1559 L42_46 L36_39 0.0533
K1560 L42_46 L49_53 0.0689
K1561 L42_46 L35_38 0.0335
K1562 L42_46 L9_13 0.1227
K1563 L42_46 L45_49 0.0798
K1564 L42_46 L1_28 0.0384
K1565 L42_46 L24_28 0.0303
K1566 L42_46 L12_16 0.0244
K1567 L42_46 L11_15 0.0387
K1568 L35_36 L6_7 0.0607
K1569 L35_36 L54_55 0.0706
K1570 L35_36 L32_33 0.4781
K1571 L35_36 L21_22 0.1047
K1572 L35_36 L7_8 0.0422
K1573 L35_36 L14_15 0.0554
K1574 L35_36 L39_40 0.259
K1575 L35_36 L50_51 0.0805
K1576 L35_36 L38_39 0.5122
K1577 L35_36 L41_42 0.2187
K1578 L35_36 L42_43 0.0785
K1579 L35_36 L49_50 0.1621
K1580 L35_36 L5_34 0.144
K1581 L35_36 L13_40 0.1281
K1582 L35_36 L45_46 0.1995
K1583 L35_36 L18_19 0.0684
K1584 L42_43 L6_7 0.2405
K1585 L42_43 L54_55 0.3169
K1586 L42_43 L32_33 0.0757
K1587 L42_43 L21_22 0.0691
K1588 L42_43 L7_8 0.1338
K1589 L42_43 L14_15 0.3456
K1590 L42_43 L39_40 0.0865
K1591 L42_43 L50_51 0.4429
K1592 L42_43 L38_39 0.0696
K1593 L42_43 L49_50 0.1969
K1594 L42_43 L5_34 0.1125
K1595 L42_43 L13_40 0.1145
K1596 L42_43 L9_10 0.3046
K1597 L42_43 L11_12 0.1431
K1598 L42_43 L45_46 0.2191
K1599 L42_43 L18_19 0.0588
K1600 L42_43 L9_37 0.1237
K1601 L49_53 L36_39 0.1763
K1602 L49_53 L50_54 0.0883
K1603 L49_53 L9_13 0.1606
K1604 L49_53 L1_28 0.0807
K1605 L49_53 L24_28 0.0673
K1606 L49_53 L12_16 0.0469
K1607 L49_53 L11_15 0.0627
K1608 L49_50 L6_7 0.1114
K1609 L49_50 L54_55 0.219
K1610 L49_50 L32_33 0.1363
K1611 L49_50 L21_22 0.0913
K1612 L49_50 L7_8 0.0764
K1613 L49_50 L14_15 0.111
K1614 L49_50 L39_40 0.1811
K1615 L49_50 L38_39 0.1634
K1616 L49_50 L41_42 0.4429
K1617 L49_50 L5_34 0.1456
K1618 L49_50 L13_40 0.1811
K1619 L49_50 L9_10 0.1992
K1620 L49_50 L11_12 0.0782
K1621 L49_50 L45_46 0.6955
K1622 L49_50 L18_19 0.0693
K1623 L49_50 L9_37 0.1765
K1624 L35_38 L36_39 0.4274
K1625 L35_38 L50_54 0.0284
K1626 L35_38 L9_13 0.1092
K1627 L35_38 L1_28 0.075
K1628 L35_38 L24_28 0.0616
K1629 L35_38 L12_16 0.0281
K1630 L35_38 L11_15 0.0374
K1631 L5_34 L54_55 0.0879
K1632 L5_34 L21_22 0.1024
K1633 L5_34 L14_15 0.0771
K1634 L5_34 L39_40 0.1784
K1635 L5_34 L50_51 0.104
K1636 L5_34 L41_42 0.1896
K1637 L5_34 L13_40 0.2331
K1638 L5_34 L9_10 0.2457
K1639 L5_34 L38_39 0.1147
K1640 L5_34 L11_12 0.053
K1641 L5_34 L45_46 0.1765
K1642 L5_34 L18_19 0.0797
K1643 L5_34 L9_37 0.4781
K1644 L13_40 L6_7 0.0736
K1645 L13_40 L54_55 0.0906
K1646 L13_40 L32_33 0.1147
K1647 L13_40 L21_22 0.0699
K1648 L13_40 L7_8 0.0458
K1649 L13_40 L50_51 0.1074
K1650 L13_40 L41_42 0.2808
K1651 L13_40 L9_10 0.2263
K1652 L13_40 L11_12 0.0461
K1653 L13_40 L45_46 0.2386
K1654 L13_40 L18_19 0.0536
K1655 L13_40 L9_37 0.5122
K1656 L9_13 L32_35 0.1071
K1657 L9_13 L21_25 0.0871
K1658 L9_13 L36_39 0.1857
K1659 L9_13 L50_54 0.0726
K1660 L9_13 L45_49 0.1839
K1661 L9_13 L12_16 0.064
K1662 L9_13 L11_15 0.0975
K1663 L9_10 L6_7 0.2421
K1664 L9_10 L54_55 0.1825
K1665 L9_10 L32_33 0.1092
K1666 L9_10 L21_22 0.095
K1667 L9_10 L7_8 0.1045
K1668 L9_10 L14_15 0.2283
K1669 L9_10 L39_40 0.1326
K1670 L9_10 L50_51 0.2288
K1671 L9_10 L38_39 0.0955
K1672 L9_10 L41_42 0.2441
K1673 L9_10 L45_46 0.2339
K1674 L9_10 L18_19 0.081
K1675 L45_49 L36_39 0.2312
K1676 L45_49 L50_54 0.0798
K1677 L45_49 L1_28 0.0914
K1678 L45_49 L24_28 0.0748
K1679 L45_49 L12_16 0.0475
K1680 L45_49 L11_15 0.064
K1681 L24_28 L32_35 0.0693
K1682 L24_28 L21_25 0.106
K1683 L24_28 L36_39 0.0874
K1684 L24_28 L50_54 0.0241
K1685 L24_28 L12_16 0.0381
K1686 L24_28 L11_15 0.0526
K1687 L38_39 L6_7 0.0523
K1688 L38_39 L54_55 0.0636
K1689 L38_39 L32_33 0.2331
K1690 L38_39 L21_22 0.0795
K1691 L38_39 L7_8 0.0366
K1692 L38_39 L50_51 0.0723
K1693 L38_39 L41_42 0.2402
K1694 L38_39 L11_12 0.0367
K1695 L38_39 L45_46 0.2089
K1696 L38_39 L18_19 0.0536
K1697 L38_39 L9_37 0.1281
K1698 L45_46 L6_7 0.1175
K1699 L45_46 L54_55 0.1969
K1700 L45_46 L32_33 0.1621
K1701 L45_46 L21_22 0.1012
K1702 L45_46 L7_8 0.0782
K1703 L45_46 L14_15 0.1157
K1704 L45_46 L39_40 0.2386
K1705 L45_46 L50_51 0.2346
K1706 L45_46 L41_42 0.7235
K1707 L45_46 L11_12 0.0797
K1708 L45_46 L18_19 0.0762
K1709 L45_46 L9_37 0.2229
K1710 L6_7 L54_55 0.1568
K1711 L6_7 L21_22 0.0651
K1712 L6_7 L14_15 0.3956
K1713 L6_7 L39_40 0.0612
K1714 L6_7 L50_51 0.1931
K1715 L6_7 L41_42 0.1109
K1716 L6_7 L11_12 0.2421
K1717 L6_7 L18_19 0.059
K1718 L6_7 L9_37 0.0861
K1719 L32_35 L36_39 0.3028
K1720 L32_35 L50_54 0.026
K1721 L32_35 L1_28 0.0837
K1722 L32_35 L12_16 0.028
K1723 L32_35 L11_15 0.0373
K1724 L32_33 L54_55 0.0669
K1725 L32_33 L21_22 0.129
K1726 L32_33 L14_15 0.0549
K1727 L32_33 L39_40 0.1784
K1728 L32_33 L50_51 0.0766
K1729 L32_33 L41_42 0.1711
K1730 L32_33 L11_12 0.0422
K1731 L32_33 L18_19 0.0797
K1732 L32_33 L9_37 0.144
K1733 L21_22 L54_55 0.0599
K1734 L21_22 L41_42 0.1
K1735 L21_22 L7_8 0.0468
K1736 L21_22 L14_15 0.0559
K1737 L21_22 L39_40 0.0768
K1738 L21_22 L50_51 0.0687
K1739 L21_22 L11_12 0.046
K1740 L21_22 L18_19 0.2736
K1741 L21_22 L9_37 0.0889
K1742 L21_25 L36_39 0.0983
K1743 L21_25 L50_54 0.0207
K1744 L21_25 L1_28 0.0988
K1745 L21_25 L12_16 0.0301
K1746 L21_25 L11_15 0.0392
K1747 L7_8 L54_55 0.1109
K1748 L7_8 L14_15 0.1984
K1749 L7_8 L39_40 0.0406
K1750 L7_8 L50_51 0.1292
K1751 L7_8 L41_42 0.0722
K1752 L7_8 L11_12 0.6456
K1753 L7_8 L18_19 0.0421
K1754 L7_8 L9_37 0.053
K1755 L14_15 L54_55 0.1887
K1756 L14_15 L50_51 0.2408
K1757 L14_15 L41_42 0.1077
K1758 L14_15 L11_12 0.2283
K1759 L14_15 L18_19 0.0494
K1760 L14_15 L9_37 0.0787
K1761 L36_39 L50_54 0.0415
K1762 L36_39 L1_28 0.1146
K1763 L36_39 L12_16 0.038
K1764 L36_39 L11_15 0.0517
K1765 L50_54 L1_28 0.0291
K1766 L50_54 L12_16 0.0234
K1767 L50_54 L11_15 0.0347
K1768 L50_51 L54_55 0.7235
K1769 L50_51 L39_40 0.0869
K1770 L50_51 L41_42 0.1969
K1771 L50_51 L11_12 0.1393
K1772 L50_51 L18_19 0.0576
K1773 L50_51 L9_37 0.1148
K1774 L9_37 L54_55 0.0969
K1775 L9_37 L39_40 0.259
K1776 L9_37 L41_42 0.2498
K1777 L9_37 L18_19 0.0684
K1778 L41_42 L54_55 0.1656
K1779 L41_42 L39_40 0.2808
K1780 L41_42 L11_12 0.0733
K1781 L41_42 L18_19 0.0749
K1782 L39_40 L54_55 0.0753
K1783 L39_40 L11_12 0.0409
K1784 L39_40 L18_19 0.0549
K1785 L54_55 L11_12 0.1197
K1786 L54_55 L18_19 0.0499
K1787 L1_28 L12_16 0.0394
K1788 L1_28 L11_15 0.0557
K1789 L11_12 L18_19 0.0411
K1790 L12_16 L11_15 0.2756
Rin53 53 gnd 50.0
Rin19 19 gnd 50.0
Rin111 111 gnd 50.0
Vs 147 gnd DC 0 AC 1.0
Rin121 147 121 50.0
.ac lin 1 1000000000.0Hz 1000000000.0Hz
.option post=2
.probe i(L1_2) i(L1_28) i(L1_5) i(L1_31) i(L2_3) i(L2_6) i(L3_4) i(L3_7) i(L4_8) i(L5_34) i(L5_6) i(L5_9) i(L6_10) i(L6_7) i(L7_11) i(L7_8) i(L8_12) i(L9_37) i(L9_10) i(L9_13) i(L10_11) i(L10_14) i(L11_15) i(L11_12) i(L12_16) i(L13_40) i(L13_14) i(L14_15) i(L15_16) i(L17_18) i(L17_21) i(L18_19) i(L18_22) i(L19_20) i(L19_23) i(L20_24) i(L21_22) i(L21_25) i(L22_26) i(L22_23) i(L23_27) i(L23_24) i(L24_28) i(L25_26) i(L25_29) i(L26_27) i(L26_30) i(L27_31) i(L27_28) i(L29_32) i(L29_30) i(L30_33) i(L30_31) i(L31_34) i(L32_33) i(L32_35) i(L33_34) i(L33_36) i(L34_37) i(L35_36) i(L35_38) i(L36_37) i(L36_39) i(L37_40) i(L38_39) i(L39_40) i(L41_42) i(L41_45) i(L42_43) i(L42_46) i(L43_44) i(L43_47) i(L44_48) i(L45_46) i(L45_49) i(L46_50) i(L46_47) i(L47_48) i(L47_51) i(L48_52) i(L49_50) i(L49_53) i(L50_51) i(L50_54) i(L51_55) i(L51_52) i(L52_56) i(L53_54) i(L54_55) i(L55_56)
.option GENK=0
.end
