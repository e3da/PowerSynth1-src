* 2018-11-02 05:44:19
R1_49 1 2 0.000786155274112
L1_49 2 3 2.33233154226e-09
R1_2 3 4 0.000189296975879
L1_2 4 5 3.61864906563e-10
R1_6 3 6 3.80823315112e-05
L1_6 6 7 1.48662202143e-10
R2_3 5 8 0.000189296975879
L2_3 8 9 3.61864906563e-10
R2_7 5 10 0.000124081417057
L2_7 10 11 2.48357542436e-10
R3_8 9 12 0.000124081417057
L3_8 12 13 2.48357542436e-10
R3_4 9 14 0.000189296975879
L3_4 14 15 3.61864906563e-10
R4_9 15 16 0.000124081417057
L4_9 16 17 2.48357542436e-10
R4_5 15 18 0.000189296975879
L4_5 18 19 3.61864906563e-10
R5_10 19 20 0.000189296975879
L5_10 20 21 3.61864906563e-10
R6_11 7 22 3.80823315112e-05
L6_11 22 23 1.48662202143e-10
R6_53 24 25 0.00057703109907
L6_53 25 7 2.02721469163e-09
R6_7 7 26 0.000124081417057
L6_7 26 11 2.48357542436e-10
R7_8 11 27 0.000124081417057
L7_8 27 13 2.48357542436e-10
R7_12 11 28 0.000124081417057
L7_12 28 29 2.48357542436e-10
R8_9 13 30 0.000124081417057
L8_9 30 17 2.48357542436e-10
R8_13 13 31 0.000124081417057
L8_13 31 32 2.48357542436e-10
R9_10 17 33 0.000124081417057
L9_10 33 21 2.48357542436e-10
R9_14 17 34 0.000124081417057
L9_14 34 35 2.48357542436e-10
R10_15 21 36 0.000189296975879
L10_15 36 37 3.61864906563e-10
R11_16 23 38 3.80823315112e-05
L11_16 38 39 1.48662202143e-10
R11_57 40 41 0.00057703109907
L11_57 41 23 2.02721469163e-09
R11_12 23 42 0.000124081417057
L11_12 42 29 2.48357542436e-10
R12_17 29 43 0.000124081417057
L12_17 43 44 2.48357542436e-10
R12_13 29 45 0.000124081417057
L12_13 45 32 2.48357542436e-10
R13_18 32 46 0.000124081417057
L13_18 46 47 2.48357542436e-10
R13_14 32 48 0.000124081417057
L13_14 48 35 2.48357542436e-10
R14_19 35 49 0.000124081417057
L14_19 49 50 2.48357542436e-10
R14_15 35 51 0.000124081417057
L14_15 51 37 2.48357542436e-10
R15_20 37 52 0.000189296975879
L15_20 52 53 3.61864906563e-10
R16_17 39 54 0.000124081417057
L16_17 54 44 2.48357542436e-10
R16_21 39 55 3.80823315112e-05
L16_21 55 56 1.48662202143e-10
R16_61 57 58 0.00057703109907
L16_61 58 39 2.02721469163e-09
R17_18 44 59 0.000124081417057
L17_18 59 47 2.48357542436e-10
R17_22 44 60 0.000124081417057
L17_22 60 61 2.48357542436e-10
R18_19 47 62 0.000124081417057
L18_19 62 50 2.48357542436e-10
R18_23 47 63 0.000124081417057
L18_23 63 64 2.48357542436e-10
R19_24 50 65 0.000124081417057
L19_24 65 66 2.48357542436e-10
R19_20 50 67 0.000124081417057
L19_20 67 53 2.48357542436e-10
R20_25 53 68 0.000189296975879
L20_25 68 69 3.61864906563e-10
R21_65 70 71 0.000786155274112
L21_65 71 56 2.33233154226e-09
R21_26 56 72 0.000586489947016
L21_26 72 73 1.59414541063e-09
R21_22 56 74 4.81272145771e-05
L21_22 74 61 1.68565415484e-10
R22_27 61 75 0.000427564578879
L22_27 75 76 1.35902917582e-09
R22_23 61 77 4.81272145771e-05
L22_23 77 64 1.68565415484e-10
R23_24 64 78 4.81272145771e-05
L23_24 78 66 1.68565415484e-10
R23_28 64 79 0.000427564578879
L23_28 79 80 1.35902917582e-09
R24_25 66 81 4.81272145771e-05
L24_25 81 69 1.68565415484e-10
R24_29 66 82 0.000427564578879
L24_29 82 83 1.35902917582e-09
R25_30 69 84 0.000586489947016
L25_30 84 85 1.59414541063e-09
R26_27 73 86 3.25009476713e-05
L26_27 86 76 1.35966114104e-10
R26_31 73 87 0.000586489947016
L26_31 87 88 1.59414541063e-09
R27_32 76 89 0.000427564578879
L27_32 89 90 1.35902917582e-09
R27_28 76 91 3.25009476713e-05
L27_28 91 80 1.35966114104e-10
R28_33 80 92 0.000427564578879
L28_33 92 93 1.35902917582e-09
R28_29 80 94 3.25009476713e-05
L28_29 94 83 1.35966114104e-10
R29_34 83 95 0.000427564578879
L29_34 95 96 1.35902917582e-09
R29_30 83 97 3.25009476713e-05
L29_30 97 85 1.35966114104e-10
R30_35 85 98 0.000586489947016
L30_35 98 99 1.59414541063e-09
R31_32 88 100 3.25009476713e-05
L31_32 100 90 1.35966114104e-10
R31_36 88 101 0.000586489947016
L31_36 101 102 1.59414541063e-09
R32_33 90 103 3.25009476713e-05
L32_33 103 93 1.35966114104e-10
R32_37 90 104 0.000427564578879
L32_37 104 105 1.35902917582e-09
R33_34 93 106 3.25009476713e-05
L33_34 106 96 1.35966114104e-10
R33_38 93 107 0.000427564578879
L33_38 107 108 1.35902917582e-09
R34_35 96 109 3.25009476713e-05
L34_35 109 99 1.35966114104e-10
R34_39 96 110 0.000427564578879
L34_39 110 111 1.35902917582e-09
R35_40 99 112 0.000586489947016
L35_40 112 113 1.59414541063e-09
R36_41 102 114 0.000586489947016
L36_41 114 115 1.59414541063e-09
R36_37 102 116 3.25009476713e-05
L36_37 116 105 1.35966114104e-10
R37_42 105 117 0.000427564578879
L37_42 117 118 1.35902917582e-09
R37_38 105 119 3.25009476713e-05
L37_38 119 108 1.35966114104e-10
R38_43 108 120 0.000427564578879
L38_43 120 121 1.35902917582e-09
R38_39 108 122 3.25009476713e-05
L38_39 122 111 1.35966114104e-10
R39_40 111 123 3.25009476713e-05
L39_40 123 113 1.35966114104e-10
R39_44 111 124 0.000427564578879
L39_44 124 125 1.35902917582e-09
R40_45 113 126 0.000586489947016
L40_45 126 127 1.59414541063e-09
R41_74 115 128 3.80823315112e-05
L41_74 128 129 1.48662202143e-10
R41_42 115 130 4.81272145771e-05
L41_42 130 118 1.68565415484e-10
R41_69 131 132 0.000786155274112
L41_69 132 115 2.33233154226e-09
R42_90 118 133 0.000124081417057
L42_90 133 134 2.48357542436e-10
R42_43 118 135 4.81272145771e-05
L42_43 135 121 1.68565415484e-10
R43_91 121 136 0.000124081417057
L43_91 136 137 2.48357542436e-10
R43_44 121 138 4.81272145771e-05
L43_44 138 125 1.68565415484e-10
R44_92 125 139 0.000124081417057
L44_92 139 140 2.48357542436e-10
R44_45 125 141 4.81272145771e-05
L44_45 141 127 1.68565415484e-10
R45_93 127 142 0.000189296975879
L45_93 142 143 3.61864906563e-10
R46_50 144 145 4.81272145771e-05
L46_50 145 146 1.68565415484e-10
R46_47 144 147 0.000786155274112
L46_47 147 148 2.33233154226e-09
R47_48 148 149 0.000786155274112
L47_48 149 150 2.33233154226e-09
R47_51 148 151 2.43027348578e-05
L47_51 151 152 1.14059892238e-10
R48_49 150 153 0.000786155274112
L48_49 153 1 2.33233154226e-09
R48_52 150 154 2.43027348578e-05
L48_52 154 155 1.14059892238e-10
R49_53 1 156 2.43027348578e-05
L49_53 156 24 1.14059892238e-10
R50_51 146 157 0.00057703109907
L50_51 157 152 2.02721469163e-09
R50_54 146 158 4.81272145771e-05
L50_54 158 159 1.68565415484e-10
R51_55 152 160 2.43027348578e-05
L51_55 160 161 1.14059892238e-10
R51_52 152 162 0.00057703109907
L51_52 162 155 2.02721469163e-09
R52_56 155 163 2.43027348578e-05
L52_56 163 164 1.14059892238e-10
R52_53 155 165 0.00057703109907
L52_53 165 24 2.02721469163e-09
R53_57 24 166 2.43027348578e-05
L53_57 166 40 1.14059892238e-10
R54_58 159 167 4.81272145771e-05
L54_58 167 168 1.68565415484e-10
R54_55 159 169 0.00057703109907
L54_55 169 161 2.02721469163e-09
R55_56 161 170 0.00057703109907
L55_56 170 164 2.02721469163e-09
R55_59 161 171 2.43027348578e-05
L55_59 171 172 1.14059892238e-10
R56_60 164 173 2.43027348578e-05
L56_60 173 174 1.14059892238e-10
R56_57 164 175 0.00057703109907
L56_57 175 40 2.02721469163e-09
R57_61 40 176 2.43027348578e-05
L57_61 176 57 1.14059892238e-10
R58_59 168 177 0.00057703109907
L58_59 177 172 2.02721469163e-09
R58_62 168 178 4.81272145771e-05
L58_62 178 179 1.68565415484e-10
R59_63 172 180 2.43027348578e-05
L59_63 180 181 1.14059892238e-10
R59_60 172 182 0.00057703109907
L59_60 182 174 2.02721469163e-09
R60_64 174 183 2.43027348578e-05
L60_64 183 184 1.14059892238e-10
R60_61 174 185 0.00057703109907
L60_61 185 57 2.02721469163e-09
R61_65 57 186 2.43027348578e-05
L61_65 186 70 1.14059892238e-10
R62_63 179 187 0.000786155274112
L62_63 187 181 2.33233154226e-09
R63_64 181 188 0.000786155274112
L63_64 188 184 2.33233154226e-09
R64_65 184 189 0.000786155274112
L64_65 189 70 2.33233154226e-09
R66_67 190 191 0.000786155274112
L66_67 191 192 2.33233154226e-09
R66_70 190 193 4.81272145771e-05
L66_70 193 194 1.68565415484e-10
R67_68 192 195 0.000786155274112
L67_68 195 196 2.33233154226e-09
R67_71 192 197 2.43027348578e-05
L67_71 197 198 1.14059892238e-10
R68_72 196 199 2.43027348578e-05
L68_72 199 200 1.14059892238e-10
R68_69 196 201 0.000786155274112
L68_69 201 131 2.33233154226e-09
R69_73 131 202 2.43027348578e-05
L69_73 202 203 1.14059892238e-10
R70_75 194 204 4.81272145771e-05
L70_75 204 205 1.68565415484e-10
R70_71 194 206 0.00057703109907
L70_71 206 198 2.02721469163e-09
R71_72 198 207 0.00057703109907
L71_72 207 200 2.02721469163e-09
R71_76 198 208 2.43027348578e-05
L71_76 208 209 1.14059892238e-10
R72_73 200 210 0.00057703109907
L72_73 210 203 2.02721469163e-09
R72_77 200 211 2.43027348578e-05
L72_77 211 212 1.14059892238e-10
R73_74 203 213 0.00057703109907
L73_74 213 129 2.02721469163e-09
R73_78 203 214 2.43027348578e-05
L73_78 214 215 1.14059892238e-10
R74_90 129 216 0.000124081417057
L74_90 216 134 2.48357542436e-10
R74_79 129 217 3.80823315112e-05
L74_79 217 218 1.48662202143e-10
R75_80 205 219 4.81272145771e-05
L75_80 219 220 1.68565415484e-10
R75_76 205 221 0.00057703109907
L75_76 221 209 2.02721469163e-09
R76_81 209 222 2.43027348578e-05
L76_81 222 223 1.14059892238e-10
R76_77 209 224 0.00057703109907
L76_77 224 212 2.02721469163e-09
R77_82 212 225 2.43027348578e-05
L77_82 225 226 1.14059892238e-10
R77_78 212 227 0.00057703109907
L77_78 227 215 2.02721469163e-09
R78_83 215 228 2.43027348578e-05
L78_83 228 229 1.14059892238e-10
R78_79 215 230 0.00057703109907
L78_79 230 218 2.02721469163e-09
R79_84 218 231 3.80823315112e-05
L79_84 231 232 1.48662202143e-10
R79_94 218 233 0.000124081417057
L79_94 233 234 2.48357542436e-10
R80_81 220 235 0.00057703109907
L80_81 235 223 2.02721469163e-09
R80_85 220 236 4.81272145771e-05
L80_85 236 237 1.68565415484e-10
R81_82 223 238 0.00057703109907
L81_82 238 226 2.02721469163e-09
R81_86 223 239 2.43027348578e-05
L81_86 239 240 1.14059892238e-10
R82_83 226 241 0.00057703109907
L82_83 241 229 2.02721469163e-09
R82_87 226 242 2.43027348578e-05
L82_87 242 243 1.14059892238e-10
R83_88 229 244 2.43027348578e-05
L83_88 244 245 1.14059892238e-10
R83_84 229 246 0.00057703109907
L83_84 246 232 2.02721469163e-09
R84_89 232 247 3.80823315112e-05
L84_89 247 248 1.48662202143e-10
R84_98 232 249 0.000124081417057
L84_98 249 250 2.48357542436e-10
R85_86 237 251 0.000786155274112
L85_86 251 240 2.33233154226e-09
R86_87 240 252 0.000786155274112
L86_87 252 243 2.33233154226e-09
R87_88 243 253 0.000786155274112
L87_88 253 245 2.33233154226e-09
R88_89 245 254 0.000786155274112
L88_89 254 248 2.33233154226e-09
R89_102 248 255 0.000189296975879
L89_102 255 256 3.61864906563e-10
R90_91 134 257 0.000124081417057
L90_91 257 137 2.48357542436e-10
R90_94 134 258 0.000124081417057
L90_94 258 234 2.48357542436e-10
R91_92 137 259 0.000124081417057
L91_92 259 140 2.48357542436e-10
R91_95 137 260 0.000124081417057
L91_95 260 261 2.48357542436e-10
R92_96 140 262 0.000124081417057
L92_96 262 263 2.48357542436e-10
R92_93 140 264 0.000124081417057
L92_93 264 143 2.48357542436e-10
R93_97 143 265 0.000189296975879
L93_97 265 266 3.61864906563e-10
R94_95 234 267 0.000124081417057
L94_95 267 261 2.48357542436e-10
R94_98 234 268 0.000124081417057
L94_98 268 250 2.48357542436e-10
R95_99 261 269 0.000124081417057
L95_99 269 270 2.48357542436e-10
R95_96 261 271 0.000124081417057
L95_96 271 263 2.48357542436e-10
R96_100 263 272 0.000124081417057
L96_100 272 273 2.48357542436e-10
R96_97 263 274 0.000124081417057
L96_97 274 266 2.48357542436e-10
R97_101 266 275 0.000189296975879
L97_101 275 276 3.61864906563e-10
R98_99 250 277 0.000124081417057
L98_99 277 270 2.48357542436e-10
R98_102 250 278 0.000124081417057
L98_102 278 256 2.48357542436e-10
R99_103 270 279 0.000124081417057
L99_103 279 280 2.48357542436e-10
R99_100 270 281 0.000124081417057
L99_100 281 273 2.48357542436e-10
R100_104 273 282 0.000124081417057
L100_104 282 283 2.48357542436e-10
R100_101 273 284 0.000124081417057
L100_101 284 276 2.48357542436e-10
R101_105 276 285 0.000189296975879
L101_105 285 286 3.61864906563e-10
R102_103 256 287 0.000189296975879
L102_103 287 280 3.61864906563e-10
R103_104 280 288 0.000189296975879
L103_104 288 283 3.61864906563e-10
R104_105 283 289 0.000189296975879
L104_105 289 286 3.61864906563e-10
R106_107 290 291 0.000786155274112
L106_107 291 292 2.33233154226e-09
R106_111 290 293 4.81272145771e-05
L106_111 293 294 1.68565415484e-10
R107_112 292 295 2.43027348578e-05
L107_112 295 296 1.14059892238e-10
R107_108 292 297 0.000786155274112
L107_108 297 298 2.33233154226e-09
R108_113 298 299 2.43027348578e-05
L108_113 299 300 1.14059892238e-10
R108_109 298 301 0.000786155274112
L108_109 301 302 2.33233154226e-09
R109_114 302 303 2.43027348578e-05
L109_114 303 304 1.14059892238e-10
R109_110 302 305 0.000786155274112
L109_110 305 306 2.33233154226e-09
R110_115 306 307 3.80823315112e-05
L110_115 307 308 1.48662202143e-10
R110_175 306 309 0.000189296975879
L110_175 309 310 3.61864906563e-10
R111_112 294 311 0.00057703109907
L111_112 311 296 2.02721469163e-09
R111_116 294 312 4.81272145771e-05
L111_116 312 313 1.68565415484e-10
R112_113 296 314 0.00057703109907
L112_113 314 300 2.02721469163e-09
R112_117 296 315 2.43027348578e-05
L112_117 315 316 1.14059892238e-10
R113_114 300 317 0.00057703109907
L113_114 317 304 2.02721469163e-09
R113_118 300 318 2.43027348578e-05
L113_118 318 319 1.14059892238e-10
R114_115 304 320 0.00057703109907
L114_115 320 308 2.02721469163e-09
R114_119 304 321 2.43027348578e-05
L114_119 321 322 1.14059892238e-10
R115_120 308 323 3.80823315112e-05
L115_120 323 324 1.48662202143e-10
R115_179 308 325 0.000124081417057
L115_179 325 326 2.48357542436e-10
R116_121 313 327 4.81272145771e-05
L116_121 327 328 1.68565415484e-10
R116_117 313 329 0.00057703109907
L116_117 329 316 2.02721469163e-09
R117_122 316 330 2.43027348578e-05
L117_122 330 331 1.14059892238e-10
R117_118 316 332 0.00057703109907
L117_118 332 319 2.02721469163e-09
R118_123 319 333 2.43027348578e-05
L118_123 333 334 1.14059892238e-10
R118_119 319 335 0.00057703109907
L118_119 335 322 2.02721469163e-09
R119_120 322 336 0.00057703109907
L119_120 336 324 2.02721469163e-09
R119_124 322 337 2.43027348578e-05
L119_124 337 338 1.14059892238e-10
R120_183 324 339 0.000124081417057
L120_183 339 340 2.48357542436e-10
R120_125 324 341 3.80823315112e-05
L120_125 341 342 1.48662202143e-10
R121_122 328 343 0.00057703109907
L121_122 343 331 2.02721469163e-09
R121_126 328 344 4.81272145771e-05
L121_126 344 345 1.68565415484e-10
R122_123 331 346 0.00057703109907
L122_123 346 334 2.02721469163e-09
R122_127 331 347 2.43027348578e-05
L122_127 347 348 1.14059892238e-10
R123_128 334 349 2.43027348578e-05
L123_128 349 350 1.14059892238e-10
R123_124 334 351 0.00057703109907
L123_124 351 338 2.02721469163e-09
R124_129 338 352 2.43027348578e-05
L124_129 352 353 1.14059892238e-10
R124_125 338 354 0.00057703109907
L124_125 354 342 2.02721469163e-09
R125_130 342 355 3.80823315112e-05
L125_130 355 356 1.48662202143e-10
R125_187 342 357 0.000124081417057
L125_187 357 358 2.48357542436e-10
R126_127 345 359 0.000786155274112
L126_127 359 348 2.33233154226e-09
R127_128 348 360 0.000786155274112
L127_128 360 350 2.33233154226e-09
R128_129 350 361 0.000786155274112
L128_129 361 353 2.33233154226e-09
R129_130 353 362 0.000786155274112
L129_130 362 356 2.33233154226e-09
R130_160 356 363 0.000586489947016
L130_160 363 364 1.59414541063e-09
R130_156 356 365 4.81272145771e-05
L130_156 365 366 1.68565415484e-10
R131_136 367 368 3.80823315112e-05
L131_136 368 369 1.48662202143e-10
R131_170 370 371 0.000586489947016
L131_170 371 367 1.59414541063e-09
R131_132 367 372 4.81272145771e-05
L131_132 372 373 1.68565415484e-10
R131_194 374 375 0.000786155274112
L131_194 375 367 2.33233154226e-09
R132_137 373 376 0.000124081417057
L132_137 376 377 2.48357542436e-10
R132_171 378 379 0.000427564578879
L132_171 379 373 1.35902917582e-09
R132_133 373 380 4.81272145771e-05
L132_133 380 381 1.68565415484e-10
R133_172 382 383 0.000427564578879
L133_172 383 381 1.35902917582e-09
R133_138 381 384 0.000124081417057
L133_138 384 385 2.48357542436e-10
R133_134 381 386 4.81272145771e-05
L133_134 386 387 1.68565415484e-10
R134_139 387 388 0.000124081417057
L134_139 388 389 2.48357542436e-10
R134_135 387 390 4.81272145771e-05
L134_135 390 391 1.68565415484e-10
R134_173 392 393 0.000427564578879
L134_173 393 387 1.35902917582e-09
R135_140 391 394 0.000189296975879
L135_140 394 395 3.61864906563e-10
R135_174 396 397 0.000586489947016
L135_174 397 391 1.59414541063e-09
R136_137 369 398 0.000124081417057
L136_137 398 377 2.48357542436e-10
R136_141 369 399 3.80823315112e-05
L136_141 399 400 1.48662202143e-10
R136_198 401 402 0.00057703109907
L136_198 402 369 2.02721469163e-09
R137_138 377 403 0.000124081417057
L137_138 403 385 2.48357542436e-10
R137_142 377 404 0.000124081417057
L137_142 404 405 2.48357542436e-10
R138_139 385 406 0.000124081417057
L138_139 406 389 2.48357542436e-10
R138_143 385 407 0.000124081417057
L138_143 407 408 2.48357542436e-10
R139_144 389 409 0.000124081417057
L139_144 409 410 2.48357542436e-10
R139_140 389 411 0.000124081417057
L139_140 411 395 2.48357542436e-10
R140_145 395 412 0.000189296975879
L140_145 412 413 3.61864906563e-10
R141_146 400 414 3.80823315112e-05
L141_146 414 415 1.48662202143e-10
R141_202 416 417 0.00057703109907
L141_202 417 400 2.02721469163e-09
R141_142 400 418 0.000124081417057
L141_142 418 405 2.48357542436e-10
R142_147 405 419 0.000124081417057
L142_147 419 420 2.48357542436e-10
R142_143 405 421 0.000124081417057
L142_143 421 408 2.48357542436e-10
R143_144 408 422 0.000124081417057
L143_144 422 410 2.48357542436e-10
R143_148 408 423 0.000124081417057
L143_148 423 424 2.48357542436e-10
R144_145 410 425 0.000124081417057
L144_145 425 413 2.48357542436e-10
R144_149 410 426 0.000124081417057
L144_149 426 427 2.48357542436e-10
R145_150 413 428 0.000189296975879
L145_150 428 429 3.61864906563e-10
R146_147 415 430 0.000124081417057
L146_147 430 420 2.48357542436e-10
R146_206 431 432 0.00057703109907
L146_206 432 415 2.02721469163e-09
R146_151 415 433 3.80823315112e-05
L146_151 433 434 1.48662202143e-10
R147_152 420 435 0.000124081417057
L147_152 435 436 2.48357542436e-10
R147_148 420 437 0.000124081417057
L147_148 437 424 2.48357542436e-10
R148_153 424 438 0.000124081417057
L148_153 438 439 2.48357542436e-10
R148_149 424 440 0.000124081417057
L148_149 440 427 2.48357542436e-10
R149_154 427 441 0.000124081417057
L149_154 441 442 2.48357542436e-10
R149_150 427 443 0.000124081417057
L149_150 443 429 2.48357542436e-10
R150_155 429 444 0.000189296975879
L150_155 444 445 3.61864906563e-10
R151_152 434 446 0.000189296975879
L151_152 446 436 3.61864906563e-10
R151_210 447 448 0.000786155274112
L151_210 448 434 2.33233154226e-09
R152_153 436 449 0.000189296975879
L152_153 449 439 3.61864906563e-10
R153_154 439 450 0.000189296975879
L153_154 450 442 3.61864906563e-10
R154_155 442 451 0.000189296975879
L154_155 451 445 3.61864906563e-10
R156_161 366 452 0.000427564578879
L156_161 452 453 1.35902917582e-09
R156_187 358 454 0.000124081417057
L156_187 454 366 2.48357542436e-10
R156_157 366 455 4.81272145771e-05
L156_157 455 456 1.68565415484e-10
R157_188 457 458 0.000124081417057
L157_188 458 456 2.48357542436e-10
R157_162 456 459 0.000427564578879
L157_162 459 460 1.35902917582e-09
R157_158 456 461 4.81272145771e-05
L157_158 461 462 1.68565415484e-10
R158_163 462 463 0.000427564578879
L158_163 463 464 1.35902917582e-09
R158_159 462 465 4.81272145771e-05
L158_159 465 466 1.68565415484e-10
R158_189 467 468 0.000124081417057
L158_189 468 462 2.48357542436e-10
R159_164 466 469 0.000586489947016
L159_164 469 470 1.59414541063e-09
R159_190 471 472 0.000189296975879
L159_190 472 466 3.61864906563e-10
R160_161 364 473 3.25009476713e-05
L160_161 473 453 1.35966114104e-10
R160_165 364 474 0.000586489947016
L160_165 474 475 1.59414541063e-09
R161_162 453 476 3.25009476713e-05
L161_162 476 460 1.35966114104e-10
R161_166 453 477 0.000427564578879
L161_166 477 478 1.35902917582e-09
R162_163 460 479 3.25009476713e-05
L162_163 479 464 1.35966114104e-10
R162_167 460 480 0.000427564578879
L162_167 480 481 1.35902917582e-09
R163_168 464 482 0.000427564578879
L163_168 482 483 1.35902917582e-09
R163_164 464 484 3.25009476713e-05
L163_164 484 470 1.35966114104e-10
R164_169 470 485 0.000586489947016
L164_169 485 486 1.59414541063e-09
R165_170 475 487 0.000586489947016
L165_170 487 370 1.59414541063e-09
R165_166 475 488 3.25009476713e-05
L165_166 488 478 1.35966114104e-10
R166_171 478 489 0.000427564578879
L166_171 489 378 1.35902917582e-09
R166_167 478 490 3.25009476713e-05
L166_167 490 481 1.35966114104e-10
R167_168 481 491 3.25009476713e-05
L167_168 491 483 1.35966114104e-10
R167_172 481 492 0.000427564578879
L167_172 492 382 1.35902917582e-09
R168_169 483 493 3.25009476713e-05
L168_169 493 486 1.35966114104e-10
R168_173 483 494 0.000427564578879
L168_173 494 392 1.35902917582e-09
R169_174 486 495 0.000586489947016
L169_174 495 396 1.59414541063e-09
R170_171 370 496 3.25009476713e-05
L170_171 496 378 1.35966114104e-10
R171_172 378 497 3.25009476713e-05
L171_172 497 382 1.35966114104e-10
R172_173 382 498 3.25009476713e-05
L172_173 498 392 1.35966114104e-10
R173_174 392 499 3.25009476713e-05
L173_174 499 396 1.35966114104e-10
R175_176 310 500 0.000189296975879
L175_176 500 501 3.61864906563e-10
R175_179 310 502 0.000124081417057
L175_179 502 326 2.48357542436e-10
R176_177 501 503 0.000189296975879
L176_177 503 504 3.61864906563e-10
R176_180 501 505 0.000124081417057
L176_180 505 506 2.48357542436e-10
R177_178 504 507 0.000189296975879
L177_178 507 508 3.61864906563e-10
R177_181 504 509 0.000124081417057
L177_181 509 510 2.48357542436e-10
R178_182 508 511 0.000189296975879
L178_182 511 512 3.61864906563e-10
R179_180 326 513 0.000124081417057
L179_180 513 506 2.48357542436e-10
R179_183 326 514 0.000124081417057
L179_183 514 340 2.48357542436e-10
R180_184 506 515 0.000124081417057
L180_184 515 516 2.48357542436e-10
R180_181 506 517 0.000124081417057
L180_181 517 510 2.48357542436e-10
R181_182 510 518 0.000124081417057
L181_182 518 512 2.48357542436e-10
R181_185 510 519 0.000124081417057
L181_185 519 520 2.48357542436e-10
R182_186 512 521 0.000189296975879
L182_186 521 522 3.61864906563e-10
R183_184 340 523 0.000124081417057
L183_184 523 516 2.48357542436e-10
R183_187 340 524 0.000124081417057
L183_187 524 358 2.48357542436e-10
R184_188 516 525 0.000124081417057
L184_188 525 457 2.48357542436e-10
R184_185 516 526 0.000124081417057
L184_185 526 520 2.48357542436e-10
R185_186 520 527 0.000124081417057
L185_186 527 522 2.48357542436e-10
R185_189 520 528 0.000124081417057
L185_189 528 467 2.48357542436e-10
R186_190 522 529 0.000189296975879
L186_190 529 471 3.61864906563e-10
R187_188 358 530 0.000124081417057
L187_188 530 457 2.48357542436e-10
R188_189 457 531 0.000124081417057
L188_189 531 467 2.48357542436e-10
R189_190 467 532 0.000124081417057
L189_190 532 471 2.48357542436e-10
R191_192 533 534 0.000786155274112
L191_192 534 535 2.33233154226e-09
R191_195 533 536 4.81272145771e-05
L191_195 536 537 1.68565415484e-10
R192_193 535 538 0.000786155274112
L192_193 538 539 2.33233154226e-09
R192_196 535 540 2.43027348578e-05
L192_196 540 541 1.14059892238e-10
R193_194 539 542 0.000786155274112
L193_194 542 374 2.33233154226e-09
R193_197 539 543 2.43027348578e-05
L193_197 543 544 1.14059892238e-10
R194_198 374 545 2.43027348578e-05
L194_198 545 401 1.14059892238e-10
R195_199 537 546 4.81272145771e-05
L195_199 546 547 1.68565415484e-10
R195_196 537 548 0.00057703109907
L195_196 548 541 2.02721469163e-09
R196_200 541 549 2.43027348578e-05
L196_200 549 550 1.14059892238e-10
R196_197 541 551 0.00057703109907
L196_197 551 544 2.02721469163e-09
R197_198 544 552 0.00057703109907
L197_198 552 401 2.02721469163e-09
R197_201 544 553 2.43027348578e-05
L197_201 553 554 1.14059892238e-10
R198_202 401 555 2.43027348578e-05
L198_202 555 416 1.14059892238e-10
R199_200 547 556 0.00057703109907
L199_200 556 550 2.02721469163e-09
R199_203 547 557 4.81272145771e-05
L199_203 557 558 1.68565415484e-10
R200_204 550 559 2.43027348578e-05
L200_204 559 560 1.14059892238e-10
R200_201 550 561 0.00057703109907
L200_201 561 554 2.02721469163e-09
R201_202 554 562 0.00057703109907
L201_202 562 416 2.02721469163e-09
R201_205 554 563 2.43027348578e-05
L201_205 563 564 1.14059892238e-10
R202_206 416 565 2.43027348578e-05
L202_206 565 431 1.14059892238e-10
R203_207 558 566 4.81272145771e-05
L203_207 566 567 1.68565415484e-10
R203_204 558 568 0.00057703109907
L203_204 568 560 2.02721469163e-09
R204_208 560 569 2.43027348578e-05
L204_208 569 570 1.14059892238e-10
R204_205 560 571 0.00057703109907
L204_205 571 564 2.02721469163e-09
R205_206 564 572 0.00057703109907
L205_206 572 431 2.02721469163e-09
R205_209 564 573 2.43027348578e-05
L205_209 573 574 1.14059892238e-10
R206_210 431 575 2.43027348578e-05
L206_210 575 447 1.14059892238e-10
R207_208 567 576 0.000786155274112
L207_208 576 570 2.33233154226e-09
R208_209 570 577 0.000786155274112
L208_209 577 574 2.33233154226e-09
R209_210 574 578 0.000786155274112
L209_210 578 447 2.33233154226e-09
K0 L175_176 L167_168 0.0441
K1 L175_176 L74_90 0.0192
K2 L175_176 L199_200 0.018
K3 L175_176 L115_179 0.2134
K4 L175_176 L128_129 0.0391
K5 L175_176 L147_148 0.0173
K6 L175_176 L196_197 0.0207
K7 L175_176 L73_74 0.0252
K8 L175_176 L172_173 0.0341
K9 L175_176 L13_14 0.1117
K10 L175_176 L23_24 0.0794
K11 L175_176 L158_159 0.0792
K12 L175_176 L77_78 0.0221
K13 L175_176 L72_73 0.023
K14 L175_176 L136_198 0.0253
K15 L175_176 L163_164 0.0606
K16 L175_176 L144_145 0.0182
K17 L175_176 L120_183 0.1362
K18 L175_176 L91_92 0.0192
K19 L175_176 L151_152 0.0138
K20 L175_176 L126_127 0.0231
K21 L175_176 L22_23 0.081
K22 L175_176 L204_205 0.0194
K23 L175_176 L99_100 0.0172
K24 L175_176 L153_154 0.0138
K25 L175_176 L34_35 0.0429
K26 L175_176 L41_42 0.0255
K27 L175_176 L16_61 0.0636
K28 L175_176 L146_206 0.023
K29 L175_176 L197_198 0.0231
K30 L175_176 L192_193 0.0198
K31 L175_176 L88_89 0.0206
K32 L175_176 L31_32 0.0435
K33 L175_176 L143_144 0.0183
K34 L175_176 L200_201 0.02
K35 L175_176 L205_206 0.0213
K36 L175_176 L36_37 0.0338
K37 L175_176 L131_132 0.0257
K38 L175_176 L100_101 0.0172
K39 L175_176 L203_204 0.0175
K40 L175_176 L92_93 0.0191
K41 L175_176 L81_82 0.0193
K42 L175_176 L131_194 0.0245
K43 L175_176 L148_149 0.0173
K44 L175_176 L19_20 0.0801
K45 L175_176 L187_188 0.1028
K46 L175_176 L102_103 0.0138
K47 L175_176 L160_161 0.0624
K48 L175_176 L60_61 0.0424
K49 L175_176 L64_65 0.0387
K50 L175_176 L133_134 0.0257
K51 L175_176 L26_27 0.0607
K52 L175_176 L165_166 0.0441
K53 L175_176 L170_171 0.0341
K54 L175_176 L193_194 0.0223
K55 L175_176 L63_64 0.0289
K56 L175_176 L21_65 0.0564
K57 L175_176 L121_122 0.025
K58 L175_176 L119_120 0.0696
K59 L175_176 L9_10 0.1153
K60 L175_176 L43_44 0.0255
K61 L175_176 L208_209 0.0176
K62 L175_176 L195_196 0.0185
K63 L175_176 L67_68 0.0198
K64 L175_176 L33_34 0.0435
K65 L175_176 L134_135 0.0255
K66 L175_176 L41_69 0.0244
K67 L175_176 L171_172 0.0342
K68 L175_176 L104_105 0.0137
K69 L175_176 L151_210 0.0207
K70 L175_176 L79_94 0.0182
K71 L175_176 L37_38 0.0339
K72 L175_176 L75_76 0.0179
K73 L175_176 L112_113 0.0323
K74 L175_176 L183_184 0.1487
K75 L175_176 L59_60 0.0314
K76 L175_176 L11_57 0.0674
K77 L175_176 L38_39 0.0338
K78 L175_176 L71_72 0.0207
K79 L175_176 L27_28 0.0613
K80 L175_176 L96_97 0.0181
K81 L175_176 L78_79 0.024
K82 L175_176 L44_45 0.0254
K83 L175_176 L29_30 0.0591
K84 L175_176 L76_77 0.02
K85 L175_176 L114_115 0.0727
K86 L175_176 L166_167 0.0443
K87 L175_176 L185_186 0.1116
K88 L175_176 L16_17 0.0879
K89 L175_176 L188_189 0.0983
K90 L175_176 L86_87 0.0176
K91 L175_176 L118_119 0.044
K92 L175_176 L180_181 0.2134
K93 L175_176 L6_53 0.0702
K94 L175_176 L149_150 0.0172
K95 L175_176 L98_99 0.0173
K96 L175_176 L55_56 0.0318
K97 L175_176 L132_133 0.0257
K98 L175_176 L84_98 0.0172
K99 L175_176 L124_125 0.0655
K100 L175_176 L113_114 0.0447
K101 L175_176 L52_53 0.0441
K102 L175_176 L80_81 0.0175
K103 L175_176 L17_18 0.0911
K104 L175_176 L141_202 0.0241
K105 L175_176 L87_88 0.0192
K106 L175_176 L146_147 0.0173
K107 L175_176 L209_210 0.0193
K108 L175_176 L94_95 0.0182
K109 L175_176 L136_137 0.0193
K110 L175_176 L127_128 0.0291
K111 L175_176 L138_139 0.0193
K112 L175_176 L42_43 0.0256
K113 L175_176 L181_182 0.1437
K114 L175_176 L28_29 0.0607
K115 L175_176 L157_158 0.0843
K116 L175_176 L122_123 0.0316
K117 L175_176 L103_104 0.0138
K118 L175_176 L66_67 0.0175
K119 L175_176 L129_130 0.0579
K120 L175_176 L21_22 0.0794
K121 L175_176 L117_118 0.032
K122 L175_176 L51_52 0.0321
K123 L175_176 L56_57 0.0434
K124 L175_176 L24_25 0.0752
K125 L175_176 L116_117 0.0252
K126 L175_176 L6_7 0.1426
K127 L175_176 L173_174 0.0338
K128 L175_176 L154_155 0.0137
K129 L175_176 L32_33 0.0437
K130 L175_176 L95_96 0.0182
K131 L175_176 L85_86 0.016
K132 L175_176 L7_8 0.1566
K133 L175_176 L82_83 0.0212
K134 L175_176 L14_15 0.0969
K135 L175_176 L184_185 0.1362
K136 L175_176 L141_142 0.0183
K137 L175_176 L62_63 0.023
K138 L175_176 L125_187 0.0983
K139 L175_176 L58_59 0.0249
K140 L175_176 L70_71 0.0184
K141 L175_176 L68_69 0.0222
K142 L175_176 L89_102 0.0138
K143 L175_176 L8_9 0.1426
K144 L175_176 L50_51 0.0252
K145 L175_176 L168_169 0.0434
K146 L175_176 L83_84 0.0229
K147 L175_176 L90_91 0.0192
K148 L175_176 L139_140 0.0192
K149 L175_176 L161_162 0.063
K150 L175_176 L111_112 0.0253
K151 L175_176 L162_163 0.0624
K152 L175_176 L137_138 0.0193
K153 L175_176 L179_180 0.2697
K154 L175_176 L12_13 0.1183
K155 L175_176 L207_208 0.016
K156 L175_176 L142_143 0.0183
K157 L175_176 L123_124 0.0429
K158 L175_176 L152_153 0.0138
K159 L175_176 L191_192 0.0176
K160 L175_176 L39_40 0.0335
K161 L175_176 L18_19 0.0879
K162 L175_176 L130_156 0.0843
K163 L175_176 L156_157 0.0863
K164 L175_176 L189_190 0.0877
K165 L175_176 L11_12 0.1117
K166 L175_176 L54_55 0.0251
K167 L175_176 L201_202 0.0222
K168 L1_49 L167_168 0.0628
K169 L1_49 L74_90 0.0301
K170 L1_49 L199_200 0.0336
K171 L1_49 L115_179 0.1668
K172 L1_49 L128_129 0.1173
K173 L1_49 L147_148 0.0267
K174 L1_49 L196_197 0.0385
K175 L1_49 L73_74 0.0425
K176 L1_49 L172_173 0.0504
K177 L1_49 L13_14 0.1086
K178 L1_49 L23_24 0.0984
K179 L1_49 L158_159 0.0863
K180 L1_49 L77_78 0.0393
K181 L1_49 L72_73 0.0414
K182 L1_49 L136_198 0.0423
K183 L1_49 L163_164 0.0771
K184 L1_49 L144_145 0.0274
K185 L1_49 L120_183 0.1412
K186 L1_49 L91_92 0.0294
K187 L1_49 L151_152 0.0215
K188 L1_49 L126_127 0.0545
K189 L1_49 L22_23 0.1087
K190 L1_49 L204_205 0.0351
K191 L1_49 L99_100 0.0266
K192 L1_49 L153_154 0.0211
K193 L1_49 L34_35 0.0612
K194 L1_49 L41_42 0.04
K195 L1_49 L16_61 0.2072
K196 L1_49 L146_206 0.038
K197 L1_49 L197_198 0.0412
K198 L1_49 L192_193 0.0372
K199 L1_49 L88_89 0.0342
K200 L1_49 L31_32 0.0674
K201 L1_49 L143_144 0.0278
K202 L1_49 L200_201 0.0367
K203 L1_49 L205_206 0.0372
K204 L1_49 L36_37 0.0527
K205 L1_49 L131_132 0.0397
K206 L1_49 L100_101 0.0262
K207 L1_49 L203_204 0.0323
K208 L1_49 L92_93 0.029
K209 L1_49 L81_82 0.0352
K210 L1_49 L131_194 0.0412
K211 L1_49 L148_149 0.0265
K212 L1_49 L19_20 0.084
K213 L1_49 L187_188 0.1049
K214 L1_49 L102_103 0.0214
K215 L1_49 L160_161 0.0906
K216 L1_49 L60_61 0.1475
K217 L1_49 L64_65 0.123
K218 L1_49 L133_134 0.0387
K219 L1_49 L26_27 0.0929
K220 L1_49 L165_166 0.0665
K221 L1_49 L170_171 0.0523
K222 L1_49 L193_194 0.0401
K223 L1_49 L63_64 0.0785
K224 L1_49 L21_65 0.1605
K225 L1_49 L121_122 0.0595
K226 L1_49 L119_120 0.2334
K227 L1_49 L9_10 0.0972
K228 L1_49 L43_44 0.0389
K229 L1_49 L208_209 0.0317
K230 L1_49 L195_196 0.0349
K231 L1_49 L67_68 0.0373
K232 L1_49 L33_34 0.0636
K233 L1_49 L134_135 0.038
K234 L1_49 L41_69 0.0414
K235 L1_49 L171_172 0.0515
K236 L1_49 L104_105 0.021
K237 L1_49 L151_210 0.0341
K238 L1_49 L79_94 0.0285
K239 L1_49 L37_38 0.0519
K240 L1_49 L75_76 0.0337
K241 L1_49 L112_113 0.0923
K242 L1_49 L183_184 0.1201
K243 L1_49 L59_60 0.0877
K244 L1_49 L11_57 0.2809
K245 L1_49 L38_39 0.0508
K246 L1_49 L71_72 0.0386
K247 L1_49 L27_28 0.0886
K248 L1_49 L96_97 0.0275
K249 L1_49 L78_79 0.0402
K250 L1_49 L44_45 0.0382
K251 L1_49 L29_30 0.0785
K252 L1_49 L76_77 0.0369
K253 L1_49 L114_115 0.2931
K254 L1_49 L166_167 0.0649
K255 L1_49 L185_186 0.0872
K256 L1_49 L16_17 0.1286
K257 L1_49 L188_189 0.0921
K258 L1_49 L86_87 0.0318
K259 L1_49 L118_119 0.1576
K260 L1_49 L180_181 0.1103
K261 L1_49 L6_53 0.4331
K262 L1_49 L149_150 0.0261
K263 L1_49 L98_99 0.0268
K264 L1_49 L55_56 0.0917
K265 L1_49 L132_133 0.0393
K266 L1_49 L84_98 0.027
K267 L1_49 L124_125 0.1866
K268 L1_49 L113_114 0.1765
K269 L1_49 L52_53 0.2045
K270 L1_49 L80_81 0.0324
K271 L1_49 L17_18 0.112
K272 L1_49 L141_202 0.04
K273 L1_49 L87_88 0.0335
K274 L1_49 L146_147 0.0269
K275 L1_49 L209_210 0.0334
K276 L1_49 L94_95 0.0282
K277 L1_49 L136_137 0.03
K278 L1_49 L127_128 0.077
K279 L1_49 L138_139 0.0293
K280 L1_49 L42_43 0.0395
K281 L1_49 L181_182 0.0922
K282 L1_49 L28_29 0.0836
K283 L1_49 L157_158 0.0951
K284 L1_49 L122_123 0.0858
K285 L1_49 L103_104 0.0212
K286 L1_49 L66_67 0.0336
K287 L1_49 L129_130 0.1492
K288 L1_49 L21_22 0.1188
K289 L1_49 L117_118 0.0896
K290 L1_49 L51_52 0.0947
K291 L1_49 L56_57 0.1727
K292 L1_49 L24_25 0.0887
K293 L1_49 L116_117 0.0607
K294 L1_49 L6_7 0.213
K295 L1_49 L173_174 0.0492
K296 L1_49 L154_155 0.0209
K297 L1_49 L32_33 0.0657
K298 L1_49 L95_96 0.0279
K299 L1_49 L85_86 0.0294
K300 L1_49 L7_8 0.1546
K301 L1_49 L82_83 0.0373
K302 L1_49 L14_15 0.0913
K303 L1_49 L184_185 0.1019
K304 L1_49 L141_142 0.0284
K305 L1_49 L62_63 0.055
K306 L1_49 L125_187 0.1183
K307 L1_49 L58_59 0.0601
K308 L1_49 L70_71 0.035
K309 L1_49 L68_69 0.0403
K310 L1_49 L89_102 0.0216
K311 L1_49 L8_9 0.1194
K312 L1_49 L50_51 0.0621
K313 L1_49 L168_169 0.0605
K314 L1_49 L83_84 0.0381
K315 L1_49 L90_91 0.0298
K316 L1_49 L139_140 0.0289
K317 L1_49 L161_162 0.0866
K318 L1_49 L111_112 0.0615
K319 L1_49 L162_163 0.082
K320 L1_49 L137_138 0.0297
K321 L1_49 L179_180 0.135
K322 L1_49 L12_13 0.132
K323 L1_49 L207_208 0.0293
K324 L1_49 L142_143 0.0281
K325 L1_49 L123_124 0.1387
K326 L1_49 L152_153 0.0213
K327 L1_49 L191_192 0.0335
K328 L1_49 L39_40 0.0496
K329 L1_49 L18_19 0.0967
K330 L1_49 L130_156 0.1131
K331 L1_49 L156_157 0.1043
K332 L1_49 L189_190 0.0809
K333 L1_49 L11_12 0.1616
K334 L1_49 L54_55 0.0613
K335 L1_49 L201_202 0.0391
K336 L175_179 L24_29 0.086
K337 L175_179 L181_185 0.1284
K338 L175_179 L140_145 0.0192
K339 L175_179 L1_6 0.1161
K340 L175_179 L13_18 0.1226
K341 L175_179 L35_40 0.0408
K342 L175_179 L23_28 0.093
K343 L175_179 L73_78 0.0308
K344 L175_179 L184_188 0.1439
K345 L175_179 L6_11 0.1131
K346 L175_179 L197_201 0.0278
K347 L175_179 L76_81 0.024
K348 L175_179 L163_168 0.061
K349 L175_179 L91_95 0.0234
K350 L175_179 L144_149 0.0221
K351 L175_179 L130_160 0.156
K352 L175_179 L4_9 0.1173
K353 L175_179 L26_31 0.0763
K354 L175_179 L202_206 0.0295
K355 L175_179 L109_114 0.0671
K356 L175_179 L57_61 0.0643
K357 L175_179 L99_103 0.021
K358 L175_179 L164_169 0.0544
K359 L175_179 L195_199 0.0197
K360 L175_179 L31_36 0.052
K361 L175_179 L45_93 0.0202
K362 L175_179 L106_111 0.0272
K363 L175_179 L34_39 0.045
K364 L175_179 L148_153 0.0211
K365 L175_179 L201_205 0.0268
K366 L175_179 L192_196 0.0255
K367 L175_179 L53_57 0.0655
K368 L175_179 L69_73 0.0322
K369 L175_179 L200_204 0.024
K370 L175_179 L150_155 0.0172
K371 L175_179 L145_150 0.0181
K372 L175_179 L118_123 0.0455
K373 L175_179 L30_35 0.0534
K374 L175_179 L194_198 0.0324
K375 L175_179 L131_136 0.0314
K376 L175_179 L101_105 0.0172
K377 L175_179 L46_50 0.0271
K378 L175_179 L196_200 0.0247
K379 L175_179 L92_96 0.0232
K380 L175_179 L81_86 0.0233
K381 L175_179 L19_24 0.0884
K382 L175_179 L120_125 0.1129
K383 L175_179 L8_13 0.1438
K384 L175_179 L157_188 0.1124
K385 L175_179 L133_138 0.025
K386 L175_179 L60_64 0.0445
K387 L175_179 L72_77 0.0277
K388 L175_179 L198_202 0.0309
K389 L175_179 L193_197 0.0288
K390 L175_179 L168_173 0.0455
K391 L175_179 L20_25 0.0657
K392 L175_179 L167_172 0.0465
K393 L175_179 L121_126 0.0268
K394 L175_179 L119_124 0.0654
K395 L175_179 L97_101 0.0181
K396 L175_179 L110_115 0.1262
K397 L175_179 L113_118 0.0459
K398 L175_179 L141_146 0.0281
K399 L175_179 L182_186 0.0861
K400 L175_179 L100_104 0.0209
K401 L175_179 L9_14 0.1127
K402 L175_179 L138_143 0.0235
K403 L175_179 L33_38 0.0459
K404 L175_179 L18_23 0.1015
K405 L175_179 L134_139 0.0247
K406 L175_179 L124_129 0.0634
K407 L175_179 L107_112 0.0351
K408 L175_179 L78_83 0.0294
K409 L175_179 L112_117 0.0351
K410 L175_179 L40_45 0.0328
K411 L175_179 L136_141 0.0297
K412 L175_179 L59_63 0.0344
K413 L175_179 L5_10 0.0811
K414 L175_179 L71_76 0.0247
K415 L175_179 L15_20 0.073
K416 L175_179 L51_55 0.0349
K417 L175_179 L58_62 0.0267
K418 L175_179 L67_71 0.0254
K419 L175_179 L36_41 0.0393
K420 L175_179 L48_52 0.0457
K421 L175_179 L29_34 0.0598
K422 L175_179 L206_210 0.0282
K423 L175_179 L41_74 0.0313
K424 L175_179 L131_170 0.0397
K425 L175_179 L28_33 0.0619
K426 L175_179 L205_209 0.0258
K427 L175_179 L191_195 0.0203
K428 L175_179 L178_182 0.0891
K429 L175_179 L180_184 0.1832
K430 L175_179 L3_8 0.1536
K431 L175_179 L157_162 0.098
K432 L175_179 L149_154 0.0209
K433 L175_179 L203_207 0.0187
K434 L175_179 L66_70 0.0203
K435 L175_179 L117_122 0.0349
K436 L175_179 L114_119 0.0667
K437 L175_179 L158_189 0.0953
K438 L175_179 L38_43 0.0364
K439 L175_179 L47_51 0.0349
K440 L175_179 L55_59 0.0347
K441 L175_179 L135_174 0.033
K442 L175_179 L160_165 0.0794
K443 L175_179 L52_56 0.0455
K444 L175_179 L115_120 0.1224
K445 L175_179 L80_85 0.0186
K446 L175_179 L10_15 0.0789
K447 L175_179 L16_21 0.0959
K448 L175_179 L158_163 0.0898
K449 L175_179 L185_189 0.1124
K450 L175_179 L96_100 0.022
K451 L175_179 L49_53 0.0659
K452 L175_179 L186_190 0.0787
K453 L175_179 L82_87 0.0257
K454 L175_179 L125_130 0.1012
K455 L175_179 L108_113 0.0461
K456 L175_179 L159_164 0.077
K457 L175_179 L84_89 0.0266
K458 L175_179 L68_72 0.0287
K459 L175_179 L169_174 0.0412
K460 L175_179 L204_208 0.0233
K461 L175_179 L25_30 0.0742
K462 L175_179 L133_172 0.0366
K463 L175_179 L14_19 0.1015
K464 L175_179 L44_92 0.0246
K465 L175_179 L21_26 0.1339
K466 L175_179 L95_99 0.0221
K467 L175_179 L116_121 0.027
K468 L175_179 L74_79 0.0296
K469 L175_179 L165_170 0.053
K470 L175_179 L199_203 0.0192
K471 L175_179 L75_80 0.0192
K472 L175_179 L143_148 0.0222
K473 L175_179 L70_75 0.0197
K474 L175_179 L50_54 0.027
K475 L175_179 L79_84 0.028
K476 L175_179 L56_60 0.0451
K477 L175_179 L159_190 0.0696
K478 L175_179 L93_97 0.0191
K479 L175_179 L134_173 0.0362
K480 L175_179 L139_144 0.0233
K481 L175_179 L83_88 0.0282
K482 L175_179 L177_181 0.1354
K483 L175_179 L176_180 0.2054
K484 L175_179 L111_116 0.0271
K485 L175_179 L162_167 0.0633
K486 L175_179 L43_91 0.0248
K487 L175_179 L122_127 0.0346
K488 L175_179 L135_140 0.0203
K489 L175_179 L39_44 0.0359
K490 L175_179 L123_128 0.0448
K491 L175_179 L54_58 0.0269
K492 L175_179 L146_151 0.0267
K493 L175_179 L61_65 0.0624
K494 L175_179 L11_16 0.1056
K495 L175_179 L77_82 0.0267
K496 L172_173 L167_168 0.1279
K497 L172_173 L74_90 0.0736
K498 L172_173 L199_200 0.0362
K499 L172_173 L115_179 0.0415
K500 L172_173 L128_129 0.0551
K501 L172_173 L147_148 0.0606
K502 L172_173 L196_197 0.0449
K503 L172_173 L73_74 0.0737
K504 L172_173 L1_2 0.0335
K505 L172_173 L23_24 0.0627
K506 L172_173 L158_159 0.0632
K507 L172_173 L77_78 0.0542
K508 L172_173 L72_73 0.0564
K509 L172_173 L136_198 0.0747
K510 L172_173 L163_164 0.0827
K511 L172_173 L144_145 0.0683
K512 L172_173 L120_183 0.045
K513 L172_173 L91_92 0.0766
K514 L172_173 L160_161 0.0811
K515 L172_173 L151_152 0.0456
K516 L172_173 L126_127 0.0371
K517 L172_173 L22_23 0.0624
K518 L172_173 L109_110 0.0508
K519 L172_173 L204_205 0.0426
K520 L172_173 L99_100 0.0599
K521 L172_173 L153_154 0.0466
K522 L172_173 L4_5 0.0338
K523 L172_173 L34_35 0.1203
K524 L172_173 L41_42 0.1106
K525 L172_173 L16_61 0.0636
K526 L172_173 L43_44 0.118
K527 L172_173 L146_206 0.0653
K528 L172_173 L197_198 0.0568
K529 L172_173 L192_193 0.0426
K530 L172_173 L88_89 0.0574
K531 L172_173 L31_32 0.1153
K532 L172_173 L143_144 0.0688
K533 L172_173 L200_201 0.0438
K534 L172_173 L205_206 0.0523
K535 L172_173 L131_132 0.1157
K536 L172_173 L100_101 0.0596
K537 L172_173 L203_204 0.0355
K538 L172_173 L92_93 0.0758
K539 L172_173 L81_82 0.0424
K540 L172_173 L13_14 0.0451
K541 L172_173 L131_194 0.0733
K542 L172_173 L148_149 0.061
K543 L172_173 L19_20 0.049
K544 L172_173 L187_188 0.0496
K545 L172_173 L165_166 0.12
K546 L172_173 L102_103 0.0456
K547 L172_173 L106_107 0.0336
K548 L172_173 L60_61 0.0545
K549 L172_173 L64_65 0.0546
K550 L172_173 L133_134 0.1244
K551 L172_173 L8_9 0.0417
K552 L172_173 L107_108 0.0391
K553 L172_173 L193_194 0.0545
K554 L172_173 L63_64 0.0447
K555 L172_173 L21_65 0.0655
K556 L172_173 L121_122 0.0385
K557 L172_173 L119_120 0.0595
K558 L172_173 L9_10 0.0416
K559 L172_173 L46_47 0.0335
K560 L172_173 L208_209 0.0389
K561 L172_173 L195_196 0.0369
K562 L172_173 L67_68 0.0424
K563 L172_173 L33_34 0.1221
K564 L172_173 L134_135 0.122
K565 L172_173 L41_69 0.0721
K566 L172_173 L104_105 0.0456
K567 L172_173 L151_210 0.0579
K568 L172_173 L79_94 0.0653
K569 L172_173 L184_185 0.0456
K570 L172_173 L75_76 0.0361
K571 L172_173 L112_113 0.0423
K572 L172_173 L183_184 0.0454
K573 L172_173 L59_60 0.0456
K574 L172_173 L11_57 0.059
K575 L172_173 L51_52 0.0421
K576 L172_173 L108_109 0.0452
K577 L172_173 L71_72 0.0447
K578 L172_173 L27_28 0.0811
K579 L172_173 L78_79 0.069
K580 L172_173 L44_45 0.116
K581 L172_173 L47_48 0.0389
K582 L172_173 L29_30 0.0811
K583 L172_173 L76_77 0.0436
K584 L172_173 L114_115 0.0554
K585 L172_173 L166_167 0.1258
K586 L172_173 L185_186 0.0454
K587 L172_173 L177_178 0.0341
K588 L172_173 L16_17 0.0484
K589 L172_173 L188_189 0.0498
K590 L172_173 L86_87 0.0387
K591 L172_173 L118_119 0.0519
K592 L172_173 L176_177 0.0342
K593 L172_173 L3_4 0.0339
K594 L172_173 L6_53 0.055
K595 L172_173 L149_150 0.0606
K596 L172_173 L2_3 0.0338
K597 L172_173 L98_99 0.0596
K598 L172_173 L55_56 0.0438
K599 L172_173 L132_133 0.122
K600 L172_173 L84_98 0.0585
K601 L172_173 L48_49 0.0449
K602 L172_173 L110_175 0.0338
K603 L172_173 L124_125 0.0642
K604 L172_173 L113_114 0.0491
K605 L172_173 L52_53 0.0488
K606 L172_173 L80_81 0.0354
K607 L172_173 L17_18 0.049
K608 L172_173 L141_202 0.0698
K609 L172_173 L87_88 0.0469
K610 L172_173 L146_147 0.0595
K611 L172_173 L209_210 0.0472
K612 L172_173 L94_95 0.0668
K613 L172_173 L136_137 0.0757
K614 L172_173 L127_128 0.0449
K615 L172_173 L138_139 0.079
K616 L172_173 L42_43 0.116
K617 L172_173 L181_182 0.0419
K618 L172_173 L28_29 0.0817
K619 L172_173 L157_158 0.0635
K620 L172_173 L122_123 0.0459
K621 L172_173 L96_97 0.0668
K622 L172_173 L66_67 0.0346
K623 L172_173 L129_130 0.0663
K624 L172_173 L21_22 0.0615
K625 L172_173 L117_118 0.0441
K626 L172_173 L56_57 0.0516
K627 L172_173 L24_25 0.0624
K628 L172_173 L116_117 0.0374
K629 L172_173 L6_7 0.0412
K630 L172_173 L154_155 0.0463
K631 L172_173 L32_33 0.1203
K632 L172_173 L95_96 0.0673
K633 L172_173 L85_86 0.0325
K634 L172_173 L7_8 0.0416
K635 L172_173 L82_83 0.052
K636 L172_173 L14_15 0.045
K637 L172_173 L141_142 0.0667
K638 L172_173 L62_63 0.037
K639 L172_173 L125_187 0.049
K640 L172_173 L58_59 0.0384
K641 L172_173 L103_104 0.0459
K642 L172_173 L70_71 0.0367
K643 L172_173 L68_69 0.0541
K644 L172_173 L180_181 0.042
K645 L172_173 L89_102 0.0449
K646 L172_173 L26_27 0.0796
K647 L172_173 L50_51 0.0362
K648 L172_173 L168_169 0.1258
K649 L172_173 L83_84 0.0646
K650 L172_173 L90_91 0.0758
K651 L172_173 L139_140 0.0781
K652 L172_173 L161_162 0.0827
K653 L172_173 L111_112 0.0363
K654 L172_173 L162_163 0.0832
K655 L172_173 L137_138 0.0781
K656 L172_173 L179_180 0.0419
K657 L172_173 L12_13 0.045
K658 L172_173 L207_208 0.0326
K659 L172_173 L142_143 0.0683
K660 L172_173 L123_124 0.0549
K661 L172_173 L152_153 0.0463
K662 L172_173 L191_192 0.0348
K663 L172_173 L18_19 0.0492
K664 L172_173 L130_156 0.0623
K665 L172_173 L156_157 0.0632
K666 L172_173 L189_190 0.0496
K667 L172_173 L11_12 0.0445
K668 L172_173 L54_55 0.0373
K669 L172_173 L201_202 0.0546
K670 L208_209 L167_168 0.0354
K671 L208_209 L74_90 0.0375
K672 L208_209 L115_179 0.022
K673 L208_209 L147_148 0.0362
K674 L208_209 L196_197 0.1829
K675 L208_209 L73_74 0.0837
K676 L208_209 L1_2 0.018
K677 L208_209 L23_24 0.0275
K678 L208_209 L158_159 0.0267
K679 L208_209 L77_78 0.1479
K680 L208_209 L72_73 0.13
K681 L208_209 L136_198 0.0854
K682 L208_209 L163_164 0.0312
K683 L208_209 L144_145 0.0316
K684 L208_209 L120_183 0.0228
K685 L208_209 L91_92 0.0329
K686 L208_209 L160_161 0.0343
K687 L208_209 L126_127 0.0403
K688 L208_209 L22_23 0.0282
K689 L208_209 L109_110 0.0318
K690 L208_209 L204_205 0.3407
K691 L208_209 L99_100 0.0337
K692 L208_209 L4_5 0.0168
K693 L208_209 L34_35 0.034
K694 L208_209 L41_42 0.0428
K695 L208_209 L16_61 0.0376
K696 L208_209 L43_44 0.0381
K697 L208_209 L146_206 0.0934
K698 L208_209 L197_198 0.1369
K699 L208_209 L192_193 0.1605
K700 L208_209 L31_32 0.0382
K701 L208_209 L143_144 0.0336
K702 L208_209 L200_201 0.2387
K703 L208_209 L205_206 0.1877
K704 L208_209 L36_37 0.0425
K705 L208_209 L131_132 0.0431
K706 L208_209 L100_101 0.0317
K707 L208_209 L203_204 0.1877
K708 L208_209 L92_93 0.031
K709 L208_209 L81_82 0.2623
K710 L208_209 L13_14 0.0216
K711 L208_209 L131_194 0.0785
K712 L208_209 L148_149 0.0339
K713 L208_209 L19_20 0.0216
K714 L208_209 L187_188 0.0229
K715 L208_209 L165_166 0.0383
K716 L208_209 L128_129 0.0403
K717 L208_209 L106_107 0.0335
K718 L208_209 L60_61 0.0401
K719 L208_209 L133_134 0.0383
K720 L208_209 L8_9 0.0209
K721 L208_209 L107_108 0.0342
K722 L208_209 L170_171 0.0428
K723 L208_209 L193_194 0.123
K724 L208_209 L63_64 0.0412
K725 L208_209 L21_65 0.0372
K726 L208_209 L121_122 0.0403
K727 L208_209 L119_120 0.036
K728 L208_209 L9_10 0.0204
K729 L208_209 L46_47 0.0334
K730 L208_209 L195_196 0.1369
K731 L208_209 L67_68 0.1492
K732 L208_209 L33_34 0.0353
K733 L208_209 L134_135 0.0363
K734 L208_209 L41_69 0.077
K735 L208_209 L171_172 0.0407
K736 L208_209 L180_181 0.0209
K737 L208_209 L79_94 0.0381
K738 L208_209 L37_38 0.0406
K739 L208_209 L75_76 0.1479
K740 L208_209 L112_113 0.0371
K741 L208_209 L183_184 0.0222
K742 L208_209 L59_60 0.0411
K743 L208_209 L11_57 0.0359
K744 L208_209 L38_39 0.0387
K745 L208_209 L108_109 0.0335
K746 L208_209 L71_72 0.1684
K747 L208_209 L27_28 0.0331
K748 L208_209 L78_79 0.0878
K749 L208_209 L44_45 0.0361
K750 L208_209 L47_48 0.0341
K751 L208_209 L29_30 0.0311
K752 L208_209 L76_77 0.2081
K753 L208_209 L114_115 0.0345
K754 L208_209 L166_167 0.0368
K755 L208_209 L185_186 0.0211
K756 L208_209 L177_178 0.0168
K757 L208_209 L16_17 0.0235
K758 L208_209 L188_189 0.0223
K759 L208_209 L181_182 0.0204
K760 L208_209 L118_119 0.0383
K761 L208_209 L176_177 0.0172
K762 L208_209 L3_4 0.0172
K763 L208_209 L6_53 0.0344
K764 L208_209 L149_150 0.0318
K765 L208_209 L2_3 0.0176
K766 L208_209 L98_99 0.036
K767 L208_209 L55_56 0.039
K768 L208_209 L132_133 0.0406
K769 L208_209 L84_98 0.0386
K770 L208_209 L48_49 0.0334
K771 L208_209 L110_175 0.018
K772 L208_209 L124_125 0.0377
K773 L208_209 L113_114 0.0364
K774 L208_209 L52_53 0.0363
K775 L208_209 L80_81 0.1674
K776 L208_209 L17_18 0.0229
K777 L208_209 L141_202 0.0898
K778 L208_209 L62_63 0.0401
K779 L208_209 L146_147 0.0389
K780 L208_209 L94_95 0.0356
K781 L208_209 L136_137 0.0377
K782 L208_209 L127_128 0.0414
K783 L208_209 L138_139 0.0331
K784 L208_209 L42_43 0.0403
K785 L208_209 L28_29 0.0321
K786 L208_209 L157_158 0.0275
K787 L208_209 L122_123 0.0413
K788 L208_209 L96_97 0.0314
K789 L208_209 L66_67 0.1173
K790 L208_209 L129_130 0.0373
K791 L208_209 L64_65 0.0401
K792 L208_209 L117_118 0.0391
K793 L208_209 L51_52 0.037
K794 L208_209 L56_57 0.0381
K795 L208_209 L24_25 0.0267
K796 L208_209 L116_117 0.0383
K797 L208_209 L6_7 0.0219
K798 L208_209 L173_174 0.0371
K799 L208_209 L32_33 0.0367
K800 L208_209 L95_96 0.0334
K801 L208_209 L21_22 0.0291
K802 L208_209 L7_8 0.0214
K803 L208_209 L82_83 0.1674
K804 L208_209 L14_15 0.021
K805 L208_209 L184_185 0.0216
K806 L208_209 L141_142 0.0384
K807 L208_209 L199_200 0.1593
K808 L208_209 L125_187 0.0236
K809 L208_209 L58_59 0.0401
K810 L208_209 L70_71 0.13
K811 L208_209 L68_69 0.1173
K812 L208_209 L26_27 0.0342
K813 L208_209 L50_51 0.0363
K814 L208_209 L168_169 0.0341
K815 L208_209 L83_84 0.0911
K816 L208_209 L90_91 0.0351
K817 L208_209 L139_140 0.0312
K818 L208_209 L161_162 0.0332
K819 L208_209 L111_112 0.0364
K820 L208_209 L162_163 0.0322
K821 L208_209 L137_138 0.0353
K822 L208_209 L179_180 0.0215
K823 L208_209 L12_13 0.0221
K824 L208_209 L142_143 0.0358
K825 L208_209 L123_124 0.0403
K826 L208_209 L191_192 0.123
K827 L208_209 L39_40 0.037
K828 L208_209 L18_19 0.0223
K829 L208_209 L130_156 0.0291
K830 L208_209 L156_157 0.0283
K831 L208_209 L189_190 0.0217
K832 L208_209 L11_12 0.0227
K833 L208_209 L54_55 0.0381
K834 L208_209 L201_202 0.1593
K835 L77_78 L167_168 0.0477
K836 L77_78 L74_90 0.0589
K837 L77_78 L115_179 0.0276
K838 L77_78 L128_129 0.0493
K839 L77_78 L196_197 0.1743
K840 L77_78 L73_74 0.1933
K841 L77_78 L1_2 0.0227
K842 L77_78 L23_24 0.0355
K843 L77_78 L158_159 0.0343
K844 L77_78 L72_73 0.3334
K845 L77_78 L136_198 0.1743
K846 L77_78 L163_164 0.0405
K847 L77_78 L120_183 0.0288
K848 L77_78 L91_92 0.0488
K849 L77_78 L160_161 0.0449
K850 L77_78 L151_152 0.0656
K851 L77_78 L126_127 0.0436
K852 L77_78 L22_23 0.0366
K853 L77_78 L109_110 0.0391
K854 L77_78 L204_205 0.1743
K855 L77_78 L99_100 0.0656
K856 L77_78 L153_154 0.0521
K857 L77_78 L4_5 0.0211
K858 L77_78 L34_35 0.0459
K859 L77_78 L41_42 0.0656
K860 L77_78 L16_61 0.0477
K861 L77_78 L43_44 0.0558
K862 L77_78 L146_206 0.1743
K863 L77_78 L197_198 0.2659
K864 L77_78 L192_193 0.1576
K865 L77_78 L88_89 0.1593
K866 L77_78 L31_32 0.0525
K867 L77_78 L191_192 0.0896
K868 L77_78 L205_206 0.2659
K869 L77_78 L36_37 0.0616
K870 L77_78 L131_132 0.0648
K871 L77_78 L100_101 0.0589
K872 L77_78 L203_204 0.0969
K873 L77_78 L92_93 0.0449
K874 L77_78 L81_82 0.1933
K875 L77_78 L13_14 0.0275
K876 L77_78 L131_194 0.1576
K877 L77_78 L148_149 0.0643
K878 L77_78 L19_20 0.0278
K879 L77_78 L187_188 0.0293
K880 L77_78 L165_166 0.0522
K881 L77_78 L102_103 0.0595
K882 L77_78 L106_107 0.0367
K883 L77_78 L60_61 0.0491
K884 L77_78 L64_65 0.0496
K885 L77_78 L133_134 0.0553
K886 L77_78 L8_9 0.0264
K887 L77_78 L107_108 0.0391
K888 L77_78 L170_171 0.061
K889 L77_78 L193_194 0.2334
K890 L77_78 L63_64 0.0479
K891 L77_78 L21_65 0.0479
K892 L77_78 L121_122 0.0439
K893 L77_78 L119_120 0.0448
K894 L77_78 L9_10 0.0257
K895 L77_78 L46_47 0.0369
K896 L77_78 L195_196 0.0969
K897 L77_78 L67_68 0.1727
K898 L77_78 L33_34 0.048
K899 L77_78 L134_135 0.0514
K900 L77_78 L41_69 0.1727
K901 L77_78 L171_172 0.0575
K902 L77_78 L104_105 0.0478
K903 L77_78 L151_210 0.1479
K904 L77_78 L138_139 0.0482
K905 L77_78 L37_38 0.0579
K906 L77_78 L98_99 0.0741
K907 L77_78 L112_113 0.0425
K908 L77_78 L183_184 0.0281
K909 L77_78 L59_60 0.0477
K910 L77_78 L11_57 0.045
K911 L77_78 L38_39 0.0546
K912 L77_78 L108_109 0.04
K913 L77_78 L71_72 0.1933
K914 L77_78 L27_28 0.0436
K915 L77_78 L114_115 0.0425
K916 L77_78 L44_45 0.0518
K917 L77_78 L47_48 0.0393
K918 L77_78 L29_30 0.0407
K919 L77_78 L166_167 0.0499
K920 L77_78 L185_186 0.0266
K921 L77_78 L177_178 0.0211
K922 L77_78 L16_17 0.0303
K923 L77_78 L188_189 0.0285
K924 L77_78 L86_87 0.1593
K925 L77_78 L118_119 0.046
K926 L77_78 L176_177 0.0216
K927 L77_78 L3_4 0.0216
K928 L77_78 L6_53 0.0427
K929 L77_78 L149_150 0.0579
K930 L77_78 L2_3 0.0222
K931 L77_78 L55_56 0.045
K932 L77_78 L132_133 0.0597
K933 L77_78 L84_98 0.0851
K934 L77_78 L48_49 0.0402
K935 L77_78 L110_175 0.0226
K936 L77_78 L124_125 0.0474
K937 L77_78 L113_114 0.0435
K938 L77_78 L52_53 0.0437
K939 L77_78 L80_81 0.0993
K940 L77_78 L17_18 0.0295
K941 L77_78 L87_88 0.2387
K942 L77_78 L146_147 0.0822
K943 L77_78 L209_210 0.2081
K944 L77_78 L136_137 0.0579
K945 L77_78 L127_128 0.0477
K946 L77_78 L42_43 0.0604
K947 L77_78 L181_182 0.0257
K948 L77_78 L28_29 0.0421
K949 L77_78 L157_158 0.0353
K950 L77_78 L122_123 0.0474
K951 L77_78 L161_162 0.0434
K952 L77_78 L66_67 0.0917
K953 L77_78 L129_130 0.0477
K954 L77_78 L21_22 0.0377
K955 L77_78 L117_118 0.0448
K956 L77_78 L51_52 0.0427
K957 L77_78 L56_57 0.0462
K958 L77_78 L24_25 0.0344
K959 L77_78 L116_117 0.0418
K960 L77_78 L6_7 0.0277
K961 L77_78 L173_174 0.0512
K962 L77_78 L154_155 0.0471
K963 L77_78 L32_33 0.0502
K964 L77_78 L103_104 0.0531
K965 L77_78 L85_86 0.0898
K966 L77_78 L7_8 0.027
K967 L77_78 L82_83 0.3334
K968 L77_78 L14_15 0.0267
K969 L77_78 L184_185 0.0274
K970 L77_78 L147_148 0.0723
K971 L77_78 L62_63 0.0438
K972 L77_78 L125_187 0.0302
K973 L77_78 L58_59 0.0441
K974 L77_78 L70_71 0.0993
K975 L77_78 L68_69 0.2809
K976 L77_78 L180_181 0.0263
K977 L77_78 L89_102 0.0676
K978 L77_78 L26_27 0.0451
K979 L77_78 L50_51 0.04
K980 L77_78 L168_169 0.0456
K981 L77_78 L83_84 0.1933
K982 L77_78 L90_91 0.0533
K983 L77_78 L139_140 0.0445
K984 L77_78 L111_112 0.0399
K985 L77_78 L162_163 0.0419
K986 L77_78 L137_138 0.0527
K987 L77_78 L179_180 0.027
K988 L77_78 L12_13 0.0282
K989 L77_78 L207_208 0.0878
K990 L77_78 L123_124 0.0488
K991 L77_78 L152_153 0.0581
K992 L77_78 L39_40 0.0515
K993 L77_78 L18_19 0.0286
K994 L77_78 L130_156 0.0375
K995 L77_78 L156_157 0.0364
K996 L77_78 L189_190 0.0277
K997 L77_78 L11_12 0.0289
K998 L77_78 L54_55 0.0419
K999 L72_73 L167_168 0.0498
K1000 L72_73 L199_200 0.0969
K1001 L72_73 L115_179 0.0288
K1002 L72_73 L128_129 0.0528
K1003 L72_73 L147_148 0.0693
K1004 L72_73 L95_96 0.0656
K1005 L72_73 L143_144 0.0643
K1006 L72_73 L1_2 0.0237
K1007 L72_73 L23_24 0.037
K1008 L72_73 L158_159 0.0356
K1009 L72_73 L163_164 0.0421
K1010 L72_73 L144_145 0.0579
K1011 L72_73 L120_183 0.0302
K1012 L72_73 L160_161 0.0471
K1013 L72_73 L151_152 0.0615
K1014 L72_73 L126_127 0.0459
K1015 L72_73 L22_23 0.0382
K1016 L72_73 L109_110 0.0412
K1017 L72_73 L204_205 0.1537
K1018 L72_73 L99_100 0.0634
K1019 L72_73 L153_154 0.05
K1020 L72_73 L4_5 0.0219
K1021 L72_73 L34_35 0.0477
K1022 L72_73 L41_42 0.0683
K1023 L72_73 L16_61 0.0506
K1024 L72_73 L43_44 0.0574
K1025 L72_73 L146_206 0.1537
K1026 L72_73 L201_202 0.2659
K1027 L72_73 L192_193 0.1765
K1028 L72_73 L88_89 0.1369
K1029 L72_73 L31_32 0.0554
K1030 L72_73 L191_192 0.0923
K1031 L72_73 L200_201 0.1743
K1032 L72_73 L205_206 0.2117
K1033 L72_73 L36_37 0.0649
K1034 L72_73 L131_132 0.0673
K1035 L72_73 L100_101 0.0573
K1036 L72_73 L203_204 0.0931
K1037 L72_73 L81_82 0.1646
K1038 L72_73 L13_14 0.0286
K1039 L72_73 L131_194 0.1765
K1040 L72_73 L148_149 0.0623
K1041 L72_73 L19_20 0.0289
K1042 L72_73 L187_188 0.0307
K1043 L72_73 L165_166 0.055
K1044 L72_73 L102_103 0.0565
K1045 L72_73 L106_107 0.0385
K1046 L72_73 L60_61 0.0523
K1047 L72_73 L64_65 0.0532
K1048 L72_73 L133_134 0.0568
K1049 L72_73 L8_9 0.0275
K1050 L72_73 L107_108 0.0412
K1051 L72_73 L170_171 0.0642
K1052 L72_73 L193_194 0.2931
K1053 L72_73 L63_64 0.0512
K1054 L72_73 L21_65 0.0512
K1055 L72_73 L121_122 0.0461
K1056 L72_73 L119_120 0.0474
K1057 L72_73 L9_10 0.0267
K1058 L72_73 L46_47 0.0386
K1059 L72_73 L67_68 0.2045
K1060 L72_73 L33_34 0.0501
K1061 L72_73 L134_135 0.0526
K1062 L72_73 L41_69 0.2045
K1063 L72_73 L171_172 0.0601
K1064 L72_73 L104_105 0.0462
K1065 L72_73 L151_210 0.13
K1066 L72_73 L79_94 0.0851
K1067 L72_73 L37_38 0.0607
K1068 L72_73 L75_76 0.0993
K1069 L72_73 L112_113 0.0448
K1070 L72_73 L183_184 0.0293
K1071 L72_73 L59_60 0.0506
K1072 L72_73 L11_57 0.0477
K1073 L72_73 L38_39 0.0568
K1074 L72_73 L108_109 0.0423
K1075 L72_73 L27_28 0.0457
K1076 L72_73 L78_79 0.1933
K1077 L72_73 L44_45 0.0531
K1078 L72_73 L47_48 0.0414
K1079 L72_73 L29_30 0.0423
K1080 L72_73 L76_77 0.1933
K1081 L72_73 L114_115 0.0448
K1082 L72_73 L166_167 0.0523
K1083 L72_73 L185_186 0.0277
K1084 L72_73 L177_178 0.0219
K1085 L72_73 L16_17 0.0317
K1086 L72_73 L188_189 0.0297
K1087 L72_73 L86_87 0.1369
K1088 L72_73 L118_119 0.0488
K1089 L72_73 L176_177 0.0225
K1090 L72_73 L3_4 0.0225
K1091 L72_73 L6_53 0.045
K1092 L72_73 L149_150 0.0564
K1093 L72_73 L2_3 0.0231
K1094 L72_73 L98_99 0.071
K1095 L72_73 L55_56 0.0477
K1096 L72_73 L132_133 0.0616
K1097 L72_73 L84_98 0.0803
K1098 L72_73 L48_49 0.0425
K1099 L72_73 L110_175 0.0236
K1100 L72_73 L124_125 0.0504
K1101 L72_73 L113_114 0.046
K1102 L72_73 L52_53 0.0462
K1103 L72_73 L80_81 0.0952
K1104 L72_73 L17_18 0.0308
K1105 L72_73 L141_202 0.1743
K1106 L72_73 L87_88 0.1829
K1107 L72_73 L146_147 0.078
K1108 L72_73 L209_210 0.1684
K1109 L72_73 L94_95 0.0741
K1110 L72_73 L127_128 0.0508
K1111 L72_73 L42_43 0.0624
K1112 L72_73 L181_182 0.0266
K1113 L72_73 L28_29 0.044
K1114 L72_73 L157_158 0.0369
K1115 L72_73 L122_123 0.0504
K1116 L72_73 L96_97 0.0589
K1117 L72_73 L66_67 0.0947
K1118 L72_73 L129_130 0.0508
K1119 L72_73 L21_22 0.0395
K1120 L72_73 L117_118 0.0474
K1121 L72_73 L51_52 0.045
K1122 L72_73 L56_57 0.0491
K1123 L72_73 L24_25 0.0358
K1124 L72_73 L116_117 0.0439
K1125 L72_73 L6_7 0.0289
K1126 L72_73 L173_174 0.053
K1127 L72_73 L154_155 0.0456
K1128 L72_73 L32_33 0.0527
K1129 L72_73 L103_104 0.0509
K1130 L72_73 L85_86 0.0854
K1131 L72_73 L7_8 0.0282
K1132 L72_73 L82_83 0.2392
K1133 L72_73 L14_15 0.0278
K1134 L72_73 L184_185 0.0285
K1135 L72_73 L141_142 0.0822
K1136 L72_73 L62_63 0.0462
K1137 L72_73 L125_187 0.0316
K1138 L72_73 L58_59 0.0464
K1139 L72_73 L68_69 0.4331
K1140 L72_73 L180_181 0.0274
K1141 L72_73 L89_102 0.0632
K1142 L72_73 L26_27 0.0474
K1143 L72_73 L50_51 0.0419
K1144 L72_73 L168_169 0.0475
K1145 L72_73 L83_84 0.1646
K1146 L72_73 L161_162 0.0454
K1147 L72_73 L111_112 0.0418
K1148 L72_73 L162_163 0.0438
K1149 L72_73 L179_180 0.0281
K1150 L72_73 L12_13 0.0295
K1151 L72_73 L207_208 0.0837
K1152 L72_73 L142_143 0.0723
K1153 L72_73 L123_124 0.052
K1154 L72_73 L152_153 0.0553
K1155 L72_73 L39_40 0.0534
K1156 L72_73 L18_19 0.0298
K1157 L72_73 L130_156 0.0393
K1158 L72_73 L156_157 0.0381
K1159 L72_73 L189_190 0.0288
K1160 L72_73 L11_12 0.0303
K1161 L72_73 L54_55 0.0441
K1162 L42_90 L24_29 0.0389
K1163 L42_90 L181_185 0.0262
K1164 L42_90 L140_145 0.0789
K1165 L42_90 L1_6 0.0314
K1166 L42_90 L13_18 0.0285
K1167 L42_90 L35_40 0.0606
K1168 L42_90 L23_28 0.0394
K1169 L42_90 L73_78 0.0667
K1170 L42_90 L184_188 0.0283
K1171 L42_90 L6_11 0.0334
K1172 L42_90 L197_201 0.0455
K1173 L42_90 L76_81 0.0349
K1174 L42_90 L163_168 0.0491
K1175 L42_90 L91_95 0.1832
K1176 L42_90 L144_149 0.1015
K1177 L42_90 L130_160 0.0428
K1178 L42_90 L4_9 0.0247
K1179 L42_90 L26_31 0.0596
K1180 L42_90 L202_206 0.0643
K1181 L42_90 L109_114 0.0322
K1182 L42_90 L57_61 0.0357
K1183 L42_90 L99_103 0.1124
K1184 L42_90 L164_169 0.0443
K1185 L42_90 L195_199 0.027
K1186 L42_90 L31_36 0.0951
K1187 L42_90 L45_93 0.0891
K1188 L42_90 L106_111 0.0203
K1189 L42_90 L34_39 0.0685
K1190 L42_90 L148_153 0.1015
K1191 L42_90 L201_205 0.0451
K1192 L42_90 L192_196 0.0349
K1193 L42_90 L53_57 0.034
K1194 L42_90 L69_73 0.0671
K1195 L42_90 L200_204 0.0347
K1196 L42_90 L150_155 0.0657
K1197 L42_90 L145_150 0.073
K1198 L42_90 L118_123 0.031
K1199 L42_90 L30_35 0.0449
K1200 L42_90 L194_198 0.0659
K1201 L42_90 L131_136 0.1161
K1202 L42_90 L101_105 0.0696
K1203 L42_90 L46_50 0.0203
K1204 L42_90 L196_200 0.0349
K1205 L42_90 L92_96 0.1284
K1206 L42_90 L81_86 0.0346
K1207 L42_90 L19_24 0.0302
K1208 L42_90 L120_125 0.0353
K1209 L42_90 L8_13 0.0266
K1210 L42_90 L157_188 0.0304
K1211 L42_90 L133_138 0.1536
K1212 L42_90 L60_64 0.0324
K1213 L42_90 L72_77 0.0459
K1214 L42_90 L198_202 0.0655
K1215 L42_90 L193_197 0.0457
K1216 L42_90 L168_173 0.0668
K1217 L42_90 L20_25 0.0247
K1218 L42_90 L167_172 0.0699
K1219 L42_90 L121_126 0.022
K1220 L42_90 L119_124 0.0355
K1221 L42_90 L97_101 0.0787
K1222 L42_90 L110_115 0.0313
K1223 L42_90 L113_118 0.0298
K1224 L42_90 L141_146 0.1056
K1225 L42_90 L182_186 0.0215
K1226 L42_90 L100_104 0.0953
K1227 L42_90 L9_14 0.0263
K1228 L42_90 L138_143 0.1438
K1229 L42_90 L33_38 0.0718
K1230 L42_90 L18_23 0.0306
K1231 L42_90 L134_139 0.1173
K1232 L42_90 L124_129 0.0374
K1233 L42_90 L107_112 0.0254
K1234 L42_90 L78_83 0.0654
K1235 L42_90 L112_117 0.0262
K1236 L42_90 L40_45 0.0877
K1237 L42_90 L136_141 0.1131
K1238 L42_90 L59_63 0.0278
K1239 L42_90 L5_10 0.0203
K1240 L42_90 L71_76 0.0351
K1241 L42_90 L15_20 0.023
K1242 L42_90 L51_55 0.0262
K1243 L42_90 L58_62 0.022
K1244 L42_90 L67_71 0.0351
K1245 L42_90 L36_41 0.2195
K1246 L42_90 L48_52 0.0288
K1247 L42_90 L29_34 0.0498
K1248 L42_90 L206_210 0.0624
K1249 L42_90 L41_74 0.1262
K1250 L42_90 L131_170 0.1665
K1251 L42_90 L28_33 0.051
K1252 L42_90 L205_209 0.0445
K1253 L42_90 L191_195 0.0271
K1254 L42_90 L178_182 0.0202
K1255 L42_90 L180_184 0.0265
K1256 L42_90 L3_8 0.025
K1257 L42_90 L157_162 0.0391
K1258 L42_90 L149_154 0.0884
K1259 L42_90 L203_207 0.0267
K1260 L42_90 L66_70 0.0272
K1261 L42_90 L117_122 0.0269
K1262 L42_90 L114_119 0.0338
K1263 L42_90 L158_189 0.03
K1264 L42_90 L38_43 0.1187
K1265 L42_90 L47_51 0.0255
K1266 L42_90 L55_59 0.027
K1267 L42_90 L135_174 0.0836
K1268 L42_90 L160_165 0.0583
K1269 L42_90 L52_56 0.03
K1270 L42_90 L115_120 0.0332
K1271 L42_90 L80_85 0.0268
K1272 L42_90 L10_15 0.0216
K1273 L42_90 L16_21 0.038
K1274 L42_90 L158_163 0.0385
K1275 L42_90 L185_189 0.0279
K1276 L42_90 L96_100 0.1124
K1277 L42_90 L49_53 0.0324
K1278 L42_90 L186_190 0.0229
K1279 L42_90 L82_87 0.0448
K1280 L42_90 L125_130 0.0378
K1281 L42_90 L108_113 0.0287
K1282 L42_90 L159_164 0.0351
K1283 L42_90 L84_89 0.1012
K1284 L42_90 L68_72 0.0461
K1285 L42_90 L169_174 0.0592
K1286 L42_90 L204_208 0.0344
K1287 L42_90 L25_30 0.0354
K1288 L42_90 L133_172 0.1101
K1289 L42_90 L14_19 0.0281
K1290 L42_90 L44_92 0.1354
K1291 L42_90 L21_26 0.0433
K1292 L42_90 L95_99 0.1439
K1293 L42_90 L116_121 0.0214
K1294 L42_90 L74_79 0.1224
K1295 L42_90 L165_170 0.0898
K1296 L42_90 L199_203 0.0269
K1297 L42_90 L75_80 0.027
K1298 L42_90 L143_148 0.1226
K1299 L42_90 L70_75 0.0271
K1300 L42_90 L50_54 0.0209
K1301 L42_90 L79_84 0.1129
K1302 L42_90 L56_60 0.0311
K1303 L42_90 L159_190 0.0245
K1304 L42_90 L93_97 0.0861
K1305 L42_90 L134_173 0.0989
K1306 L42_90 L139_144 0.1127
K1307 L42_90 L83_88 0.0634
K1308 L42_90 L177_181 0.0246
K1309 L42_90 L176_180 0.0248
K1310 L42_90 L111_116 0.0208
K1311 L42_90 L162_167 0.0503
K1312 L42_90 L43_91 0.2054
K1313 L42_90 L122_127 0.0277
K1314 L42_90 L135_140 0.0811
K1315 L42_90 L39_44 0.1049
K1316 L42_90 L123_128 0.0322
K1317 L42_90 L54_58 0.0214
K1318 L42_90 L146_151 0.0959
K1319 L42_90 L61_65 0.0376
K1320 L42_90 L11_16 0.0356
K1321 L42_90 L77_82 0.0455
K1322 L197_201 L181_185 0.0271
K1323 L197_201 L140_145 0.0314
K1324 L197_201 L1_6 0.0375
K1325 L197_201 L13_18 0.0289
K1326 L197_201 L35_40 0.0397
K1327 L197_201 L23_28 0.0384
K1328 L197_201 L73_78 0.1114
K1329 L197_201 L6_11 0.0391
K1330 L197_201 L76_81 0.1104
K1331 L197_201 L163_168 0.041
K1332 L197_201 L91_95 0.0424
K1333 L197_201 L144_149 0.0398
K1334 L197_201 L130_160 0.0379
K1335 L197_201 L4_9 0.0261
K1336 L197_201 L26_31 0.0426
K1337 L197_201 L202_206 0.1134
K1338 L197_201 L132_137 0.0459
K1339 L197_201 L109_114 0.0466
K1340 L197_201 L57_61 0.0513
K1341 L197_201 L99_103 0.042
K1342 L197_201 L164_169 0.0367
K1343 L197_201 L195_199 0.0818
K1344 L197_201 L31_36 0.0479
K1345 L197_201 L45_93 0.0312
K1346 L197_201 L106_111 0.0375
K1347 L197_201 L34_39 0.0447
K1348 L197_201 L148_153 0.0423
K1349 L197_201 L156_187 0.0311
K1350 L197_201 L204_208 0.1103
K1351 L197_201 L192_196 0.1134
K1352 L197_201 L53_57 0.0487
K1353 L197_201 L69_73 0.1104
K1354 L197_201 L200_204 0.1134
K1355 L197_201 L150_155 0.0312
K1356 L197_201 L145_150 0.0313
K1357 L197_201 L30_35 0.0365
K1358 L197_201 L194_198 0.1134
K1359 L197_201 L131_136 0.069
K1360 L197_201 L101_105 0.031
K1361 L197_201 L46_50 0.0373
K1362 L197_201 L196_200 0.1145
K1363 L197_201 L92_96 0.0396
K1364 L197_201 L81_86 0.1076
K1365 L197_201 L19_24 0.0289
K1366 L197_201 L120_125 0.041
K1367 L197_201 L8_13 0.0279
K1368 L197_201 L157_188 0.03
K1369 L197_201 L133_138 0.0426
K1370 L197_201 L37_42 0.0546
K1371 L197_201 L198_202 0.1145
K1372 L197_201 L168_173 0.0449
K1373 L197_201 L7_12 0.0287
K1374 L197_201 L137_142 0.0461
K1375 L197_201 L20_25 0.0233
K1376 L197_201 L167_172 0.0474
K1377 L197_201 L121_126 0.0433
K1378 L197_201 L119_124 0.0515
K1379 L197_201 L97_101 0.0312
K1380 L197_201 L110_115 0.0377
K1381 L197_201 L134_139 0.0398
K1382 L197_201 L141_146 0.069
K1383 L197_201 L182_186 0.0219
K1384 L197_201 L100_104 0.0392
K1385 L197_201 L166_171 0.0501
K1386 L197_201 L9_14 0.027
K1387 L197_201 L138_143 0.0427
K1388 L197_201 L33_38 0.0471
K1389 L197_201 L18_23 0.0299
K1390 L197_201 L132_171 0.055
K1391 L197_201 L124_129 0.0543
K1392 L197_201 L107_112 0.0466
K1393 L197_201 L78_83 0.1104
K1394 L197_201 L112_117 0.0489
K1395 L197_201 L40_45 0.0425
K1396 L197_201 L183_187 0.03
K1397 L197_201 L136_141 0.0692
K1398 L197_201 L59_63 0.054
K1399 L197_201 L5_10 0.0212
K1400 L197_201 L71_76 0.1114
K1401 L197_201 L15_20 0.0226
K1402 L197_201 L51_55 0.0487
K1403 L197_201 L58_62 0.0431
K1404 L197_201 L67_71 0.1104
K1405 L197_201 L36_41 0.053
K1406 L197_201 L29_34 0.0409
K1407 L197_201 L179_183 0.0288
K1408 L197_201 L158_189 0.029
K1409 L197_201 L206_210 0.1103
K1410 L197_201 L41_74 0.0681
K1411 L197_201 L131_170 0.0534
K1412 L197_201 L28_33 0.0427
K1413 L197_201 L191_195 0.0812
K1414 L197_201 L66_70 0.0797
K1415 L197_201 L98_102 0.0451
K1416 L197_201 L27_32 0.0446
K1417 L197_201 L142_147 0.0459
K1418 L197_201 L147_152 0.0455
K1419 L197_201 L178_182 0.0213
K1420 L197_201 L180_184 0.028
K1421 L197_201 L3_8 0.0269
K1422 L197_201 L157_162 0.0385
K1423 L197_201 L149_154 0.0395
K1424 L197_201 L203_207 0.0796
K1425 L197_201 L2_7 0.0277
K1426 L197_201 L117_122 0.0515
K1427 L197_201 L22_27 0.0398
K1428 L197_201 L17_22 0.031
K1429 L197_201 L38_43 0.0511
K1430 L197_201 L47_51 0.0464
K1431 L197_201 L55_59 0.0513
K1432 L197_201 L135_174 0.0427
K1433 L197_201 L94_98 0.0455
K1434 L197_201 L160_165 0.0428
K1435 L197_201 L115_120 0.0393
K1436 L197_201 L80_85 0.0782
K1437 L197_201 L10_15 0.0219
K1438 L197_201 L16_21 0.0426
K1439 L197_201 L158_163 0.0372
K1440 L197_201 L185_189 0.028
K1441 L197_201 L96_100 0.0395
K1442 L197_201 L49_53 0.0464
K1443 L197_201 L186_190 0.0227
K1444 L197_201 L156_161 0.0399
K1445 L197_201 L125_130 0.0428
K1446 L197_201 L184_188 0.029
K1447 L197_201 L159_164 0.0334
K1448 L197_201 L24_29 0.0371
K1449 L197_201 L169_174 0.0399
K1450 L197_201 L25_30 0.0333
K1451 L197_201 L32_37 0.0498
K1452 L197_201 L133_172 0.0515
K1453 L197_201 L14_19 0.0279
K1454 L197_201 L44_92 0.0395
K1455 L197_201 L161_166 0.0448
K1456 L197_201 L21_26 0.0377
K1457 L197_201 L95_99 0.0423
K1458 L197_201 L84_89 0.0673
K1459 L197_201 L116_121 0.0412
K1460 L197_201 L74_79 0.0684
K1461 L197_201 L165_170 0.0482
K1462 L197_201 L199_203 0.0812
K1463 L197_201 L75_80 0.0797
K1464 L197_201 L143_148 0.0426
K1465 L197_201 L70_75 0.0802
K1466 L197_201 L50_54 0.0391
K1467 L197_201 L79_84 0.0681
K1468 L197_201 L159_190 0.0234
K1469 L197_201 L93_97 0.0312
K1470 L197_201 L90_94 0.0457
K1471 L197_201 L134_173 0.0484
K1472 L197_201 L139_144 0.0398
K1473 L197_201 L83_88 0.1076
K1474 L197_201 L177_181 0.0262
K1475 L197_201 L176_180 0.027
K1476 L197_201 L111_116 0.0393
K1477 L197_201 L162_167 0.0429
K1478 L197_201 L43_91 0.0423
K1479 L197_201 L122_127 0.0543
K1480 L197_201 L135_140 0.0313
K1481 L197_201 L39_44 0.0481
K1482 L197_201 L12_17 0.0298
K1483 L197_201 L54_58 0.041
K1484 L197_201 L146_151 0.0681
K1485 L197_201 L114_119 0.0489
K1486 L197_201 L61_65 0.054
K1487 L197_201 L11_16 0.0408
K1488 L76_81 L181_185 0.0233
K1489 L76_81 L140_145 0.0249
K1490 L76_81 L1_6 0.0326
K1491 L76_81 L13_18 0.0247
K1492 L76_81 L35_40 0.0325
K1493 L76_81 L23_28 0.0326
K1494 L76_81 L73_78 0.0741
K1495 L76_81 L6_11 0.0336
K1496 L76_81 L163_168 0.0339
K1497 L76_81 L91_95 0.0331
K1498 L76_81 L144_149 0.0313
K1499 L76_81 L130_160 0.0318
K1500 L76_81 L4_9 0.0227
K1501 L76_81 L26_31 0.0349
K1502 L76_81 L202_206 0.0736
K1503 L76_81 L132_137 0.0347
K1504 L76_81 L109_114 0.0404
K1505 L76_81 L57_61 0.0439
K1506 L76_81 L99_103 0.0331
K1507 L76_81 L164_169 0.0304
K1508 L76_81 L195_199 0.1405
K1509 L76_81 L31_36 0.038
K1510 L76_81 L45_93 0.0249
K1511 L76_81 L106_111 0.0384
K1512 L76_81 L34_39 0.0363
K1513 L76_81 L148_153 0.0329
K1514 L76_81 L156_187 0.0262
K1515 L76_81 L201_205 0.1114
K1516 L76_81 L9_14 0.0233
K1517 L76_81 L53_57 0.0421
K1518 L76_81 L69_73 0.0733
K1519 L76_81 L205_209 0.1104
K1520 L76_81 L150_155 0.0249
K1521 L76_81 L145_150 0.0249
K1522 L76_81 L118_123 0.0487
K1523 L76_81 L30_35 0.0305
K1524 L76_81 L194_198 0.0726
K1525 L76_81 L131_136 0.05
K1526 L76_81 L101_105 0.025
K1527 L76_81 L46_50 0.0385
K1528 L76_81 L92_96 0.0313
K1529 L76_81 L19_24 0.0246
K1530 L76_81 L120_125 0.0347
K1531 L76_81 L8_13 0.024
K1532 L76_81 L157_188 0.0253
K1533 L76_81 L133_138 0.0328
K1534 L76_81 L60_64 0.0515
K1535 L76_81 L72_77 0.1134
K1536 L76_81 L198_202 0.0734
K1537 L76_81 L193_197 0.1076
K1538 L76_81 L168_173 0.0362
K1539 L76_81 L7_12 0.0247
K1540 L76_81 L137_142 0.0349
K1541 L76_81 L20_25 0.0199
K1542 L76_81 L167_172 0.0378
K1543 L76_81 L121_126 0.0453
K1544 L76_81 L119_124 0.0437
K1545 L76_81 L97_101 0.025
K1546 L76_81 L110_115 0.0325
K1547 L76_81 L141_146 0.0504
K1548 L76_81 L182_186 0.0189
K1549 L76_81 L100_104 0.0313
K1550 L76_81 L166_171 0.0395
K1551 L76_81 L24_29 0.0315
K1552 L76_81 L138_143 0.0329
K1553 L76_81 L33_38 0.0379
K1554 L76_81 L18_23 0.0254
K1555 L76_81 L132_171 0.0422
K1556 L76_81 L124_129 0.0455
K1557 L76_81 L78_83 0.0744
K1558 L76_81 L134_139 0.0311
K1559 L76_81 L40_45 0.0342
K1560 L76_81 L183_187 0.0254
K1561 L76_81 L136_141 0.0503
K1562 L76_81 L5_10 0.0184
K1563 L76_81 L15_20 0.0194
K1564 L76_81 L58_62 0.0455
K1565 L76_81 L36_41 0.0407
K1566 L76_81 L48_52 0.0444
K1567 L76_81 L29_34 0.034
K1568 L76_81 L179_183 0.0247
K1569 L76_81 L158_189 0.0245
K1570 L76_81 L206_210 0.0734
K1571 L76_81 L41_74 0.0503
K1572 L76_81 L131_170 0.0405
K1573 L76_81 L28_33 0.0353
K1574 L76_81 L191_195 0.1322
K1575 L76_81 L66_70 0.1402
K1576 L76_81 L98_102 0.0351
K1577 L76_81 L27_32 0.0367
K1578 L76_81 L147_152 0.0349
K1579 L76_81 L178_182 0.0184
K1580 L76_81 L180_184 0.024
K1581 L76_81 L3_8 0.0234
K1582 L76_81 L157_162 0.0325
K1583 L76_81 L149_154 0.0312
K1584 L76_81 L203_207 0.1405
K1585 L76_81 L2_7 0.024
K1586 L76_81 L22_27 0.0336
K1587 L76_81 L17_22 0.0262
K1588 L76_81 L38_43 0.0403
K1589 L76_81 L113_118 0.0464
K1590 L76_81 L108_113 0.0443
K1591 L76_81 L135_174 0.034
K1592 L76_81 L94_98 0.0351
K1593 L76_81 L160_165 0.0348
K1594 L76_81 L52_56 0.0466
K1595 L76_81 L115_120 0.0336
K1596 L76_81 L80_85 0.1506
K1597 L76_81 L10_15 0.0189
K1598 L76_81 L16_21 0.0359
K1599 L76_81 L158_163 0.0314
K1600 L76_81 L185_189 0.0239
K1601 L76_81 L96_100 0.0314
K1602 L76_81 L49_53 0.0405
K1603 L76_81 L186_190 0.0193
K1604 L76_81 L156_161 0.0336
K1605 L76_81 L82_87 0.1134
K1606 L76_81 L125_130 0.0358
K1607 L76_81 L184_188 0.0246
K1608 L76_81 L159_164 0.0283
K1609 L76_81 L84_89 0.0506
K1610 L76_81 L68_72 0.1103
K1611 L76_81 L169_174 0.0324
K1612 L76_81 L37_42 0.0424
K1613 L76_81 L25_30 0.0284
K1614 L76_81 L32_37 0.0397
K1615 L76_81 L133_172 0.0401
K1616 L76_81 L14_19 0.0239
K1617 L76_81 L44_92 0.0312
K1618 L76_81 L161_166 0.0366
K1619 L76_81 L21_26 0.0319
K1620 L76_81 L95_99 0.0331
K1621 L76_81 L116_121 0.0427
K1622 L76_81 L74_79 0.0506
K1623 L76_81 L165_170 0.0378
K1624 L76_81 L199_203 0.1437
K1625 L76_81 L75_80 0.1548
K1626 L76_81 L143_148 0.033
K1627 L76_81 L70_75 0.1506
K1628 L76_81 L50_54 0.0406
K1629 L76_81 L79_84 0.0507
K1630 L76_81 L56_60 0.0489
K1631 L76_81 L159_190 0.0198
K1632 L76_81 L93_97 0.025
K1633 L76_81 L90_94 0.0351
K1634 L76_81 L134_173 0.0382
K1635 L76_81 L139_144 0.0312
K1636 L76_81 L83_88 0.0741
K1637 L76_81 L177_181 0.0227
K1638 L76_81 L176_180 0.0233
K1639 L76_81 L111_116 0.0405
K1640 L76_81 L162_167 0.0352
K1641 L76_81 L43_91 0.0329
K1642 L76_81 L142_147 0.0349
K1643 L76_81 L135_140 0.0248
K1644 L76_81 L39_44 0.0383
K1645 L76_81 L123_128 0.0513
K1646 L76_81 L12_17 0.0255
K1647 L76_81 L54_58 0.043
K1648 L76_81 L146_151 0.0503
K1649 L76_81 L114_119 0.042
K1650 L76_81 L61_65 0.0457
K1651 L76_81 L11_16 0.0348
K1652 L76_81 L77_82 0.1145
K1653 L132_133 L167_168 0.0782
K1654 L132_133 L74_90 0.1234
K1655 L132_133 L199_200 0.0361
K1656 L132_133 L115_179 0.0315
K1657 L132_133 L128_129 0.0444
K1658 L132_133 L196_197 0.0461
K1659 L132_133 L73_74 0.0916
K1660 L132_133 L1_2 0.0255
K1661 L132_133 L23_24 0.0453
K1662 L132_133 L158_159 0.0453
K1663 L132_133 L136_198 0.0942
K1664 L132_133 L163_164 0.057
K1665 L132_133 L144_145 0.1004
K1666 L132_133 L120_183 0.0337
K1667 L132_133 L91_92 0.1234
K1668 L132_133 L160_161 0.0577
K1669 L132_133 L151_152 0.0644
K1670 L132_133 L126_127 0.0323
K1671 L132_133 L22_23 0.0454
K1672 L132_133 L109_110 0.0395
K1673 L132_133 L99_100 0.0844
K1674 L132_133 L153_154 0.0644
K1675 L132_133 L4_5 0.0254
K1676 L132_133 L34_35 0.0751
K1677 L132_133 L16_61 0.0487
K1678 L132_133 L146_206 0.081
K1679 L132_133 L197_198 0.0624
K1680 L132_133 L204_205 0.0443
K1681 L132_133 L88_89 0.0699
K1682 L132_133 L31_32 0.0767
K1683 L132_133 L143_144 0.1076
K1684 L132_133 L200_201 0.0453
K1685 L132_133 L205_206 0.0581
K1686 L132_133 L36_37 0.116
K1687 L132_133 L141_142 0.1076
K1688 L132_133 L100_101 0.0808
K1689 L132_133 L203_204 0.0356
K1690 L132_133 L92_93 0.1128
K1691 L132_133 L81_82 0.044
K1692 L132_133 L13_14 0.0335
K1693 L132_133 L185_186 0.0334
K1694 L132_133 L148_149 0.0883
K1695 L132_133 L19_20 0.0356
K1696 L132_133 L187_188 0.0363
K1697 L132_133 L165_166 0.0782
K1698 L132_133 L102_103 0.0629
K1699 L132_133 L106_107 0.0289
K1700 L132_133 L60_61 0.0441
K1701 L132_133 L64_65 0.0441
K1702 L132_133 L8_9 0.0313
K1703 L132_133 L107_108 0.0327
K1704 L132_133 L170_171 0.122
K1705 L132_133 L63_64 0.0378
K1706 L132_133 L21_65 0.0496
K1707 L132_133 L121_122 0.0333
K1708 L132_133 L119_120 0.0458
K1709 L132_133 L9_10 0.0311
K1710 L132_133 L46_47 0.0288
K1711 L132_133 L195_196 0.0365
K1712 L132_133 L33_34 0.0767
K1713 L132_133 L171_172 0.1244
K1714 L132_133 L104_105 0.06
K1715 L132_133 L151_210 0.0712
K1716 L132_133 L79_94 0.1006
K1717 L132_133 L37_38 0.118
K1718 L132_133 L75_76 0.0359
K1719 L132_133 L112_113 0.0355
K1720 L132_133 L183_184 0.0338
K1721 L132_133 L59_60 0.0385
K1722 L132_133 L11_57 0.0455
K1723 L132_133 L38_39 0.116
K1724 L132_133 L108_109 0.0366
K1725 L132_133 L71_72 0.0458
K1726 L132_133 L27_28 0.0572
K1727 L132_133 L96_97 0.0947
K1728 L132_133 L78_79 0.0855
K1729 L132_133 L138_139 0.1375
K1730 L132_133 L47_48 0.0326
K1731 L132_133 L29_30 0.0564
K1732 L132_133 L76_77 0.045
K1733 L132_133 L114_115 0.043
K1734 L132_133 L166_167 0.0788
K1735 L132_133 L177_178 0.0255
K1736 L132_133 L16_17 0.0359
K1737 L132_133 L188_189 0.0362
K1738 L132_133 L86_87 0.0403
K1739 L132_133 L118_119 0.0419
K1740 L132_133 L176_177 0.0257
K1741 L132_133 L3_4 0.0255
K1742 L132_133 L6_53 0.0428
K1743 L132_133 L149_150 0.0842
K1744 L132_133 L2_3 0.0256
K1745 L132_133 L98_99 0.0857
K1746 L132_133 L55_56 0.0369
K1747 L132_133 L184_185 0.0337
K1748 L132_133 L84_98 0.0844
K1749 L132_133 L48_49 0.0364
K1750 L132_133 L110_175 0.0257
K1751 L132_133 L124_125 0.049
K1752 L132_133 L113_114 0.0397
K1753 L132_133 L52_53 0.0395
K1754 L132_133 L80_81 0.0354
K1755 L132_133 L17_18 0.036
K1756 L132_133 L141_202 0.0876
K1757 L132_133 L87_88 0.052
K1758 L132_133 L146_147 0.0883
K1759 L132_133 L209_210 0.0525
K1760 L132_133 L94_95 0.1029
K1761 L132_133 L127_128 0.038
K1762 L132_133 L181_182 0.0313
K1763 L132_133 L28_29 0.057
K1764 L132_133 L157_158 0.0457
K1765 L132_133 L122_123 0.0386
K1766 L132_133 L103_104 0.0622
K1767 L132_133 L129_130 0.05
K1768 L132_133 L21_22 0.0453
K1769 L132_133 L117_118 0.037
K1770 L132_133 L51_52 0.0353
K1771 L132_133 L56_57 0.0417
K1772 L132_133 L24_25 0.0449
K1773 L132_133 L116_117 0.0323
K1774 L132_133 L6_7 0.0313
K1775 L132_133 L173_174 0.1157
K1776 L132_133 L154_155 0.0621
K1777 L132_133 L32_33 0.0772
K1778 L132_133 L95_96 0.1006
K1779 L132_133 L85_86 0.0326
K1780 L132_133 L7_8 0.0314
K1781 L132_133 L82_83 0.0575
K1782 L132_133 L14_15 0.0332
K1783 L132_133 L147_148 0.0898
K1784 L132_133 L62_63 0.0322
K1785 L132_133 L125_187 0.0362
K1786 L132_133 L58_59 0.0332
K1787 L132_133 L70_71 0.0363
K1788 L132_133 L136_137 0.1375
K1789 L132_133 L180_181 0.0315
K1790 L132_133 L89_102 0.0622
K1791 L132_133 L26_27 0.057
K1792 L132_133 L50_51 0.0312
K1793 L132_133 L168_169 0.0766
K1794 L132_133 L83_84 0.0794
K1795 L132_133 L90_91 0.1276
K1796 L132_133 L139_140 0.1231
K1797 L132_133 L161_162 0.0579
K1798 L132_133 L111_112 0.0312
K1799 L132_133 L162_163 0.0577
K1800 L132_133 L137_138 0.1436
K1801 L132_133 L179_180 0.0316
K1802 L132_133 L12_13 0.0335
K1803 L132_133 L207_208 0.0328
K1804 L132_133 L142_143 0.1104
K1805 L132_133 L123_124 0.0443
K1806 L132_133 L152_153 0.0652
K1807 L132_133 L39_40 0.1106
K1808 L132_133 L18_19 0.0359
K1809 L132_133 L130_156 0.0457
K1810 L132_133 L156_157 0.0458
K1811 L132_133 L189_190 0.0359
K1812 L132_133 L11_12 0.0335
K1813 L132_133 L54_55 0.0322
K1814 L132_133 L201_202 0.0604
K1815 L132_137 L24_29 0.0385
K1816 L132_137 L181_185 0.0263
K1817 L132_137 L140_145 0.0861
K1818 L132_137 L1_6 0.0313
K1819 L132_137 L13_18 0.0283
K1820 L132_137 L35_40 0.0592
K1821 L132_137 L23_28 0.0391
K1822 L132_137 L73_78 0.0655
K1823 L132_137 L184_188 0.0285
K1824 L132_137 L6_11 0.0332
K1825 L132_137 L163_168 0.0498
K1826 L132_137 L91_95 0.1438
K1827 L132_137 L144_149 0.1124
K1828 L132_137 L130_160 0.0433
K1829 L132_137 L4_9 0.0246
K1830 L132_137 L26_31 0.0583
K1831 L132_137 L202_206 0.0654
K1832 L132_137 L109_114 0.0324
K1833 L132_137 L57_61 0.0355
K1834 L132_137 L99_103 0.1015
K1835 L132_137 L164_169 0.0449
K1836 L132_137 L195_199 0.0271
K1837 L132_137 L31_36 0.0898
K1838 L132_137 L45_93 0.0811
K1839 L132_137 L106_111 0.0203
K1840 L132_137 L34_39 0.0668
K1841 L132_137 L148_153 0.1124
K1842 L132_137 L201_205 0.0455
K1843 L132_137 L192_196 0.0351
K1844 L132_137 L53_57 0.0338
K1845 L132_137 L69_73 0.0659
K1846 L132_137 L200_204 0.0349
K1847 L132_137 L150_155 0.0696
K1848 L132_137 L145_150 0.0787
K1849 L132_137 L118_123 0.0311
K1850 L132_137 L30_35 0.0443
K1851 L132_137 L194_198 0.0671
K1852 L132_137 L131_136 0.1262
K1853 L132_137 L101_105 0.0657
K1854 L132_137 L46_50 0.0203
K1855 L132_137 L196_200 0.0351
K1856 L132_137 L92_96 0.1127
K1857 L132_137 L81_86 0.0344
K1858 L132_137 L19_24 0.03
K1859 L132_137 L120_125 0.0356
K1860 L132_137 L8_13 0.0265
K1861 L132_137 L157_188 0.0306
K1862 L132_137 L133_138 0.2054
K1863 L132_137 L60_64 0.0322
K1864 L132_137 L72_77 0.0455
K1865 L132_137 L198_202 0.0667
K1866 L132_137 L193_197 0.0461
K1867 L132_137 L168_173 0.0685
K1868 L132_137 L20_25 0.0245
K1869 L132_137 L167_172 0.0718
K1870 L132_137 L121_126 0.022
K1871 L132_137 L119_124 0.0357
K1872 L132_137 L97_101 0.073
K1873 L132_137 L110_115 0.0314
K1874 L132_137 L113_118 0.03
K1875 L132_137 L141_146 0.1129
K1876 L132_137 L182_186 0.0216
K1877 L132_137 L100_104 0.0884
K1878 L132_137 L9_14 0.0262
K1879 L132_137 L138_143 0.1832
K1880 L132_137 L33_38 0.0699
K1881 L132_137 L18_23 0.0304
K1882 L132_137 L134_139 0.1354
K1883 L132_137 L124_129 0.0376
K1884 L132_137 L107_112 0.0255
K1885 L132_137 L78_83 0.0643
K1886 L132_137 L112_117 0.0262
K1887 L132_137 L40_45 0.0836
K1888 L132_137 L136_141 0.1224
K1889 L132_137 L59_63 0.0277
K1890 L132_137 L5_10 0.0202
K1891 L132_137 L71_76 0.0349
K1892 L132_137 L15_20 0.0229
K1893 L132_137 L51_55 0.0262
K1894 L132_137 L58_62 0.022
K1895 L132_137 L67_71 0.0349
K1896 L132_137 L36_41 0.1665
K1897 L132_137 L48_52 0.0287
K1898 L132_137 L29_34 0.0491
K1899 L132_137 L206_210 0.0634
K1900 L132_137 L41_74 0.1161
K1901 L132_137 L131_170 0.2195
K1902 L132_137 L28_33 0.0503
K1903 L132_137 L205_209 0.0448
K1904 L132_137 L191_195 0.0272
K1905 L132_137 L178_182 0.0203
K1906 L132_137 L180_184 0.0266
K1907 L132_137 L3_8 0.0248
K1908 L132_137 L157_162 0.0394
K1909 L132_137 L149_154 0.0953
K1910 L132_137 L203_207 0.0268
K1911 L132_137 L66_70 0.0271
K1912 L132_137 L117_122 0.027
K1913 L132_137 L114_119 0.034
K1914 L132_137 L158_189 0.0302
K1915 L132_137 L38_43 0.1101
K1916 L132_137 L47_51 0.0254
K1917 L132_137 L55_59 0.0269
K1918 L132_137 L135_174 0.0877
K1919 L132_137 L160_165 0.0596
K1920 L132_137 L52_56 0.0298
K1921 L132_137 L115_120 0.0334
K1922 L132_137 L80_85 0.0267
K1923 L132_137 L10_15 0.0215
K1924 L132_137 L16_21 0.0378
K1925 L132_137 L158_163 0.0389
K1926 L132_137 L185_189 0.0281
K1927 L132_137 L96_100 0.1015
K1928 L132_137 L49_53 0.0322
K1929 L132_137 L186_190 0.023
K1930 L132_137 L82_87 0.0445
K1931 L132_137 L125_130 0.038
K1932 L132_137 L108_113 0.0288
K1933 L132_137 L159_164 0.0354
K1934 L132_137 L84_89 0.0959
K1935 L132_137 L68_72 0.0457
K1936 L132_137 L169_174 0.0606
K1937 L132_137 L204_208 0.0346
K1938 L132_137 L25_30 0.0351
K1939 L132_137 L133_172 0.1187
K1940 L132_137 L14_19 0.0279
K1941 L132_137 L44_92 0.1173
K1942 L132_137 L21_26 0.0428
K1943 L132_137 L95_99 0.1226
K1944 L132_137 L116_121 0.0214
K1945 L132_137 L74_79 0.1131
K1946 L132_137 L165_170 0.0951
K1947 L132_137 L199_203 0.027
K1948 L132_137 L75_80 0.0269
K1949 L132_137 L143_148 0.1439
K1950 L132_137 L70_75 0.027
K1951 L132_137 L50_54 0.0208
K1952 L132_137 L79_84 0.1056
K1953 L132_137 L56_60 0.031
K1954 L132_137 L159_190 0.0247
K1955 L132_137 L93_97 0.0789
K1956 L132_137 L134_173 0.1049
K1957 L132_137 L139_144 0.1284
K1958 L132_137 L83_88 0.0624
K1959 L132_137 L177_181 0.0247
K1960 L132_137 L176_180 0.025
K1961 L132_137 L111_116 0.0209
K1962 L132_137 L162_167 0.051
K1963 L132_137 L43_91 0.1536
K1964 L132_137 L122_127 0.0278
K1965 L132_137 L135_140 0.0891
K1966 L132_137 L39_44 0.0989
K1967 L132_137 L123_128 0.0324
K1968 L132_137 L54_58 0.0214
K1969 L132_137 L146_151 0.1012
K1970 L132_137 L61_65 0.0374
K1971 L132_137 L11_16 0.0353
K1972 L132_137 L77_82 0.0451
K1973 L109_110 L167_168 0.0636
K1974 L109_110 L74_90 0.03
K1975 L109_110 L199_200 0.0337
K1976 L109_110 L115_179 0.213
K1977 L109_110 L128_129 0.123
K1978 L109_110 L147_148 0.0268
K1979 L109_110 L196_197 0.0386
K1980 L109_110 L73_74 0.0423
K1981 L109_110 L13_14 0.1019
K1982 L109_110 L23_24 0.0951
K1983 L109_110 L158_159 0.0887
K1984 L109_110 L136_198 0.0425
K1985 L109_110 L163_164 0.0785
K1986 L109_110 L144_145 0.0275
K1987 L109_110 L120_183 0.1616
K1988 L109_110 L91_92 0.0293
K1989 L109_110 L151_152 0.0216
K1990 L109_110 L126_127 0.055
K1991 L109_110 L22_23 0.1043
K1992 L109_110 L204_205 0.0352
K1993 L109_110 L99_100 0.0265
K1994 L109_110 L153_154 0.0212
K1995 L109_110 L34_35 0.0605
K1996 L109_110 L41_42 0.0397
K1997 L109_110 L16_61 0.1866
K1998 L109_110 L146_206 0.0381
K1999 L109_110 L197_198 0.0414
K2000 L109_110 L192_193 0.0373
K2001 L109_110 L88_89 0.0341
K2002 L109_110 L31_32 0.0665
K2003 L109_110 L143_144 0.0279
K2004 L109_110 L200_201 0.0369
K2005 L109_110 L205_206 0.0373
K2006 L109_110 L36_37 0.0523
K2007 L109_110 L131_132 0.04
K2008 L109_110 L100_101 0.0261
K2009 L109_110 L203_204 0.0324
K2010 L109_110 L92_93 0.0289
K2011 L109_110 L81_82 0.0351
K2012 L109_110 L131_194 0.0414
K2013 L109_110 L148_149 0.0266
K2014 L109_110 L19_20 0.0809
K2015 L109_110 L187_188 0.112
K2016 L109_110 L102_103 0.0213
K2017 L109_110 L160_161 0.0929
K2018 L109_110 L60_61 0.1387
K2019 L109_110 L64_65 0.1173
K2020 L109_110 L133_134 0.0389
K2021 L109_110 L26_27 0.0906
K2022 L109_110 L165_166 0.0674
K2023 L109_110 L170_171 0.0527
K2024 L109_110 L193_194 0.0403
K2025 L109_110 L63_64 0.077
K2026 L109_110 L21_65 0.1492
K2027 L109_110 L121_122 0.0601
K2028 L109_110 L119_120 0.2809
K2029 L109_110 L9_10 0.0922
K2030 L109_110 L43_44 0.0387
K2031 L109_110 L195_196 0.035
K2032 L109_110 L67_68 0.0372
K2033 L109_110 L33_34 0.0628
K2034 L109_110 L134_135 0.0382
K2035 L109_110 L41_69 0.0412
K2036 L109_110 L171_172 0.0519
K2037 L109_110 L104_105 0.0209
K2038 L109_110 L151_210 0.0342
K2039 L109_110 L79_94 0.0284
K2040 L109_110 L37_38 0.0515
K2041 L109_110 L75_76 0.0336
K2042 L109_110 L112_113 0.0947
K2043 L109_110 L183_184 0.132
K2044 L109_110 L59_60 0.0858
K2045 L109_110 L11_57 0.2334
K2046 L109_110 L38_39 0.0504
K2047 L109_110 L71_72 0.0385
K2048 L109_110 L27_28 0.0866
K2049 L109_110 L96_97 0.0274
K2050 L109_110 L78_79 0.04
K2051 L109_110 L44_45 0.038
K2052 L109_110 L29_30 0.0771
K2053 L109_110 L76_77 0.0367
K2054 L109_110 L114_115 0.4331
K2055 L109_110 L166_167 0.0657
K2056 L109_110 L185_186 0.0913
K2057 L109_110 L16_17 0.1183
K2058 L109_110 L188_189 0.0967
K2059 L109_110 L86_87 0.0317
K2060 L109_110 L118_119 0.1727
K2061 L109_110 L180_181 0.1194
K2062 L109_110 L6_53 0.2931
K2063 L109_110 L149_150 0.0262
K2064 L109_110 L98_99 0.0267
K2065 L109_110 L55_56 0.0896
K2066 L109_110 L84_98 0.0269
K2067 L109_110 L124_125 0.2072
K2068 L109_110 L113_114 0.2045
K2069 L109_110 L52_53 0.1765
K2070 L109_110 L80_81 0.0323
K2071 L109_110 L17_18 0.1049
K2072 L109_110 L141_202 0.0402
K2073 L109_110 L87_88 0.0334
K2074 L109_110 L146_147 0.027
K2075 L109_110 L209_210 0.0335
K2076 L109_110 L94_95 0.0281
K2077 L109_110 L136_137 0.0301
K2078 L109_110 L127_128 0.0785
K2079 L109_110 L138_139 0.0294
K2080 L109_110 L42_43 0.0393
K2081 L109_110 L181_182 0.0972
K2082 L109_110 L28_29 0.082
K2083 L109_110 L157_158 0.0984
K2084 L109_110 L122_123 0.0877
K2085 L109_110 L103_104 0.0211
K2086 L109_110 L66_67 0.0335
K2087 L109_110 L129_130 0.1605
K2088 L109_110 L21_22 0.1131
K2089 L109_110 L117_118 0.0917
K2090 L109_110 L51_52 0.0923
K2091 L109_110 L56_57 0.1576
K2092 L109_110 L24_25 0.0863
K2093 L109_110 L116_117 0.0613
K2094 L109_110 L6_7 0.1668
K2095 L109_110 L173_174 0.0496
K2096 L109_110 L154_155 0.021
K2097 L109_110 L32_33 0.0649
K2098 L109_110 L95_96 0.0278
K2099 L109_110 L85_86 0.0293
K2100 L109_110 L7_8 0.135
K2101 L109_110 L82_83 0.0372
K2102 L109_110 L14_15 0.0872
K2103 L109_110 L184_185 0.1086
K2104 L109_110 L141_142 0.0285
K2105 L109_110 L62_63 0.0545
K2106 L109_110 L125_187 0.1286
K2107 L109_110 L58_59 0.0595
K2108 L109_110 L70_71 0.0349
K2109 L109_110 L68_69 0.0401
K2110 L109_110 L89_102 0.0215
K2111 L109_110 L8_9 0.1103
K2112 L109_110 L50_51 0.0615
K2113 L109_110 L168_169 0.0612
K2114 L109_110 L83_84 0.038
K2115 L109_110 L90_91 0.0297
K2116 L109_110 L139_140 0.029
K2117 L109_110 L161_162 0.0886
K2118 L109_110 L111_112 0.0621
K2119 L109_110 L162_163 0.0836
K2120 L109_110 L137_138 0.0298
K2121 L109_110 L179_180 0.1546
K2122 L109_110 L12_13 0.1201
K2123 L109_110 L207_208 0.0294
K2124 L109_110 L142_143 0.0282
K2125 L109_110 L123_124 0.1475
K2126 L109_110 L152_153 0.0214
K2127 L109_110 L191_192 0.0336
K2128 L109_110 L39_40 0.0492
K2129 L109_110 L18_19 0.0921
K2130 L109_110 L130_156 0.1188
K2131 L109_110 L156_157 0.1087
K2132 L109_110 L189_190 0.084
K2133 L109_110 L11_12 0.1412
K2134 L109_110 L54_55 0.0607
K2135 L109_110 L201_202 0.0393
K2136 L99_100 L167_168 0.0451
K2137 L99_100 L74_90 0.1124
K2138 L99_100 L199_200 0.0339
K2139 L99_100 L115_179 0.021
K2140 L99_100 L128_129 0.0292
K2141 L99_100 L196_197 0.0438
K2142 L99_100 L73_74 0.1069
K2143 L99_100 L1_2 0.0172
K2144 L99_100 L23_24 0.0297
K2145 L99_100 L158_159 0.0294
K2146 L99_100 L136_198 0.1014
K2147 L99_100 L163_164 0.0361
K2148 L99_100 L144_145 0.1438
K2149 L99_100 L120_183 0.0221
K2150 L99_100 L91_92 0.1354
K2151 L99_100 L160_161 0.0359
K2152 L99_100 L151_152 0.1062
K2153 L99_100 L126_127 0.023
K2154 L99_100 L22_23 0.0296
K2155 L99_100 L138_139 0.1173
K2156 L99_100 L153_154 0.1363
K2157 L99_100 L4_5 0.0173
K2158 L99_100 L34_35 0.0454
K2159 L99_100 L41_42 0.0842
K2160 L99_100 L16_61 0.032
K2161 L99_100 L43_44 0.0898
K2162 L99_100 L197_198 0.0623
K2163 L99_100 L192_193 0.0406
K2164 L99_100 L88_89 0.0697
K2165 L99_100 L31_32 0.045
K2166 L99_100 L143_144 0.1536
K2167 L99_100 L200_201 0.0445
K2168 L99_100 L36_37 0.0595
K2169 L99_100 L131_132 0.0808
K2170 L99_100 L122_123 0.0266
K2171 L99_100 L92_93 0.1284
K2172 L99_100 L13_14 0.0224
K2173 L99_100 L131_194 0.0921
K2174 L99_100 L19_20 0.0237
K2175 L99_100 L187_188 0.0235
K2176 L99_100 L102_103 0.1673
K2177 L99_100 L106_107 0.0207
K2178 L99_100 L60_61 0.0296
K2179 L99_100 L64_65 0.0294
K2180 L99_100 L133_134 0.0857
K2181 L99_100 L8_9 0.0212
K2182 L99_100 L107_108 0.0228
K2183 L99_100 L170_171 0.0585
K2184 L99_100 L193_194 0.0575
K2185 L99_100 L63_64 0.0261
K2186 L99_100 L21_65 0.032
K2187 L99_100 L121_122 0.0238
K2188 L99_100 L119_120 0.0302
K2189 L99_100 L9_10 0.0212
K2190 L99_100 L46_47 0.0207
K2191 L99_100 L195_196 0.0336
K2192 L99_100 L67_68 0.041
K2193 L99_100 L33_34 0.0456
K2194 L99_100 L134_135 0.0844
K2195 L99_100 L41_69 0.0967
K2196 L99_100 L171_172 0.0596
K2197 L99_100 L104_105 0.1673
K2198 L99_100 L151_210 0.068
K2199 L99_100 L79_94 0.1439
K2200 L99_100 L37_38 0.0606
K2201 L99_100 L75_76 0.0341
K2202 L99_100 L112_113 0.0247
K2203 L99_100 L183_184 0.0222
K2204 L99_100 L59_60 0.0267
K2205 L99_100 L11_57 0.0303
K2206 L99_100 L38_39 0.061
K2207 L99_100 L108_109 0.0249
K2208 L99_100 L71_72 0.0442
K2209 L99_100 L27_28 0.0363
K2210 L99_100 L96_97 0.1832
K2211 L99_100 L78_79 0.1196
K2212 L99_100 L44_45 0.0883
K2213 L99_100 L47_48 0.0229
K2214 L99_100 L29_30 0.0363
K2215 L99_100 L76_77 0.0449
K2216 L99_100 L166_167 0.045
K2217 L99_100 L185_186 0.0222
K2218 L99_100 L177_178 0.0172
K2219 L99_100 L16_17 0.0235
K2220 L99_100 L188_189 0.0236
K2221 L99_100 L86_87 0.0339
K2222 L99_100 L118_119 0.0282
K2223 L99_100 L176_177 0.0173
K2224 L99_100 L3_4 0.0173
K2225 L99_100 L6_53 0.0288
K2226 L99_100 L2_3 0.0173
K2227 L99_100 L55_56 0.0257
K2228 L99_100 L113_114 0.027
K2229 L99_100 L48_49 0.025
K2230 L99_100 L110_175 0.0172
K2231 L99_100 L124_125 0.0319
K2232 L99_100 L114_115 0.0287
K2233 L99_100 L52_53 0.0271
K2234 L99_100 L17_18 0.0237
K2235 L99_100 L141_202 0.1117
K2236 L99_100 L87_88 0.0456
K2237 L99_100 L209_210 0.0451
K2238 L99_100 L94_95 0.1832
K2239 L99_100 L136_137 0.1015
K2240 L99_100 L127_128 0.0261
K2241 L99_100 L42_43 0.0883
K2242 L99_100 L181_182 0.0211
K2243 L99_100 L28_29 0.0364
K2244 L99_100 L157_158 0.0295
K2245 L99_100 L95_96 0.2054
K2246 L99_100 L66_67 0.0314
K2247 L99_100 L129_130 0.0319
K2248 L99_100 L21_22 0.0294
K2249 L99_100 L117_118 0.0257
K2250 L99_100 L51_52 0.0248
K2251 L99_100 L56_57 0.0283
K2252 L99_100 L24_25 0.0296
K2253 L99_100 L116_117 0.023
K2254 L99_100 L6_7 0.0211
K2255 L99_100 L173_174 0.0596
K2256 L99_100 L32_33 0.0454
K2257 L99_100 L103_104 0.1916
K2258 L99_100 L85_86 0.0269
K2259 L99_100 L7_8 0.0212
K2260 L99_100 L154_155 0.1266
K2261 L99_100 L14_15 0.0223
K2262 L99_100 L184_185 0.0223
K2263 L99_100 L141_142 0.1226
K2264 L99_100 L62_63 0.0231
K2265 L99_100 L125_187 0.0234
K2266 L99_100 L58_59 0.0238
K2267 L99_100 L70_71 0.0338
K2268 L99_100 L68_69 0.0585
K2269 L99_100 L180_181 0.0211
K2270 L99_100 L89_102 0.1268
K2271 L99_100 L26_27 0.0361
K2272 L99_100 L50_51 0.0224
K2273 L99_100 L168_169 0.045
K2274 L99_100 L165_166 0.0445
K2275 L99_100 L90_91 0.1284
K2276 L99_100 L139_140 0.1127
K2277 L99_100 L161_162 0.0361
K2278 L99_100 L111_112 0.0224
K2279 L99_100 L162_163 0.0362
K2280 L99_100 L137_138 0.1127
K2281 L99_100 L179_180 0.0211
K2282 L99_100 L12_13 0.0223
K2283 L99_100 L207_208 0.0268
K2284 L99_100 L142_143 0.1438
K2285 L99_100 L123_124 0.0295
K2286 L99_100 L152_153 0.1266
K2287 L99_100 L191_192 0.0312
K2288 L99_100 L39_40 0.0606
K2289 L99_100 L18_19 0.0237
K2290 L99_100 L130_156 0.0293
K2291 L99_100 L156_157 0.0294
K2292 L99_100 L189_190 0.0235
K2293 L99_100 L11_12 0.0222
K2294 L99_100 L54_55 0.0231
K2295 L99_100 L201_202 0.0643
K2296 L99_103 L24_29 0.0321
K2297 L99_103 L181_185 0.0221
K2298 L99_103 L140_145 0.088
K2299 L99_103 L1_6 0.0264
K2300 L99_103 L72_77 0.0423
K2301 L99_103 L35_40 0.0463
K2302 L99_103 L73_78 0.059
K2303 L99_103 L6_11 0.0277
K2304 L99_103 L163_168 0.0391
K2305 L99_103 L144_149 0.1438
K2306 L99_103 L130_160 0.0335
K2307 L99_103 L4_9 0.0211
K2308 L99_103 L26_31 0.0427
K2309 L99_103 L202_206 0.059
K2310 L99_103 L109_114 0.0276
K2311 L99_103 L57_61 0.0301
K2312 L99_103 L164_169 0.0357
K2313 L99_103 L195_199 0.0255
K2314 L99_103 L31_36 0.058
K2315 L99_103 L45_93 0.0823
K2316 L99_103 L106_111 0.0182
K2317 L99_103 L34_39 0.051
K2318 L99_103 L156_187 0.0248
K2319 L99_103 L201_205 0.0423
K2320 L99_103 L192_196 0.0325
K2321 L99_103 L53_57 0.0288
K2322 L99_103 L69_73 0.0575
K2323 L99_103 L200_204 0.0329
K2324 L99_103 L150_155 0.1033
K2325 L99_103 L145_150 0.0988
K2326 L99_103 L118_123 0.0269
K2327 L99_103 L30_35 0.036
K2328 L99_103 L194_198 0.0568
K2329 L99_103 L131_136 0.0836
K2330 L99_103 L101_105 0.1216
K2331 L99_103 L46_50 0.0182
K2332 L99_103 L196_200 0.0328
K2333 L99_103 L92_96 0.1439
K2334 L99_103 L81_86 0.0331
K2335 L99_103 L19_24 0.025
K2336 L99_103 L120_125 0.0291
K2337 L99_103 L160_165 0.0422
K2338 L99_103 L185_189 0.0234
K2339 L99_103 L60_64 0.028
K2340 L99_103 L198_202 0.0581
K2341 L99_103 L193_197 0.0415
K2342 L99_103 L168_173 0.0503
K2343 L99_103 L7_12 0.0222
K2344 L99_103 L137_142 0.1226
K2345 L99_103 L20_25 0.0206
K2346 L99_103 L121_126 0.0196
K2347 L99_103 L119_124 0.03
K2348 L99_103 L97_101 0.1144
K2349 L99_103 L110_115 0.0263
K2350 L99_103 L113_118 0.026
K2351 L99_103 L141_146 0.0941
K2352 L99_103 L182_186 0.0182
K2353 L99_103 L100_104 0.2054
K2354 L99_103 L166_171 0.0619
K2355 L99_103 L9_14 0.0222
K2356 L99_103 L132_171 0.093
K2357 L99_103 L134_139 0.1015
K2358 L99_103 L124_129 0.0314
K2359 L99_103 L107_112 0.0227
K2360 L99_103 L78_83 0.0599
K2361 L99_103 L112_117 0.0233
K2362 L99_103 L40_45 0.0641
K2363 L99_103 L183_187 0.0234
K2364 L99_103 L136_141 0.0897
K2365 L99_103 L59_63 0.0247
K2366 L99_103 L5_10 0.0174
K2367 L99_103 L71_76 0.0329
K2368 L99_103 L15_20 0.0194
K2369 L99_103 L51_55 0.0234
K2370 L99_103 L58_62 0.0197
K2371 L99_103 L67_71 0.0327
K2372 L99_103 L36_41 0.0887
K2373 L99_103 L48_52 0.0252
K2374 L99_103 L29_34 0.0394
K2375 L99_103 L179_183 0.0221
K2376 L99_103 L158_189 0.0248
K2377 L99_103 L206_210 0.0593
K2378 L99_103 L41_74 0.0869
K2379 L99_103 L131_170 0.0844
K2380 L99_103 L205_209 0.0424
K2381 L99_103 L191_195 0.0253
K2382 L99_103 L66_70 0.0254
K2383 L99_103 L98_102 0.2054
K2384 L99_103 L27_32 0.0465
K2385 L99_103 L142_147 0.1438
K2386 L99_103 L147_152 0.1536
K2387 L99_103 L178_182 0.0173
K2388 L99_103 L149_154 0.1536
K2389 L99_103 L203_207 0.0256
K2390 L99_103 L2_7 0.0211
K2391 L99_103 L117_122 0.024
K2392 L99_103 L22_27 0.0366
K2393 L99_103 L17_22 0.025
K2394 L99_103 L47_51 0.0227
K2395 L99_103 L55_59 0.024
K2396 L99_103 L135_174 0.0625
K2397 L99_103 L94_98 0.1832
K2398 L99_103 L52_56 0.0261
K2399 L99_103 L115_120 0.0276
K2400 L99_103 L80_85 0.0257
K2401 L99_103 L10_15 0.0183
K2402 L99_103 L16_21 0.0309
K2403 L99_103 L158_163 0.0319
K2404 L99_103 L96_100 0.1832
K2405 L99_103 L49_53 0.0277
K2406 L99_103 L186_190 0.0193
K2407 L99_103 L156_161 0.0364
K2408 L99_103 L82_87 0.0427
K2409 L99_103 L125_130 0.0307
K2410 L99_103 L108_113 0.0251
K2411 L99_103 L159_164 0.0293
K2412 L99_103 L84_89 0.1011
K2413 L99_103 L68_72 0.0418
K2414 L99_103 L169_174 0.0457
K2415 L99_103 L204_208 0.033
K2416 L99_103 L37_42 0.098
K2417 L99_103 L25_30 0.0295
K2418 L99_103 L32_37 0.0633
K2419 L99_103 L14_19 0.0235
K2420 L99_103 L44_92 0.1124
K2421 L99_103 L161_166 0.0459
K2422 L99_103 L21_26 0.0338
K2423 L99_103 L116_121 0.0191
K2424 L99_103 L74_79 0.0939
K2425 L99_103 L165_170 0.0568
K2426 L99_103 L199_203 0.0256
K2427 L99_103 L75_80 0.0257
K2428 L99_103 L70_75 0.0256
K2429 L99_103 L50_54 0.0187
K2430 L99_103 L79_84 0.0991
K2431 L99_103 L56_60 0.027
K2432 L99_103 L159_190 0.0204
K2433 L99_103 L93_97 0.0985
K2434 L99_103 L90_94 0.1439
K2435 L99_103 L134_173 0.0699
K2436 L99_103 L139_144 0.1226
K2437 L99_103 L83_88 0.0602
K2438 L99_103 L177_181 0.021
K2439 L99_103 L111_116 0.0186
K2440 L99_103 L122_127 0.0246
K2441 L99_103 L135_140 0.0759
K2442 L99_103 L39_44 0.0718
K2443 L99_103 L123_128 0.0279
K2444 L99_103 L12_17 0.0235
K2445 L99_103 L54_58 0.0192
K2446 L99_103 L146_151 0.0958
K2447 L99_103 L114_119 0.0288
K2448 L99_103 L61_65 0.0315
K2449 L99_103 L11_16 0.0292
K2450 L99_103 L77_82 0.0426
K2451 L16_61 L167_168 0.0819
K2452 L16_61 L74_90 0.037
K2453 L16_61 L199_200 0.0393
K2454 L16_61 L115_179 0.0885
K2455 L16_61 L128_129 0.1674
K2456 L16_61 L147_148 0.0323
K2457 L16_61 L196_197 0.0461
K2458 L16_61 L95_96 0.0339
K2459 L16_61 L73_74 0.0523
K2460 L16_61 L1_2 0.0746
K2461 L16_61 L23_24 0.1374
K2462 L16_61 L158_159 0.1114
K2463 L16_61 L136_198 0.052
K2464 L16_61 L163_164 0.1009
K2465 L16_61 L144_145 0.0331
K2466 L16_61 L120_183 0.095
K2467 L16_61 L91_92 0.0359
K2468 L16_61 L160_161 0.1312
K2469 L16_61 L151_152 0.0259
K2470 L16_61 L126_127 0.0611
K2471 L16_61 L22_23 0.1656
K2472 L16_61 L204_205 0.0418
K2473 L16_61 L153_154 0.0254
K2474 L16_61 L4_5 0.052
K2475 L16_61 L34_35 0.0788
K2476 L16_61 L41_42 0.0498
K2477 L16_61 L43_44 0.0481
K2478 L16_61 L146_206 0.046
K2479 L16_61 L197_198 0.0504
K2480 L16_61 L192_193 0.0447
K2481 L16_61 L88_89 0.0413
K2482 L16_61 L31_32 0.0912
K2483 L16_61 L143_144 0.0337
K2484 L16_61 L200_201 0.0439
K2485 L16_61 L205_206 0.0448
K2486 L16_61 L36_37 0.0676
K2487 L16_61 L131_132 0.0494
K2488 L16_61 L100_101 0.0315
K2489 L16_61 L203_204 0.0378
K2490 L16_61 L92_93 0.0352
K2491 L16_61 L81_82 0.0419
K2492 L16_61 L13_14 0.0741
K2493 L16_61 L131_194 0.051
K2494 L16_61 L148_149 0.0319
K2495 L16_61 L165_166 0.0893
K2496 L16_61 L102_103 0.0258
K2497 L16_61 L106_107 0.0595
K2498 L16_61 L64_65 0.1877
K2499 L16_61 L133_134 0.0477
K2500 L16_61 L26_27 0.1377
K2501 L16_61 L107_108 0.0858
K2502 L16_61 L170_171 0.0669
K2503 L16_61 L193_194 0.0492
K2504 L16_61 L63_64 0.0934
K2505 L16_61 L21_65 0.3407
K2506 L16_61 L119_120 0.2659
K2507 L16_61 L9_10 0.0634
K2508 L16_61 L46_47 0.0601
K2509 L16_61 L195_196 0.041
K2510 L16_61 L67_68 0.045
K2511 L16_61 L33_34 0.0833
K2512 L16_61 L134_135 0.0466
K2513 L16_61 L41_69 0.0513
K2514 L16_61 L171_172 0.0654
K2515 L16_61 L104_105 0.0251
K2516 L16_61 L151_210 0.0411
K2517 L16_61 L79_94 0.0347
K2518 L16_61 L37_38 0.0661
K2519 L16_61 L75_76 0.0395
K2520 L16_61 L112_113 0.0931
K2521 L16_61 L183_184 0.0822
K2522 L16_61 L11_57 0.3334
K2523 L16_61 L38_39 0.0642
K2524 L16_61 L108_109 0.1387
K2525 L16_61 L71_72 0.0464
K2526 L16_61 L27_28 0.1263
K2527 L16_61 L78_79 0.0491
K2528 L16_61 L44_45 0.0469
K2529 L16_61 L47_48 0.0877
K2530 L16_61 L29_30 0.1037
K2531 L16_61 L76_77 0.0441
K2532 L16_61 L114_115 0.2117
K2533 L16_61 L166_167 0.0859
K2534 L16_61 L185_186 0.0643
K2535 L16_61 L177_178 0.0511
K2536 L16_61 L191_192 0.0394
K2537 L16_61 L86_87 0.0377
K2538 L16_61 L118_119 0.1743
K2539 L16_61 L176_177 0.0568
K2540 L16_61 L3_4 0.0581
K2541 L16_61 L6_53 0.2392
K2542 L16_61 L149_150 0.0314
K2543 L16_61 L2_3 0.0655
K2544 L16_61 L98_99 0.0324
K2545 L16_61 L55_56 0.0993
K2546 L16_61 L84_98 0.0328
K2547 L16_61 L48_49 0.1475
K2548 L16_61 L110_175 0.0719
K2549 L16_61 L113_114 0.1537
K2550 L16_61 L52_53 0.1646
K2551 L16_61 L80_81 0.0379
K2552 L16_61 L141_202 0.0488
K2553 L16_61 L87_88 0.0403
K2554 L16_61 L146_147 0.0326
K2555 L16_61 L209_210 0.0401
K2556 L16_61 L94_95 0.0344
K2557 L16_61 L136_137 0.0368
K2558 L16_61 L127_128 0.0911
K2559 L16_61 L138_139 0.0357
K2560 L16_61 L42_43 0.049
K2561 L16_61 L181_182 0.0623
K2562 L16_61 L28_29 0.1147
K2563 L16_61 L157_158 0.1293
K2564 L16_61 L96_97 0.0333
K2565 L16_61 L66_67 0.0395
K2566 L16_61 L129_130 0.2623
K2567 L16_61 L21_22 0.2011
K2568 L16_61 L117_118 0.0969
K2569 L16_61 L51_52 0.0952
K2570 L16_61 L56_57 0.1933
K2571 L16_61 L24_25 0.1163
K2572 L16_61 L116_117 0.0653
K2573 L16_61 L6_7 0.0921
K2574 L16_61 L173_174 0.0615
K2575 L16_61 L154_155 0.025
K2576 L16_61 L32_33 0.0876
K2577 L16_61 L103_104 0.0255
K2578 L16_61 L85_86 0.0343
K2579 L16_61 L7_8 0.0803
K2580 L16_61 L82_83 0.045
K2581 L16_61 L14_15 0.0656
K2582 L16_61 L184_185 0.0723
K2583 L16_61 L141_142 0.0346
K2584 L16_61 L62_63 0.0618
K2585 L16_61 L70_71 0.0411
K2586 L16_61 L68_69 0.0495
K2587 L16_61 L180_181 0.0693
K2588 L16_61 L89_102 0.026
K2589 L16_61 L8_9 0.071
K2590 L16_61 L50_51 0.0648
K2591 L16_61 L168_169 0.0776
K2592 L16_61 L83_84 0.0462
K2593 L16_61 L90_91 0.0365
K2594 L16_61 L139_140 0.035
K2595 L16_61 L161_162 0.1213
K2596 L16_61 L111_112 0.0642
K2597 L16_61 L162_163 0.1109
K2598 L16_61 L137_138 0.0363
K2599 L16_61 L179_180 0.078
K2600 L16_61 L12_13 0.0851
K2601 L16_61 L207_208 0.0342
K2602 L16_61 L142_143 0.0342
K2603 L16_61 L152_153 0.0257
K2604 L16_61 L39_40 0.0621
K2605 L16_61 L130_156 0.1766
K2606 L16_61 L156_157 0.1514
K2607 L16_61 L11_12 0.0996
K2608 L16_61 L54_55 0.066
K2609 L16_61 L201_202 0.0474
K2610 L45_93 L24_29 0.0386
K2611 L45_93 L181_185 0.022
K2612 L45_93 L1_6 0.0247
K2613 L45_93 L13_18 0.0234
K2614 L45_93 L23_28 0.0379
K2615 L45_93 L73_78 0.0421
K2616 L45_93 L184_188 0.0232
K2617 L45_93 L6_11 0.026
K2618 L45_93 L163_168 0.0517
K2619 L45_93 L91_95 0.1144
K2620 L45_93 L144_149 0.1062
K2621 L45_93 L130_160 0.0336
K2622 L45_93 L4_9 0.0207
K2623 L45_93 L26_31 0.0445
K2624 L45_93 L109_114 0.0247
K2625 L45_93 L57_61 0.0269
K2626 L45_93 L195_199 0.0194
K2627 L45_93 L31_36 0.0622
K2628 L45_93 L106_111 0.0154
K2629 L45_93 L34_39 0.0827
K2630 L45_93 L148_153 0.0759
K2631 L45_93 L156_187 0.0245
K2632 L45_93 L201_205 0.031
K2633 L45_93 L192_196 0.0249
K2634 L45_93 L53_57 0.0258
K2635 L45_93 L69_73 0.0423
K2636 L45_93 L200_204 0.0248
K2637 L45_93 L118_123 0.0233
K2638 L45_93 L194_198 0.0418
K2639 L45_93 L131_136 0.0604
K2640 L45_93 L100_104 0.0968
K2641 L45_93 L46_50 0.0155
K2642 L45_93 L196_200 0.0249
K2643 L45_93 L92_96 0.1673
K2644 L45_93 L81_86 0.0247
K2645 L45_93 L19_24 0.0254
K2646 L45_93 L120_125 0.0274
K2647 L45_93 L8_13 0.0219
K2648 L45_93 L157_188 0.0249
K2649 L45_93 L133_138 0.1033
K2650 L45_93 L60_64 0.0241
K2651 L45_93 L72_77 0.0313
K2652 L45_93 L198_202 0.0417
K2653 L45_93 L193_197 0.0312
K2654 L45_93 L168_173 0.0784
K2655 L45_93 L7_12 0.0216
K2656 L45_93 L137_142 0.0789
K2657 L45_93 L143_148 0.088
K2658 L45_93 L167_172 0.0728
K2659 L45_93 L121_126 0.0165
K2660 L45_93 L119_124 0.0268
K2661 L45_93 L110_115 0.0246
K2662 L45_93 L113_118 0.0226
K2663 L45_93 L134_139 0.1363
K2664 L45_93 L141_146 0.0581
K2665 L45_93 L17_22 0.0247
K2666 L45_93 L166_171 0.0666
K2667 L45_93 L9_14 0.0221
K2668 L45_93 L138_143 0.0988
K2669 L45_93 L33_38 0.0762
K2670 L45_93 L18_23 0.0251
K2671 L45_93 L132_171 0.093
K2672 L45_93 L124_129 0.028
K2673 L45_93 L107_112 0.0193
K2674 L45_93 L78_83 0.0417
K2675 L45_93 L112_117 0.0198
K2676 L45_93 L183_187 0.0229
K2677 L45_93 L136_141 0.0598
K2678 L45_93 L59_63 0.0208
K2679 L45_93 L71_76 0.025
K2680 L45_93 L51_55 0.0199
K2681 L45_93 L58_62 0.0165
K2682 L45_93 L67_71 0.025
K2683 L45_93 L36_41 0.0877
K2684 L45_93 L48_52 0.0219
K2685 L45_93 L29_34 0.0528
K2686 L45_93 L179_183 0.0215
K2687 L45_93 L206_210 0.0405
K2688 L45_93 L41_74 0.0622
K2689 L45_93 L131_170 0.082
K2690 L45_93 L28_33 0.051
K2691 L45_93 L205_209 0.0307
K2692 L45_93 L191_195 0.0195
K2693 L45_93 L66_70 0.0195
K2694 L45_93 L98_102 0.0696
K2695 L45_93 L27_32 0.0488
K2696 L45_93 L142_147 0.073
K2697 L45_93 L147_152 0.0657
K2698 L45_93 L180_184 0.0218
K2699 L45_93 L3_8 0.0206
K2700 L45_93 L157_162 0.0375
K2701 L45_93 L149_154 0.0867
K2702 L45_93 L203_207 0.0193
K2703 L45_93 L2_7 0.0203
K2704 L45_93 L117_122 0.0203
K2705 L45_93 L22_27 0.037
K2706 L45_93 L158_189 0.0252
K2707 L45_93 L38_43 0.1262
K2708 L45_93 L47_51 0.0194
K2709 L45_93 L108_113 0.0219
K2710 L45_93 L94_98 0.0787
K2711 L45_93 L160_165 0.0437
K2712 L45_93 L52_56 0.0227
K2713 L45_93 L115_120 0.0259
K2714 L45_93 L80_85 0.0193
K2715 L45_93 L16_21 0.0292
K2716 L45_93 L158_163 0.0382
K2717 L45_93 L185_189 0.0235
K2718 L45_93 L96_100 0.1268
K2719 L45_93 L49_53 0.0248
K2720 L45_93 L156_161 0.0366
K2721 L45_93 L82_87 0.0308
K2722 L45_93 L125_130 0.029
K2723 L45_93 L55_59 0.0204
K2724 L45_93 L84_89 0.057
K2725 L45_93 L68_72 0.0314
K2726 L45_93 L204_208 0.0246
K2727 L45_93 L37_42 0.1002
K2728 L45_93 L202_206 0.0412
K2729 L45_93 L32_37 0.0691
K2730 L45_93 L133_172 0.1123
K2731 L45_93 L14_19 0.0237
K2732 L45_93 L44_92 0.1916
K2733 L45_93 L161_166 0.0479
K2734 L45_93 L21_26 0.0339
K2735 L45_93 L95_99 0.0985
K2736 L45_93 L116_121 0.0161
K2737 L45_93 L74_79 0.0615
K2738 L45_93 L165_170 0.0601
K2739 L45_93 L199_203 0.0194
K2740 L45_93 L75_80 0.0194
K2741 L45_93 L70_75 0.0195
K2742 L45_93 L50_54 0.0158
K2743 L45_93 L79_84 0.0597
K2744 L45_93 L56_60 0.0234
K2745 L45_93 L90_94 0.0861
K2746 L45_93 L134_173 0.1366
K2747 L45_93 L139_144 0.1266
K2748 L45_93 L83_88 0.0409
K2749 L45_93 L177_181 0.0206
K2750 L45_93 L176_180 0.0204
K2751 L45_93 L111_116 0.0158
K2752 L45_93 L162_167 0.05
K2753 L45_93 L43_91 0.1216
K2754 L45_93 L122_127 0.0208
K2755 L45_93 L39_44 0.1671
K2756 L45_93 L123_128 0.0241
K2757 L45_93 L12_17 0.023
K2758 L45_93 L54_58 0.0162
K2759 L45_93 L146_151 0.0556
K2760 L45_93 L114_119 0.0257
K2761 L45_93 L61_65 0.0281
K2762 L45_93 L11_16 0.0275
K2763 L45_93 L77_82 0.0312
K2764 L43_44 L167_168 0.0772
K2765 L43_44 L74_90 0.1231
K2766 L43_44 L199_200 0.0342
K2767 L43_44 L115_179 0.0311
K2768 L43_44 L128_129 0.0425
K2769 L43_44 L196_197 0.043
K2770 L43_44 L73_74 0.0838
K2771 L43_44 L1_2 0.0255
K2772 L43_44 L23_24 0.0458
K2773 L43_44 L158_159 0.0453
K2774 L43_44 L136_198 0.082
K2775 L43_44 L163_164 0.057
K2776 L43_44 L144_145 0.1006
K2777 L43_44 L120_183 0.0332
K2778 L43_44 L91_92 0.1436
K2779 L43_44 L160_161 0.0564
K2780 L43_44 L151_152 0.06
K2781 L43_44 L126_127 0.031
K2782 L43_44 L22_23 0.0457
K2783 L43_44 L153_154 0.0629
K2784 L43_44 L4_5 0.0257
K2785 L43_44 L34_35 0.0782
K2786 L43_44 L146_206 0.0729
K2787 L43_44 L197_198 0.0568
K2788 L43_44 L204_205 0.0415
K2789 L43_44 L88_89 0.0657
K2790 L43_44 L31_32 0.0766
K2791 L43_44 L143_144 0.1029
K2792 L43_44 L200_201 0.0423
K2793 L43_44 L205_206 0.0535
K2794 L43_44 L36_37 0.1157
K2795 L43_44 L141_142 0.0947
K2796 L43_44 L100_101 0.0883
K2797 L43_44 L203_204 0.0337
K2798 L43_44 L92_93 0.1375
K2799 L43_44 L81_82 0.0418
K2800 L43_44 L13_14 0.0338
K2801 L43_44 L185_186 0.0335
K2802 L43_44 L148_149 0.0857
K2803 L43_44 L19_20 0.0362
K2804 L43_44 L187_188 0.0359
K2805 L43_44 L165_166 0.0751
K2806 L43_44 L102_103 0.0644
K2807 L43_44 L106_107 0.0279
K2808 L43_44 L60_61 0.0429
K2809 L43_44 L64_65 0.0428
K2810 L43_44 L8_9 0.0316
K2811 L43_44 L107_108 0.0316
K2812 L43_44 L170_171 0.1106
K2813 L43_44 L63_64 0.0365
K2814 L43_44 L21_65 0.0488
K2815 L43_44 L121_122 0.032
K2816 L43_44 L119_120 0.0448
K2817 L43_44 L9_10 0.0315
K2818 L43_44 L46_47 0.028
K2819 L43_44 L195_196 0.0345
K2820 L43_44 L33_34 0.0788
K2821 L43_44 L171_172 0.116
K2822 L43_44 L104_105 0.0644
K2823 L43_44 L151_210 0.0648
K2824 L43_44 L79_94 0.1004
K2825 L43_44 L37_38 0.122
K2826 L43_44 L75_76 0.0343
K2827 L43_44 L112_113 0.0343
K2828 L43_44 L183_184 0.0335
K2829 L43_44 L59_60 0.0372
K2830 L43_44 L11_57 0.045
K2831 L43_44 L38_39 0.1244
K2832 L43_44 L108_109 0.0355
K2833 L43_44 L71_72 0.0433
K2834 L43_44 L27_28 0.0577
K2835 L43_44 L96_97 0.1076
K2836 L43_44 L78_79 0.0791
K2837 L43_44 L138_139 0.1276
K2838 L43_44 L47_48 0.0317
K2839 L43_44 L29_30 0.0577
K2840 L43_44 L76_77 0.0426
K2841 L43_44 L114_115 0.0421
K2842 L43_44 L166_167 0.0767
K2843 L43_44 L177_178 0.0255
K2844 L43_44 L16_17 0.0359
K2845 L43_44 L188_189 0.036
K2846 L43_44 L86_87 0.0383
K2847 L43_44 L118_119 0.0405
K2848 L43_44 L176_177 0.0256
K2849 L43_44 L3_4 0.0257
K2850 L43_44 L6_53 0.0424
K2851 L43_44 L149_150 0.0844
K2852 L43_44 L2_3 0.0257
K2853 L43_44 L98_99 0.0883
K2854 L43_44 L55_56 0.0358
K2855 L43_44 L184_185 0.0335
K2856 L43_44 L84_98 0.0842
K2857 L43_44 L48_49 0.0356
K2858 L43_44 L110_175 0.0254
K2859 L43_44 L124_125 0.0477
K2860 L43_44 L113_114 0.0385
K2861 L43_44 L52_53 0.0387
K2862 L43_44 L80_81 0.0339
K2863 L43_44 L17_18 0.0362
K2864 L43_44 L141_202 0.0776
K2865 L43_44 L87_88 0.049
K2866 L43_44 L146_147 0.0808
K2867 L43_44 L209_210 0.0486
K2868 L43_44 L94_95 0.1076
K2869 L43_44 L127_128 0.0363
K2870 L43_44 L181_182 0.0313
K2871 L43_44 L28_29 0.0579
K2872 L43_44 L157_158 0.0454
K2873 L43_44 L122_123 0.0371
K2874 L43_44 L103_104 0.0652
K2875 L43_44 L129_130 0.0484
K2876 L43_44 L21_22 0.0453
K2877 L43_44 L117_118 0.0356
K2878 L43_44 L51_52 0.0344
K2879 L43_44 L56_57 0.0407
K2880 L43_44 L24_25 0.0457
K2881 L43_44 L116_117 0.0311
K2882 L43_44 L6_7 0.0313
K2883 L43_44 L173_174 0.116
K2884 L43_44 L154_155 0.0622
K2885 L43_44 L32_33 0.0782
K2886 L43_44 L95_96 0.1104
K2887 L43_44 L85_86 0.0312
K2888 L43_44 L7_8 0.0315
K2889 L43_44 L82_83 0.054
K2890 L43_44 L14_15 0.0337
K2891 L43_44 L147_148 0.0844
K2892 L43_44 L62_63 0.0311
K2893 L43_44 L125_187 0.0356
K2894 L43_44 L58_59 0.0321
K2895 L43_44 L70_71 0.0346
K2896 L43_44 L136_137 0.1128
K2897 L43_44 L180_181 0.0314
K2898 L43_44 L89_102 0.0621
K2899 L43_44 L26_27 0.057
K2900 L43_44 L50_51 0.0303
K2901 L43_44 L168_169 0.0767
K2902 L43_44 L83_84 0.0742
K2903 L43_44 L90_91 0.1375
K2904 L43_44 L139_140 0.1234
K2905 L43_44 L161_162 0.057
K2906 L43_44 L111_112 0.0302
K2907 L43_44 L162_163 0.0572
K2908 L43_44 L137_138 0.1234
K2909 L43_44 L179_180 0.0313
K2910 L43_44 L12_13 0.0337
K2911 L43_44 L207_208 0.0311
K2912 L43_44 L142_143 0.1006
K2913 L43_44 L123_124 0.0427
K2914 L43_44 L152_153 0.0622
K2915 L43_44 L39_40 0.122
K2916 L43_44 L18_19 0.0363
K2917 L43_44 L130_156 0.0449
K2918 L43_44 L156_157 0.0453
K2919 L43_44 L189_190 0.0359
K2920 L43_44 L11_12 0.0334
K2921 L43_44 L54_55 0.0312
K2922 L43_44 L201_202 0.0553
K2923 L176_180 L24_29 0.093
K2924 L176_180 L181_185 0.1832
K2925 L176_180 L140_145 0.0194
K2926 L176_180 L1_6 0.0958
K2927 L176_180 L72_77 0.0269
K2928 L176_180 L35_40 0.0418
K2929 L176_180 L73_78 0.03
K2930 L176_180 L6_11 0.0941
K2931 L176_180 L163_168 0.0633
K2932 L176_180 L144_149 0.0222
K2933 L176_180 L130_160 0.1305
K2934 L176_180 L4_9 0.1536
K2935 L176_180 L26_31 0.0729
K2936 L176_180 L202_206 0.0288
K2937 L176_180 L109_114 0.0602
K2938 L176_180 L57_61 0.0581
K2939 L176_180 L164_169 0.0569
K2940 L176_180 L195_199 0.0192
K2941 L176_180 L31_36 0.051
K2942 L176_180 L106_111 0.0257
K2943 L176_180 L34_39 0.0459
K2944 L176_180 L156_187 0.1124
K2945 L176_180 L201_205 0.0261
K2946 L176_180 L192_196 0.0247
K2947 L176_180 L53_57 0.059
K2948 L176_180 L69_73 0.0314
K2949 L176_180 L200_204 0.0234
K2950 L176_180 L150_155 0.0174
K2951 L176_180 L145_150 0.0183
K2952 L176_180 L118_123 0.0423
K2953 L176_180 L30_35 0.0557
K2954 L176_180 L194_198 0.0315
K2955 L176_180 L131_136 0.0309
K2956 L176_180 L101_105 0.0173
K2957 L176_180 L46_50 0.0256
K2958 L176_180 L196_200 0.024
K2959 L176_180 L92_96 0.0234
K2960 L176_180 L81_86 0.0227
K2961 L176_180 L19_24 0.1015
K2962 L176_180 L120_125 0.0939
K2963 L176_180 L160_165 0.0756
K2964 L176_180 L185_189 0.1439
K2965 L176_180 L60_64 0.0415
K2966 L176_180 L198_202 0.0301
K2967 L176_180 L193_197 0.028
K2968 L176_180 L168_173 0.0465
K2969 L176_180 L7_12 0.1438
K2970 L176_180 L137_142 0.0235
K2971 L176_180 L20_25 0.0759
K2972 L176_180 L121_126 0.0254
K2973 L176_180 L119_124 0.059
K2974 L176_180 L97_101 0.0182
K2975 L176_180 L110_115 0.1011
K2976 L176_180 L113_118 0.0426
K2977 L176_180 L141_146 0.0277
K2978 L176_180 L182_186 0.1144
K2979 L176_180 L100_104 0.021
K2980 L176_180 L166_171 0.0565
K2981 L176_180 L9_14 0.1438
K2982 L176_180 L132_171 0.0427
K2983 L176_180 L134_139 0.025
K2984 L176_180 L124_129 0.0575
K2985 L176_180 L107_112 0.0331
K2986 L176_180 L78_83 0.0288
K2987 L176_180 L112_117 0.0331
K2988 L176_180 L40_45 0.0333
K2989 L176_180 L183_187 0.1439
K2990 L176_180 L136_141 0.0292
K2991 L176_180 L59_63 0.0325
K2992 L176_180 L5_10 0.1033
K2993 L176_180 L71_76 0.024
K2994 L176_180 L15_20 0.088
K2995 L176_180 L51_55 0.0329
K2996 L176_180 L58_62 0.0253
K2997 L176_180 L67_71 0.0246
K2998 L176_180 L36_41 0.0389
K2999 L176_180 L48_52 0.0424
K3000 L176_180 L29_34 0.0619
K3001 L176_180 L179_183 0.1832
K3002 L176_180 L158_189 0.1124
K3003 L176_180 L206_210 0.0277
K3004 L176_180 L41_74 0.0307
K3005 L176_180 L131_170 0.0392
K3006 L176_180 L205_209 0.0252
K3007 L176_180 L191_195 0.0197
K3008 L176_180 L66_70 0.0196
K3009 L176_180 L98_102 0.021
K3010 L176_180 L27_32 0.08
K3011 L176_180 L142_147 0.0222
K3012 L176_180 L147_152 0.0211
K3013 L176_180 L178_182 0.1216
K3014 L176_180 L149_154 0.0211
K3015 L176_180 L203_207 0.0182
K3016 L176_180 L2_7 0.1536
K3017 L176_180 L117_122 0.0329
K3018 L176_180 L22_27 0.1319
K3019 L176_180 L17_22 0.1015
K3020 L176_180 L47_51 0.033
K3021 L176_180 L55_59 0.0328
K3022 L176_180 L135_174 0.0335
K3023 L176_180 L94_98 0.0221
K3024 L176_180 L52_56 0.0423
K3025 L176_180 L115_120 0.0991
K3026 L176_180 L80_85 0.0182
K3027 L176_180 L10_15 0.0988
K3028 L176_180 L16_21 0.0836
K3029 L176_180 L158_163 0.098
K3030 L176_180 L96_100 0.0221
K3031 L176_180 L49_53 0.0593
K3032 L176_180 L186_190 0.0985
K3033 L176_180 L156_161 0.1482
K3034 L176_180 L82_87 0.0251
K3035 L176_180 L125_130 0.0869
K3036 L176_180 L108_113 0.0427
K3037 L176_180 L159_164 0.0849
K3038 L176_180 L84_89 0.0263
K3039 L176_180 L68_72 0.0279
K3040 L176_180 L169_174 0.0423
K3041 L176_180 L204_208 0.0227
K3042 L176_180 L37_42 0.0422
K3043 L176_180 L25_30 0.0812
K3044 L176_180 L32_37 0.0555
K3045 L176_180 L14_19 0.1226
K3046 L176_180 L44_92 0.0248
K3047 L176_180 L161_166 0.083
K3048 L176_180 L21_26 0.1175
K3049 L176_180 L116_121 0.0256
K3050 L176_180 L74_79 0.0291
K3051 L176_180 L165_170 0.0518
K3052 L176_180 L199_203 0.0187
K3053 L176_180 L75_80 0.0186
K3054 L176_180 L70_75 0.0191
K3055 L176_180 L50_54 0.0256
K3056 L176_180 L79_84 0.0276
K3057 L176_180 L56_60 0.042
K3058 L176_180 L159_190 0.0823
K3059 L176_180 L93_97 0.0193
K3060 L176_180 L90_94 0.0234
K3061 L176_180 L134_173 0.0366
K3062 L176_180 L139_144 0.0235
K3063 L176_180 L83_88 0.0276
K3064 L176_180 L177_181 0.2054
K3065 L176_180 L111_116 0.0257
K3066 L176_180 L122_127 0.0327
K3067 L176_180 L135_140 0.0206
K3068 L176_180 L39_44 0.0364
K3069 L176_180 L123_128 0.0418
K3070 L176_180 L12_17 0.1226
K3071 L176_180 L54_58 0.0255
K3072 L176_180 L146_151 0.0264
K3073 L176_180 L114_119 0.0599
K3074 L176_180 L61_65 0.0568
K3075 L176_180 L11_16 0.0897
K3076 L176_180 L77_82 0.026
K3077 L156_187 L24_29 0.1293
K3078 L156_187 L181_185 0.1124
K3079 L156_187 L140_145 0.023
K3080 L156_187 L1_6 0.0959
K3081 L156_187 L13_18 0.1438
K3082 L156_187 L35_40 0.0534
K3083 L156_187 L23_28 0.1572
K3084 L156_187 L73_78 0.0355
K3085 L156_187 L184_188 0.1832
K3086 L156_187 L6_11 0.1056
K3087 L156_187 L163_168 0.0898
K3088 L156_187 L91_95 0.0283
K3089 L156_187 L144_149 0.0263
K3090 L156_187 L130_160 0.3319
K3091 L156_187 L4_9 0.0884
K3092 L156_187 L26_31 0.1339
K3093 L156_187 L202_206 0.034
K3094 L156_187 L109_114 0.0634
K3095 L156_187 L57_61 0.0655
K3096 L156_187 L164_169 0.077
K3097 L156_187 L195_199 0.0214
K3098 L156_187 L31_36 0.0763
K3099 L156_187 L106_111 0.0268
K3100 L156_187 L34_39 0.0598
K3101 L156_187 L148_153 0.025
K3102 L156_187 L201_205 0.03
K3103 L156_187 L192_196 0.0278
K3104 L156_187 L53_57 0.0643
K3105 L156_187 L69_73 0.0374
K3106 L156_187 L200_204 0.0262
K3107 L156_187 L150_155 0.0203
K3108 L156_187 L145_150 0.0216
K3109 L156_187 L118_123 0.0459
K3110 L156_187 L30_35 0.0742
K3111 L156_187 L194_198 0.0376
K3112 L156_187 L131_136 0.038
K3113 L156_187 L101_105 0.0202
K3114 L156_187 L46_50 0.0267
K3115 L156_187 L196_200 0.027
K3116 L156_187 L92_96 0.0279
K3117 L156_187 L81_86 0.0254
K3118 L156_187 L19_24 0.1173
K3119 L156_187 L120_125 0.1224
K3120 L156_187 L8_13 0.1226
K3121 L156_187 L157_188 0.2054
K3122 L156_187 L133_138 0.0306
K3123 L156_187 L60_64 0.0457
K3124 L156_187 L72_77 0.031
K3125 L156_187 L198_202 0.0357
K3126 L156_187 L193_197 0.0324
K3127 L156_187 L168_173 0.061
K3128 L156_187 L20_25 0.0811
K3129 L156_187 L167_172 0.0633
K3130 L156_187 L121_126 0.0272
K3131 L156_187 L119_124 0.0667
K3132 L156_187 L97_101 0.0215
K3133 L156_187 L110_115 0.1012
K3134 L156_187 L113_118 0.0455
K3135 L156_187 L141_146 0.0334
K3136 L156_187 L182_186 0.0787
K3137 L156_187 L100_104 0.0246
K3138 L156_187 L9_14 0.1015
K3139 L156_187 L138_143 0.0285
K3140 L156_187 L33_38 0.0619
K3141 L156_187 L18_23 0.1536
K3142 L156_187 L134_139 0.0302
K3143 L156_187 L124_129 0.0671
K3144 L156_187 L107_112 0.0346
K3145 L156_187 L78_83 0.0338
K3146 L156_187 L112_117 0.0349
K3147 L156_187 L40_45 0.0408
K3148 L156_187 L136_141 0.0356
K3149 L156_187 L59_63 0.0349
K3150 L156_187 L5_10 0.0657
K3151 L156_187 L71_76 0.0269
K3152 L156_187 L15_20 0.0789
K3153 L156_187 L51_55 0.0347
K3154 L156_187 L58_62 0.0271
K3155 L156_187 L67_71 0.0277
K3156 L156_187 L36_41 0.052
K3157 L156_187 L48_52 0.0445
K3158 L156_187 L29_34 0.086
K3159 L156_187 L206_210 0.0324
K3160 L156_187 L41_74 0.0378
K3161 L156_187 L131_170 0.053
K3162 L156_187 L28_33 0.093
K3163 L156_187 L205_209 0.0288
K3164 L156_187 L191_195 0.022
K3165 L156_187 L178_182 0.0696
K3166 L156_187 L180_184 0.1439
K3167 L156_187 L3_8 0.1015
K3168 L156_187 L157_162 0.1879
K3169 L156_187 L149_154 0.0247
K3170 L156_187 L203_207 0.0203
K3171 L156_187 L66_70 0.022
K3172 L156_187 L117_122 0.0351
K3173 L156_187 L114_119 0.0654
K3174 L156_187 L158_189 0.1354
K3175 L156_187 L38_43 0.0459
K3176 L156_187 L47_51 0.0344
K3177 L156_187 L55_59 0.0349
K3178 L156_187 L135_174 0.0412
K3179 L156_187 L160_165 0.156
K3180 L156_187 L52_56 0.0451
K3181 L156_187 L115_120 0.1129
K3182 L156_187 L80_85 0.0203
K3183 L156_187 L10_15 0.073
K3184 L156_187 L16_21 0.1161
K3185 L156_187 L158_163 0.1437
K3186 L156_187 L185_189 0.1284
K3187 L156_187 L96_100 0.0262
K3188 L156_187 L49_53 0.0624
K3189 L156_187 L186_190 0.0861
K3190 L156_187 L82_87 0.0287
K3191 L156_187 L125_130 0.1262
K3192 L156_187 L108_113 0.0448
K3193 L156_187 L159_164 0.1117
K3194 L156_187 L84_89 0.0313
K3195 L156_187 L68_72 0.0322
K3196 L156_187 L169_174 0.0544
K3197 L156_187 L204_208 0.0255
K3198 L156_187 L25_30 0.1037
K3199 L156_187 L133_172 0.0465
K3200 L156_187 L14_19 0.1127
K3201 L156_187 L44_92 0.03
K3202 L156_187 L21_26 0.2105
K3203 L156_187 L95_99 0.0265
K3204 L156_187 L116_121 0.0271
K3205 L156_187 L74_79 0.0353
K3206 L156_187 L165_170 0.0794
K3207 L156_187 L199_203 0.0209
K3208 L156_187 L75_80 0.0208
K3209 L156_187 L143_148 0.0266
K3210 L156_187 L70_75 0.0214
K3211 L156_187 L50_54 0.0269
K3212 L156_187 L79_84 0.0332
K3213 L156_187 L56_60 0.0455
K3214 L156_187 L159_190 0.0891
K3215 L156_187 L93_97 0.0229
K3216 L156_187 L134_173 0.0455
K3217 L156_187 L139_144 0.0281
K3218 L156_187 L83_88 0.0322
K3219 L156_187 L177_181 0.0953
K3220 L156_187 L111_116 0.027
K3221 L156_187 L162_167 0.098
K3222 L156_187 L43_91 0.0304
K3223 L156_187 L122_127 0.0351
K3224 L156_187 L135_140 0.0247
K3225 L156_187 L39_44 0.045
K3226 L156_187 L123_128 0.0461
K3227 L156_187 L54_58 0.027
K3228 L156_187 L146_151 0.0314
K3229 L156_187 L61_65 0.0659
K3230 L156_187 L11_16 0.1131
K3231 L156_187 L77_82 0.0298
K3232 L146_206 L167_168 0.0539
K3233 L146_206 L74_90 0.0885
K3234 L146_206 L199_200 0.066
K3235 L146_206 L115_179 0.0285
K3236 L146_206 L128_129 0.0451
K3237 L146_206 L196_197 0.0952
K3238 L146_206 L73_74 0.2117
K3239 L146_206 L1_2 0.0232
K3240 L146_206 L23_24 0.0376
K3241 L146_206 L158_159 0.0369
K3242 L146_206 L136_198 0.2392
K3243 L146_206 L163_164 0.0442
K3244 L146_206 L144_145 0.0656
K3245 L146_206 L120_183 0.0299
K3246 L146_206 L91_92 0.0693
K3247 L146_206 L160_161 0.0477
K3248 L146_206 L151_152 0.1637
K3249 L146_206 L126_127 0.0372
K3250 L146_206 L22_23 0.0384
K3251 L146_206 L138_139 0.071
K3252 L146_206 L153_154 0.1016
K3253 L146_206 L4_5 0.0221
K3254 L146_206 L34_35 0.0516
K3255 L146_206 L41_42 0.0865
K3256 L146_206 L197_198 0.1646
K3257 L146_206 L192_193 0.0877
K3258 L146_206 L88_89 0.2623
K3259 L146_206 L31_32 0.0573
K3260 L146_206 L143_144 0.0741
K3261 L146_206 L200_201 0.0993
K3262 L146_206 L36_37 0.0715
K3263 L146_206 L131_132 0.0886
K3264 L146_206 L122_123 0.0419
K3265 L146_206 L92_93 0.0623
K3266 L146_206 L13_14 0.0288
K3267 L146_206 L131_194 0.2072
K3268 L146_206 L19_20 0.0295
K3269 L146_206 L187_188 0.0309
K3270 L146_206 L102_103 0.1136
K3271 L146_206 L106_107 0.0324
K3272 L146_206 L60_61 0.0448
K3273 L146_206 L64_65 0.0449
K3274 L146_206 L133_134 0.0742
K3275 L146_206 L8_9 0.0275
K3276 L146_206 L107_108 0.0352
K3277 L146_206 L170_171 0.0725
K3278 L146_206 L193_194 0.1475
K3279 L146_206 L63_64 0.0414
K3280 L146_206 L21_65 0.0462
K3281 L146_206 L121_122 0.0379
K3282 L146_206 L119_120 0.0437
K3283 L146_206 L9_10 0.027
K3284 L146_206 L46_47 0.0323
K3285 L146_206 L195_196 0.0648
K3286 L146_206 L67_68 0.0858
K3287 L146_206 L33_34 0.0536
K3288 L146_206 L134_135 0.0681
K3289 L146_206 L41_69 0.1866
K3290 L146_206 L171_172 0.0689
K3291 L146_206 L104_105 0.08
K3292 L146_206 L151_210 0.3407
K3293 L146_206 L79_94 0.095
K3294 L146_206 L37_38 0.0681
K3295 L146_206 L75_76 0.0653
K3296 L146_206 L112_113 0.0382
K3297 L146_206 L183_184 0.0294
K3298 L146_206 L59_60 0.0418
K3299 L146_206 L11_57 0.0435
K3300 L146_206 L38_39 0.0646
K3301 L146_206 L108_109 0.0373
K3302 L146_206 L71_72 0.0931
K3303 L146_206 L27_28 0.0464
K3304 L146_206 L96_97 0.0643
K3305 L146_206 L78_79 0.2659
K3306 L146_206 L44_45 0.0671
K3307 L146_206 L47_48 0.0351
K3308 L146_206 L29_30 0.044
K3309 L146_206 L76_77 0.0969
K3310 L146_206 L166_167 0.0559
K3311 L146_206 L185_186 0.0283
K3312 L146_206 L177_178 0.0222
K3313 L146_206 L16_17 0.0314
K3314 L146_206 L188_189 0.0303
K3315 L146_206 L86_87 0.0911
K3316 L146_206 L118_119 0.0427
K3317 L146_206 L176_177 0.0226
K3318 L146_206 L3_4 0.0225
K3319 L146_206 L6_53 0.0412
K3320 L146_206 L2_3 0.0229
K3321 L146_206 L55_56 0.0399
K3322 L146_206 L113_114 0.0405
K3323 L146_206 L48_49 0.0372
K3324 L146_206 L110_175 0.0233
K3325 L146_206 L124_125 0.0462
K3326 L146_206 L114_115 0.0414
K3327 L146_206 L52_53 0.0404
K3328 L146_206 L17_18 0.0308
K3329 L146_206 L141_202 0.3334
K3330 L146_206 L87_88 0.1674
K3331 L146_206 L209_210 0.1877
K3332 L146_206 L94_95 0.0822
K3333 L146_206 L136_137 0.0921
K3334 L146_206 L127_128 0.0416
K3335 L146_206 L42_43 0.0794
K3336 L146_206 L181_182 0.0271
K3337 L146_206 L28_29 0.0452
K3338 L146_206 L157_158 0.0377
K3339 L146_206 L95_96 0.0723
K3340 L146_206 L66_67 0.0595
K3341 L146_206 L129_130 0.0465
K3342 L146_206 L21_22 0.0391
K3343 L146_206 L117_118 0.04
K3344 L146_206 L51_52 0.0381
K3345 L146_206 L56_57 0.0425
K3346 L146_206 L24_25 0.0367
K3347 L146_206 L116_117 0.0365
K3348 L146_206 L6_7 0.0284
K3349 L146_206 L173_174 0.0618
K3350 L146_206 L32_33 0.0555
K3351 L146_206 L103_104 0.0945
K3352 L146_206 L85_86 0.0611
K3353 L146_206 L7_8 0.028
K3354 L146_206 L154_155 0.0839
K3355 L146_206 L14_15 0.0282
K3356 L146_206 L184_185 0.0289
K3357 L146_206 L141_142 0.0996
K3358 L146_206 L62_63 0.037
K3359 L146_206 L125_187 0.0315
K3360 L146_206 L58_59 0.0378
K3361 L146_206 L70_71 0.0642
K3362 L146_206 L68_69 0.1387
K3363 L146_206 L180_181 0.0276
K3364 L146_206 L89_102 0.1369
K3365 L146_206 L26_27 0.0475
K3366 L146_206 L50_51 0.035
K3367 L146_206 L168_169 0.0519
K3368 L146_206 L165_166 0.0578
K3369 L146_206 L90_91 0.078
K3370 L146_206 L139_140 0.0634
K3371 L146_206 L161_162 0.0467
K3372 L146_206 L111_112 0.0351
K3373 L146_206 L162_163 0.0455
K3374 L146_206 L137_138 0.0803
K3375 L146_206 L179_180 0.028
K3376 L146_206 L12_13 0.0293
K3377 L146_206 L207_208 0.0618
K3378 L146_206 L142_143 0.0851
K3379 L146_206 L123_124 0.045
K3380 L146_206 L152_153 0.1273
K3381 L146_206 L191_192 0.0601
K3382 L146_206 L39_40 0.0612
K3383 L146_206 L18_19 0.0302
K3384 L146_206 L130_156 0.0393
K3385 L146_206 L156_157 0.0386
K3386 L146_206 L189_190 0.0296
K3387 L146_206 L11_12 0.0298
K3388 L146_206 L54_55 0.0364
K3389 L146_206 L201_202 0.1933
K3390 L192_196 L181_185 0.0246
K3391 L192_196 L140_145 0.025
K3392 L192_196 L1_6 0.0347
K3393 L192_196 L13_18 0.026
K3394 L192_196 L35_40 0.0335
K3395 L192_196 L23_28 0.0343
K3396 L192_196 L73_78 0.0734
K3397 L192_196 L6_11 0.0358
K3398 L192_196 L163_168 0.0356
K3399 L192_196 L91_95 0.0329
K3400 L192_196 L144_149 0.0312
K3401 L192_196 L130_160 0.0339
K3402 L192_196 L4_9 0.0239
K3403 L192_196 L26_31 0.0368
K3404 L192_196 L202_206 0.0733
K3405 L192_196 L109_114 0.0439
K3406 L192_196 L57_61 0.0474
K3407 L192_196 L164_169 0.0318
K3408 L192_196 L195_199 0.1506
K3409 L192_196 L31_36 0.0397
K3410 L192_196 L106_111 0.043
K3411 L192_196 L34_39 0.0376
K3412 L192_196 L148_153 0.0327
K3413 L192_196 L201_205 0.1103
K3414 L192_196 L9_14 0.0245
K3415 L192_196 L53_57 0.0455
K3416 L192_196 L69_73 0.0736
K3417 L192_196 L205_209 0.1057
K3418 L192_196 L150_155 0.0247
K3419 L192_196 L145_150 0.0249
K3420 L192_196 L118_123 0.0543
K3421 L192_196 L30_35 0.0317
K3422 L192_196 L194_198 0.0744
K3423 L192_196 L131_136 0.0507
K3424 L192_196 L101_105 0.0246
K3425 L192_196 L46_50 0.0427
K3426 L192_196 L92_96 0.0312
K3427 L192_196 L19_24 0.0258
K3428 L192_196 L120_125 0.0371
K3429 L192_196 L8_13 0.0253
K3430 L192_196 L157_188 0.0268
K3431 L192_196 L133_138 0.0331
K3432 L192_196 L60_64 0.057
K3433 L192_196 L72_77 0.1104
K3434 L192_196 L198_202 0.0741
K3435 L192_196 L193_197 0.1145
K3436 L192_196 L168_173 0.0377
K3437 L192_196 L7_12 0.0262
K3438 L192_196 L137_142 0.0351
K3439 L192_196 L20_25 0.0208
K3440 L192_196 L167_172 0.0395
K3441 L192_196 L121_126 0.0517
K3442 L192_196 L119_124 0.0476
K3443 L192_196 L97_101 0.0248
K3444 L192_196 L110_115 0.0348
K3445 L192_196 L141_146 0.0503
K3446 L192_196 L182_186 0.0199
K3447 L192_196 L100_104 0.0309
K3448 L192_196 L166_171 0.0416
K3449 L192_196 L24_29 0.0331
K3450 L192_196 L138_143 0.0331
K3451 L192_196 L33_38 0.0394
K3452 L192_196 L18_23 0.0267
K3453 L192_196 L132_171 0.0438
K3454 L192_196 L124_129 0.0496
K3455 L192_196 L78_83 0.0726
K3456 L192_196 L134_139 0.0314
K3457 L192_196 L40_45 0.0349
K3458 L192_196 L183_187 0.027
K3459 L192_196 L136_141 0.0506
K3460 L192_196 L5_10 0.0193
K3461 L192_196 L15_20 0.0203
K3462 L192_196 L58_62 0.0513
K3463 L192_196 L36_41 0.042
K3464 L192_196 L48_52 0.0487
K3465 L192_196 L29_34 0.0354
K3466 L192_196 L179_183 0.0262
K3467 L192_196 L158_189 0.0258
K3468 L192_196 L206_210 0.072
K3469 L192_196 L41_74 0.0504
K3470 L192_196 L131_170 0.0422
K3471 L192_196 L28_33 0.0369
K3472 L192_196 L191_195 0.1548
K3473 L192_196 L66_70 0.1437
K3474 L192_196 L98_102 0.0344
K3475 L192_196 L27_32 0.0386
K3476 L192_196 L147_152 0.0346
K3477 L192_196 L178_182 0.0194
K3478 L192_196 L180_184 0.0254
K3479 L192_196 L3_8 0.0246
K3480 L192_196 L157_162 0.0344
K3481 L192_196 L149_154 0.031
K3482 L192_196 L203_207 0.1273
K3483 L192_196 L2_7 0.0254
K3484 L192_196 L22_27 0.0355
K3485 L192_196 L17_22 0.0277
K3486 L192_196 L38_43 0.0413
K3487 L192_196 L113_118 0.0515
K3488 L192_196 L108_113 0.0489
K3489 L192_196 L135_174 0.035
K3490 L192_196 L94_98 0.0347
K3491 L192_196 L160_165 0.0369
K3492 L192_196 L52_56 0.0513
K3493 L192_196 L115_120 0.0359
K3494 L192_196 L80_85 0.1215
K3495 L192_196 L10_15 0.0198
K3496 L192_196 L16_21 0.0383
K3497 L192_196 L158_163 0.0331
K3498 L192_196 L185_189 0.0252
K3499 L192_196 L96_100 0.0311
K3500 L192_196 L49_53 0.0437
K3501 L192_196 L186_190 0.0204
K3502 L192_196 L156_161 0.0357
K3503 L192_196 L82_87 0.1034
K3504 L192_196 L125_130 0.0384
K3505 L192_196 L184_188 0.0261
K3506 L192_196 L159_164 0.0298
K3507 L192_196 L84_89 0.0495
K3508 L192_196 L68_72 0.1114
K3509 L192_196 L169_174 0.0336
K3510 L192_196 L37_42 0.0436
K3511 L192_196 L25_30 0.0297
K3512 L192_196 L32_37 0.0414
K3513 L192_196 L133_172 0.0414
K3514 L192_196 L14_19 0.0251
K3515 L192_196 L44_92 0.0313
K3516 L192_196 L161_166 0.0387
K3517 L192_196 L21_26 0.0337
K3518 L192_196 L95_99 0.0328
K3519 L192_196 L116_121 0.0484
K3520 L192_196 L74_79 0.0503
K3521 L192_196 L165_170 0.0399
K3522 L192_196 L199_203 0.1402
K3523 L192_196 L75_80 0.1322
K3524 L192_196 L143_148 0.0329
K3525 L192_196 L70_75 0.1405
K3526 L192_196 L50_54 0.0453
K3527 L192_196 L79_84 0.05
K3528 L192_196 L56_60 0.054
K3529 L192_196 L159_190 0.0208
K3530 L192_196 L93_97 0.0249
K3531 L192_196 L90_94 0.0349
K3532 L192_196 L134_173 0.0393
K3533 L192_196 L139_144 0.0313
K3534 L192_196 L83_88 0.0713
K3535 L192_196 L177_181 0.0239
K3536 L192_196 L111_116 0.0455
K3537 L192_196 L162_167 0.0371
K3538 L192_196 L43_91 0.033
K3539 L192_196 L142_147 0.0349
K3540 L192_196 L135_140 0.025
K3541 L192_196 L39_44 0.0392
K3542 L192_196 L123_128 0.0574
K3543 L192_196 L12_17 0.0269
K3544 L192_196 L54_58 0.0481
K3545 L192_196 L146_151 0.0498
K3546 L192_196 L114_119 0.0457
K3547 L192_196 L61_65 0.0494
K3548 L192_196 L11_16 0.037
K3549 L192_196 L77_82 0.1076
K3550 L26_31 L181_185 0.0777
K3551 L26_31 L140_145 0.0398
K3552 L26_31 L13_18 0.1065
K3553 L26_31 L35_40 0.1129
K3554 L26_31 L23_28 0.17
K3555 L26_31 L73_78 0.0513
K3556 L26_31 L184_188 0.0992
K3557 L26_31 L163_168 0.1599
K3558 L26_31 L91_95 0.0518
K3559 L26_31 L144_149 0.045
K3560 L26_31 L4_9 0.0707
K3561 L26_31 L202_206 0.0481
K3562 L26_31 L109_114 0.0608
K3563 L26_31 L57_61 0.0694
K3564 L26_31 L164_169 0.1257
K3565 L26_31 L195_199 0.0282
K3566 L26_31 L158_189 0.1012
K3567 L26_31 L106_111 0.0303
K3568 L26_31 L34_39 0.1398
K3569 L26_31 L148_153 0.0422
K3570 L26_31 L201_205 0.0409
K3571 L26_31 L53_57 0.0654
K3572 L26_31 L69_73 0.0544
K3573 L26_31 L200_204 0.0348
K3574 L26_31 L150_155 0.0336
K3575 L26_31 L145_150 0.0364
K3576 L26_31 L118_123 0.0514
K3577 L26_31 L30_35 0.1357
K3578 L26_31 L194_198 0.054
K3579 L26_31 L101_105 0.0339
K3580 L26_31 L46_50 0.0304
K3581 L26_31 L196_200 0.0358
K3582 L26_31 L92_96 0.0502
K3583 L26_31 L81_86 0.0339
K3584 L26_31 L19_24 0.1087
K3585 L26_31 L8_13 0.0887
K3586 L26_31 L157_188 0.1175
K3587 L26_31 L133_138 0.0568
K3588 L26_31 L60_64 0.0534
K3589 L26_31 L72_77 0.0428
K3590 L26_31 L198_202 0.0509
K3591 L26_31 L193_197 0.0443
K3592 L26_31 L168_173 0.1298
K3593 L26_31 L7_12 0.0951
K3594 L26_31 L137_142 0.052
K3595 L26_31 L20_25 0.0791
K3596 L26_31 L167_172 0.1517
K3597 L26_31 L121_126 0.0321
K3598 L26_31 L119_124 0.0685
K3599 L26_31 L97_101 0.0369
K3600 L26_31 L113_118 0.0497
K3601 L26_31 L134_139 0.0546
K3602 L26_31 L182_186 0.0601
K3603 L26_31 L100_104 0.0418
K3604 L26_31 L166_171 0.1747
K3605 L26_31 L24_29 0.1398
K3606 L26_31 L138_143 0.051
K3607 L26_31 L33_38 0.17
K3608 L26_31 L18_23 0.1305
K3609 L26_31 L132_171 0.0992
K3610 L26_31 L124_129 0.0724
K3611 L26_31 L107_112 0.0388
K3612 L26_31 L78_83 0.0484
K3613 L26_31 L112_117 0.0397
K3614 L26_31 L40_45 0.0795
K3615 L26_31 L183_187 0.1083
K3616 L26_31 L59_63 0.0415
K3617 L26_31 L5_10 0.0552
K3618 L26_31 L71_76 0.0359
K3619 L26_31 L15_20 0.0703
K3620 L26_31 L51_55 0.0399
K3621 L26_31 L58_62 0.0322
K3622 L26_31 L67_71 0.0369
K3623 L26_31 L48_52 0.0482
K3624 L26_31 L29_34 0.1786
K3625 L26_31 L179_183 0.0898
K3626 L26_31 L206_210 0.0455
K3627 L26_31 L28_33 0.2473
K3628 L26_31 L205_209 0.0393
K3629 L26_31 L191_195 0.0289
K3630 L26_31 L66_70 0.029
K3631 L26_31 L98_102 0.0433
K3632 L26_31 L27_32 0.3972
K3633 L26_31 L142_147 0.047
K3634 L26_31 L147_152 0.0428
K3635 L26_31 L178_182 0.0537
K3636 L26_31 L180_184 0.0844
K3637 L26_31 L3_8 0.0756
K3638 L26_31 L157_162 0.1517
K3639 L26_31 L149_154 0.0413
K3640 L26_31 L203_207 0.0267
K3641 L26_31 L2_7 0.0794
K3642 L26_31 L117_122 0.0405
K3643 L26_31 L22_27 0.2112
K3644 L26_31 L17_22 0.156
K3645 L26_31 L38_43 0.0983
K3646 L26_31 L47_51 0.0389
K3647 L26_31 L108_113 0.0479
K3648 L26_31 L135_174 0.0772
K3649 L26_31 L94_98 0.0477
K3650 L26_31 L52_56 0.0501
K3651 L26_31 L80_85 0.0268
K3652 L26_31 L10_15 0.0622
K3653 L26_31 L158_163 0.1298
K3654 L26_31 L185_189 0.0887
K3655 L26_31 L96_100 0.0456
K3656 L26_31 L49_53 0.0615
K3657 L26_31 L186_190 0.0672
K3658 L26_31 L156_161 0.1747
K3659 L26_31 L82_87 0.0395
K3660 L26_31 L55_59 0.0407
K3661 L26_31 L159_164 0.1068
K3662 L26_31 L9_14 0.081
K3663 L26_31 L68_72 0.0446
K3664 L26_31 L169_174 0.1068
K3665 L26_31 L204_208 0.0337
K3666 L26_31 L37_42 0.1037
K3667 L26_31 L25_30 0.1129
K3668 L26_31 L32_37 0.2112
K3669 L26_31 L133_172 0.0946
K3670 L26_31 L14_19 0.0937
K3671 L26_31 L44_92 0.0557
K3672 L26_31 L161_166 0.2588
K3673 L26_31 L95_99 0.0468
K3674 L26_31 L116_121 0.0316
K3675 L26_31 L199_203 0.0275
K3676 L26_31 L75_80 0.0276
K3677 L26_31 L143_148 0.0462
K3678 L26_31 L70_75 0.0283
K3679 L26_31 L50_54 0.0311
K3680 L26_31 L56_60 0.0518
K3681 L26_31 L159_190 0.0748
K3682 L26_31 L93_97 0.0404
K3683 L26_31 L90_94 0.053
K3684 L26_31 L134_173 0.0885
K3685 L26_31 L139_144 0.0494
K3686 L26_31 L83_88 0.0458
K3687 L26_31 L177_181 0.0685
K3688 L26_31 L111_116 0.031
K3689 L26_31 L162_167 0.2027
K3690 L26_31 L43_91 0.058
K3691 L26_31 L122_127 0.0413
K3692 L26_31 L135_140 0.0437
K3693 L26_31 L39_44 0.0915
K3694 L26_31 L123_128 0.053
K3695 L26_31 L54_58 0.0317
K3696 L26_31 L114_119 0.0646
K3697 L26_31 L61_65 0.0735
K3698 L26_31 L12_17 0.1185
K3699 L26_31 L77_82 0.0411
K3700 L192_193 L167_168 0.0394
K3701 L192_193 L74_90 0.0496
K3702 L192_193 L199_200 0.1727
K3703 L192_193 L115_179 0.0249
K3704 L192_193 L128_129 0.0502
K3705 L192_193 L196_197 0.4331
K3706 L192_193 L73_74 0.0923
K3707 L192_193 L1_2 0.0204
K3708 L192_193 L23_24 0.0307
K3709 L192_193 L158_159 0.0297
K3710 L192_193 L136_198 0.0947
K3711 L192_193 L163_164 0.0346
K3712 L192_193 L144_145 0.0387
K3713 L192_193 L120_183 0.0258
K3714 L192_193 L91_92 0.0418
K3715 L192_193 L160_161 0.039
K3716 L192_193 L151_152 0.0391
K3717 L192_193 L126_127 0.0502
K3718 L192_193 L22_23 0.0318
K3719 L192_193 L153_154 0.0334
K3720 L192_193 L4_5 0.0186
K3721 L192_193 L34_35 0.0375
K3722 L192_193 L197_198 0.2045
K3723 L192_193 L204_205 0.2072
K3724 L192_193 L88_89 0.077
K3725 L192_193 L31_32 0.0433
K3726 L192_193 L143_144 0.0417
K3727 L192_193 L200_201 0.2809
K3728 L192_193 L205_206 0.1475
K3729 L192_193 L36_37 0.0476
K3730 L192_193 L141_142 0.0495
K3731 L192_193 L100_101 0.0378
K3732 L192_193 L203_204 0.1475
K3733 L192_193 L92_93 0.0387
K3734 L192_193 L81_82 0.1866
K3735 L192_193 L13_14 0.0241
K3736 L192_193 L185_186 0.0234
K3737 L192_193 L148_149 0.041
K3738 L192_193 L19_20 0.0241
K3739 L192_193 L187_188 0.0259
K3740 L192_193 L165_166 0.0435
K3741 L192_193 L102_103 0.0357
K3742 L192_193 L106_107 0.0403
K3743 L192_193 L60_61 0.0492
K3744 L192_193 L64_65 0.0498
K3745 L192_193 L8_9 0.0234
K3746 L192_193 L107_108 0.0414
K3747 L192_193 L170_171 0.0479
K3748 L192_193 L63_64 0.052
K3749 L192_193 L21_65 0.0446
K3750 L192_193 L121_122 0.0495
K3751 L192_193 L119_120 0.0427
K3752 L192_193 L9_10 0.0227
K3753 L192_193 L46_47 0.0401
K3754 L192_193 L195_196 0.2045
K3755 L192_193 L33_34 0.0393
K3756 L192_193 L171_172 0.0451
K3757 L192_193 L104_105 0.0309
K3758 L192_193 L151_210 0.0785
K3759 L192_193 L79_94 0.0489
K3760 L192_193 L37_38 0.0449
K3761 L192_193 L75_76 0.1576
K3762 L192_193 L112_113 0.0451
K3763 L192_193 L183_184 0.025
K3764 L192_193 L59_60 0.051
K3765 L192_193 L11_57 0.0425
K3766 L192_193 L38_39 0.0424
K3767 L192_193 L108_109 0.0403
K3768 L192_193 L71_72 0.2931
K3769 L192_193 L27_28 0.0373
K3770 L192_193 L96_97 0.0384
K3771 L192_193 L78_79 0.0896
K3772 L192_193 L138_139 0.0422
K3773 L192_193 L47_48 0.0412
K3774 L192_193 L29_30 0.0345
K3775 L192_193 L76_77 0.2334
K3776 L192_193 L114_115 0.0406
K3777 L192_193 L166_167 0.0414
K3778 L192_193 L177_178 0.0187
K3779 L192_193 L16_17 0.0267
K3780 L192_193 L188_189 0.025
K3781 L192_193 L86_87 0.1492
K3782 L192_193 L118_119 0.0465
K3783 L192_193 L176_177 0.0192
K3784 L192_193 L3_4 0.0192
K3785 L192_193 L6_53 0.0404
K3786 L192_193 L149_150 0.0381
K3787 L192_193 L2_3 0.0198
K3788 L192_193 L98_99 0.0439
K3789 L192_193 L55_56 0.0477
K3790 L192_193 L184_185 0.0242
K3791 L192_193 L84_98 0.0477
K3792 L192_193 L48_49 0.0401
K3793 L192_193 L110_175 0.0204
K3794 L192_193 L124_125 0.045
K3795 L192_193 L113_114 0.0438
K3796 L192_193 L52_53 0.0436
K3797 L192_193 L80_81 0.1387
K3798 L192_193 L17_18 0.0258
K3799 L192_193 L141_202 0.0917
K3800 L192_193 L87_88 0.1173
K3801 L192_193 L146_147 0.0483
K3802 L192_193 L209_210 0.123
K3803 L192_193 L94_95 0.0448
K3804 L192_193 L127_128 0.0524
K3805 L192_193 L181_182 0.0227
K3806 L192_193 L28_29 0.0359
K3807 L192_193 L157_158 0.0308
K3808 L192_193 L122_123 0.0513
K3809 L192_193 L103_104 0.0331
K3810 L192_193 L129_130 0.0449
K3811 L192_193 L21_22 0.033
K3812 L192_193 L117_118 0.048
K3813 L192_193 L51_52 0.0448
K3814 L192_193 L56_57 0.0462
K3815 L192_193 L24_25 0.0296
K3816 L192_193 L116_117 0.0465
K3817 L192_193 L6_7 0.0248
K3818 L192_193 L173_174 0.0404
K3819 L192_193 L154_155 0.0311
K3820 L192_193 L32_33 0.0412
K3821 L192_193 L95_96 0.0413
K3822 L192_193 L85_86 0.1173
K3823 L192_193 L7_8 0.0241
K3824 L192_193 L82_83 0.1387
K3825 L192_193 L14_15 0.0233
K3826 L192_193 L147_148 0.0444
K3827 L192_193 L62_63 0.0498
K3828 L192_193 L125_187 0.0268
K3829 L192_193 L58_59 0.0492
K3830 L192_193 L70_71 0.1765
K3831 L192_193 L136_137 0.0503
K3832 L192_193 L180_181 0.0234
K3833 L192_193 L89_102 0.0387
K3834 L192_193 L26_27 0.0389
K3835 L192_193 L50_51 0.0436
K3836 L192_193 L168_169 0.0376
K3837 L192_193 L83_84 0.0858
K3838 L192_193 L90_91 0.0454
K3839 L192_193 L139_140 0.0391
K3840 L192_193 L161_162 0.0375
K3841 L192_193 L111_112 0.0438
K3842 L192_193 L162_163 0.036
K3843 L192_193 L137_138 0.0459
K3844 L192_193 L179_180 0.0241
K3845 L192_193 L12_13 0.0249
K3846 L192_193 L207_208 0.123
K3847 L192_193 L142_143 0.0453
K3848 L192_193 L123_124 0.0495
K3849 L192_193 L152_153 0.036
K3850 L192_193 L39_40 0.0402
K3851 L192_193 L18_19 0.0249
K3852 L192_193 L130_156 0.0331
K3853 L192_193 L156_157 0.032
K3854 L192_193 L189_190 0.0241
K3855 L192_193 L11_12 0.0257
K3856 L192_193 L54_55 0.0462
K3857 L192_193 L201_202 0.1727
K3858 L31_36 L181_185 0.0546
K3859 L31_36 L140_145 0.0537
K3860 L31_36 L13_18 0.0657
K3861 L31_36 L35_40 0.1357
K3862 L31_36 L23_28 0.0983
K3863 L31_36 L73_78 0.0615
K3864 L31_36 L184_188 0.0639
K3865 L31_36 L163_168 0.1298
K3866 L31_36 L91_95 0.0756
K3867 L31_36 L144_149 0.0609
K3868 L31_36 L4_9 0.0502
K3869 L31_36 L202_206 0.0573
K3870 L31_36 L109_114 0.0509
K3871 L31_36 L57_61 0.0578
K3872 L31_36 L164_169 0.1068
K3873 L31_36 L195_199 0.0303
K3874 L31_36 L158_189 0.0685
K3875 L31_36 L106_111 0.0282
K3876 L31_36 L34_39 0.1786
K3877 L31_36 L148_153 0.0568
K3878 L31_36 L201_205 0.0461
K3879 L31_36 L53_57 0.0544
K3880 L31_36 L69_73 0.0654
K3881 L31_36 L200_204 0.0378
K3882 L31_36 L150_155 0.0437
K3883 L31_36 L145_150 0.0483
K3884 L31_36 L118_123 0.0461
K3885 L31_36 L30_35 0.1129
K3886 L31_36 L194_198 0.0646
K3887 L31_36 L101_105 0.0445
K3888 L31_36 L46_50 0.0283
K3889 L31_36 L196_200 0.0388
K3890 L31_36 L92_96 0.0707
K3891 L31_36 L81_86 0.0369
K3892 L31_36 L19_24 0.0707
K3893 L31_36 L8_13 0.058
K3894 L31_36 L157_188 0.0729
K3895 L31_36 L133_138 0.0844
K3896 L31_36 L60_64 0.0482
K3897 L31_36 L72_77 0.0482
K3898 L31_36 L198_202 0.0608
K3899 L31_36 L193_197 0.0497
K3900 L31_36 L168_173 0.1599
K3901 L31_36 L7_12 0.0596
K3902 L31_36 L137_142 0.0763
K3903 L31_36 L20_25 0.0552
K3904 L31_36 L167_172 0.2027
K3905 L31_36 L121_126 0.0303
K3906 L31_36 L119_124 0.0573
K3907 L31_36 L97_101 0.0494
K3908 L31_36 L113_118 0.0443
K3909 L31_36 L134_139 0.0777
K3910 L31_36 L182_186 0.0437
K3911 L31_36 L100_104 0.0557
K3912 L31_36 L166_171 0.2588
K3913 L31_36 L24_29 0.0915
K3914 L31_36 L138_143 0.0729
K3915 L31_36 L33_38 0.2473
K3916 L31_36 L18_23 0.0756
K3917 L31_36 L132_171 0.1747
K3918 L31_36 L124_129 0.0608
K3919 L31_36 L107_112 0.0358
K3920 L31_36 L78_83 0.0578
K3921 L31_36 L112_117 0.0368
K3922 L31_36 L40_45 0.1129
K3923 L31_36 L183_187 0.0661
K3924 L31_36 L59_63 0.0389
K3925 L31_36 L5_10 0.0404
K3926 L31_36 L71_76 0.0389
K3927 L31_36 L15_20 0.0494
K3928 L31_36 L51_55 0.0369
K3929 L31_36 L58_62 0.0304
K3930 L31_36 L67_71 0.0399
K3931 L31_36 L48_52 0.0428
K3932 L31_36 L29_34 0.1398
K3933 L31_36 L179_183 0.0583
K3934 L31_36 L206_210 0.054
K3935 L31_36 L28_33 0.17
K3936 L31_36 L205_209 0.0443
K3937 L31_36 L191_195 0.031
K3938 L31_36 L66_70 0.0311
K3939 L31_36 L98_102 0.0596
K3940 L31_36 L27_32 0.2112
K3941 L31_36 L142_147 0.0661
K3942 L31_36 L147_152 0.0583
K3943 L31_36 L178_182 0.0398
K3944 L31_36 L180_184 0.0568
K3945 L31_36 L3_8 0.0518
K3946 L31_36 L157_162 0.0946
K3947 L31_36 L149_154 0.0546
K3948 L31_36 L203_207 0.0289
K3949 L31_36 L2_7 0.053
K3950 L31_36 L117_122 0.0378
K3951 L31_36 L22_27 0.1037
K3952 L31_36 L17_22 0.0794
K3953 L31_36 L38_43 0.17
K3954 L31_36 L47_51 0.0359
K3955 L31_36 L108_113 0.0426
K3956 L31_36 L135_174 0.1068
K3957 L31_36 L94_98 0.0681
K3958 L31_36 L52_56 0.0446
K3959 L31_36 L80_85 0.029
K3960 L31_36 L10_15 0.0445
K3961 L31_36 L158_163 0.0885
K3962 L31_36 L185_189 0.0609
K3963 L31_36 L96_100 0.0624
K3964 L31_36 L49_53 0.0513
K3965 L31_36 L186_190 0.0483
K3966 L31_36 L156_161 0.0992
K3967 L31_36 L82_87 0.0446
K3968 L31_36 L55_59 0.038
K3969 L31_36 L159_164 0.0772
K3970 L31_36 L9_14 0.0557
K3971 L31_36 L68_72 0.0501
K3972 L31_36 L169_174 0.1257
K3973 L31_36 L204_208 0.0368
K3974 L31_36 L37_42 0.2112
K3975 L31_36 L25_30 0.0795
K3976 L31_36 L32_37 0.3972
K3977 L31_36 L133_172 0.1517
K3978 L31_36 L14_19 0.0624
K3979 L31_36 L44_92 0.081
K3980 L31_36 L161_166 0.1747
K3981 L31_36 L95_99 0.0657
K3982 L31_36 L116_121 0.0296
K3983 L31_36 L199_203 0.0296
K3984 L31_36 L75_80 0.0298
K3985 L31_36 L143_148 0.0639
K3986 L31_36 L70_75 0.0304
K3987 L31_36 L50_54 0.029
K3988 L31_36 L56_60 0.0464
K3989 L31_36 L159_190 0.0537
K3990 L31_36 L93_97 0.0552
K3991 L31_36 L90_94 0.0794
K3992 L31_36 L134_173 0.1298
K3993 L31_36 L139_144 0.0685
K3994 L31_36 L83_88 0.0544
K3995 L31_36 L177_181 0.0494
K3996 L31_36 L111_116 0.0289
K3997 L31_36 L162_167 0.1517
K3998 L31_36 L43_91 0.0887
K3999 L31_36 L122_127 0.0388
K4000 L31_36 L135_140 0.0601
K4001 L31_36 L39_44 0.1398
K4002 L31_36 L123_128 0.0479
K4003 L31_36 L54_58 0.0298
K4004 L31_36 L114_119 0.054
K4005 L31_36 L61_65 0.0615
K4006 L31_36 L12_17 0.0681
K4007 L31_36 L77_82 0.0464
K4008 L88_89 L167_168 0.0478
K4009 L88_89 L74_90 0.0803
K4010 L88_89 L115_179 0.0255
K4011 L88_89 L147_148 0.0776
K4012 L88_89 L196_197 0.0837
K4013 L88_89 L73_74 0.1829
K4014 L88_89 L1_2 0.021
K4015 L88_89 L23_24 0.0339
K4016 L88_89 L158_159 0.033
K4017 L88_89 L136_198 0.1684
K4018 L88_89 L163_164 0.0395
K4019 L88_89 L144_145 0.0586
K4020 L88_89 L120_183 0.0268
K4021 L88_89 L91_92 0.0636
K4022 L88_89 L160_161 0.0424
K4023 L88_89 L126_127 0.0335
K4024 L88_89 L22_23 0.0346
K4025 L88_89 L204_205 0.0911
K4026 L88_89 L4_5 0.02
K4027 L88_89 L34_35 0.0464
K4028 L88_89 L41_42 0.077
K4029 L88_89 L197_198 0.13
K4030 L88_89 L31_32 0.0512
K4031 L88_89 L143_144 0.0654
K4032 L88_89 L200_201 0.0878
K4033 L88_89 L205_206 0.1674
K4034 L88_89 L36_37 0.0636
K4035 L88_89 L131_132 0.0754
K4036 L88_89 L100_101 0.0616
K4037 L88_89 L203_204 0.0611
K4038 L88_89 L92_93 0.0573
K4039 L88_89 L81_82 0.0934
K4040 L88_89 L13_14 0.026
K4041 L88_89 L131_194 0.1492
K4042 L88_89 L148_149 0.068
K4043 L88_89 L19_20 0.0267
K4044 L88_89 L187_188 0.0277
K4045 L88_89 L165_166 0.0508
K4046 L88_89 L128_129 0.0401
K4047 L88_89 L106_107 0.0293
K4048 L88_89 L60_61 0.0403
K4049 L88_89 L133_134 0.0648
K4050 L88_89 L8_9 0.0249
K4051 L88_89 L107_108 0.0317
K4052 L88_89 L170_171 0.0629
K4053 L88_89 L193_194 0.1173
K4054 L88_89 L63_64 0.0373
K4055 L88_89 L21_65 0.0414
K4056 L88_89 L121_122 0.0342
K4057 L88_89 L119_120 0.039
K4058 L88_89 L9_10 0.0244
K4059 L88_89 L46_47 0.0294
K4060 L88_89 L195_196 0.0588
K4061 L88_89 L67_68 0.0785
K4062 L88_89 L33_34 0.0481
K4063 L88_89 L134_135 0.06
K4064 L88_89 L41_69 0.1605
K4065 L88_89 L171_172 0.0601
K4066 L88_89 L180_181 0.0248
K4067 L88_89 L79_94 0.0877
K4068 L88_89 L37_38 0.0608
K4069 L88_89 L75_76 0.0608
K4070 L88_89 L112_113 0.0344
K4071 L88_89 L183_184 0.0264
K4072 L88_89 L59_60 0.0377
K4073 L88_89 L11_57 0.0391
K4074 L88_89 L38_39 0.0579
K4075 L88_89 L108_109 0.0334
K4076 L88_89 L71_72 0.0854
K4077 L88_89 L27_28 0.0417
K4078 L88_89 L78_79 0.2387
K4079 L88_89 L44_45 0.0608
K4080 L88_89 L47_48 0.0318
K4081 L88_89 L29_30 0.0397
K4082 L88_89 L76_77 0.0898
K4083 L88_89 L114_115 0.037
K4084 L88_89 L166_167 0.0494
K4085 L88_89 L185_186 0.0254
K4086 L88_89 L177_178 0.02
K4087 L88_89 L16_17 0.0282
K4088 L88_89 L188_189 0.0271
K4089 L88_89 L181_182 0.0244
K4090 L88_89 L118_119 0.0381
K4091 L88_89 L176_177 0.0203
K4092 L88_89 L3_4 0.0204
K4093 L88_89 L6_53 0.0371
K4094 L88_89 L149_150 0.0604
K4095 L88_89 L2_3 0.0207
K4096 L88_89 L98_99 0.0803
K4097 L88_89 L55_56 0.036
K4098 L88_89 L84_98 0.0945
K4099 L88_89 L48_49 0.0335
K4100 L88_89 L110_175 0.0209
K4101 L88_89 L124_125 0.0411
K4102 L88_89 L113_114 0.0363
K4103 L88_89 L52_53 0.0364
K4104 L88_89 L80_81 0.0618
K4105 L88_89 L17_18 0.0278
K4106 L88_89 L141_202 0.2081
K4107 L88_89 L62_63 0.0336
K4108 L88_89 L146_147 0.09
K4109 L88_89 L94_95 0.0761
K4110 L88_89 L136_137 0.0776
K4111 L88_89 L127_128 0.0372
K4112 L88_89 L138_139 0.0622
K4113 L88_89 L42_43 0.0712
K4114 L88_89 L28_29 0.0408
K4115 L88_89 L157_158 0.0338
K4116 L88_89 L122_123 0.0376
K4117 L88_89 L96_97 0.0597
K4118 L88_89 L66_67 0.055
K4119 L88_89 L129_130 0.0412
K4120 L88_89 L64_65 0.0403
K4121 L88_89 L117_118 0.0359
K4122 L88_89 L51_52 0.0345
K4123 L88_89 L56_57 0.0383
K4124 L88_89 L24_25 0.0332
K4125 L88_89 L116_117 0.033
K4126 L88_89 L6_7 0.0256
K4127 L88_89 L173_174 0.0546
K4128 L88_89 L32_33 0.0497
K4129 L88_89 L95_96 0.067
K4130 L88_89 L21_22 0.0352
K4131 L88_89 L7_8 0.0253
K4132 L88_89 L82_83 0.1877
K4133 L88_89 L14_15 0.0255
K4134 L88_89 L184_185 0.0259
K4135 L88_89 L141_142 0.0842
K4136 L88_89 L199_200 0.0602
K4137 L88_89 L125_187 0.0281
K4138 L88_89 L58_59 0.0343
K4139 L88_89 L70_71 0.0594
K4140 L88_89 L68_69 0.123
K4141 L88_89 L26_27 0.0426
K4142 L88_89 L50_51 0.0318
K4143 L88_89 L168_169 0.0461
K4144 L88_89 L83_84 0.3407
K4145 L88_89 L90_91 0.0711
K4146 L88_89 L139_140 0.0563
K4147 L88_89 L161_162 0.0415
K4148 L88_89 L111_112 0.0317
K4149 L88_89 L162_163 0.0406
K4150 L88_89 L137_138 0.0693
K4151 L88_89 L179_180 0.0252
K4152 L88_89 L12_13 0.0265
K4153 L88_89 L142_143 0.0738
K4154 L88_89 L123_124 0.0401
K4155 L88_89 L191_192 0.0545
K4156 L88_89 L39_40 0.0551
K4157 L88_89 L18_19 0.0273
K4158 L88_89 L130_156 0.0351
K4159 L88_89 L156_157 0.0344
K4160 L88_89 L189_190 0.0266
K4161 L88_89 L11_12 0.0269
K4162 L88_89 L54_55 0.033
K4163 L88_89 L201_202 0.1479
K4164 L31_32 L74_90 0.0548
K4165 L31_32 L199_200 0.0368
K4166 L31_32 L115_179 0.054
K4167 L31_32 L128_129 0.075
K4168 L31_32 L147_148 0.045
K4169 L31_32 L196_197 0.0452
K4170 L31_32 L73_74 0.0669
K4171 L31_32 L1_2 0.0443
K4172 L31_32 L23_24 0.0864
K4173 L31_32 L158_159 0.081
K4174 L31_32 L136_198 0.0662
K4175 L31_32 L163_164 0.1084
K4176 L31_32 L144_145 0.0475
K4177 L31_32 L120_183 0.0599
K4178 L31_32 L91_92 0.0537
K4179 L31_32 L160_161 0.1221
K4180 L31_32 L151_152 0.0352
K4181 L31_32 L126_127 0.0443
K4182 L31_32 L22_23 0.0888
K4183 L31_32 L204_205 0.0421
K4184 L31_32 L153_154 0.0348
K4185 L31_32 L4_5 0.0424
K4186 L31_32 L41_42 0.0788
K4187 L31_32 L197_198 0.055
K4188 L31_32 L143_144 0.0484
K4189 L31_32 L200_201 0.0436
K4190 L31_32 L205_206 0.0496
K4191 L31_32 L36_37 0.1279
K4192 L31_32 L131_132 0.0772
K4193 L31_32 L100_101 0.0442
K4194 L31_32 L203_204 0.0359
K4195 L31_32 L92_93 0.0524
K4196 L31_32 L81_82 0.0423
K4197 L31_32 L13_14 0.0595
K4198 L31_32 L131_194 0.0654
K4199 L31_32 L148_149 0.0445
K4200 L31_32 L19_20 0.0642
K4201 L31_32 L102_103 0.0354
K4202 L31_32 L106_107 0.0399
K4203 L31_32 L60_61 0.0743
K4204 L31_32 L64_65 0.0763
K4205 L31_32 L133_134 0.0751
K4206 L31_32 L8_9 0.0537
K4207 L31_32 L107_108 0.0482
K4208 L31_32 L170_171 0.1221
K4209 L31_32 L193_194 0.0533
K4210 L31_32 L63_64 0.0572
K4211 L31_32 L21_65 0.099
K4212 L31_32 L121_122 0.0459
K4213 L31_32 L119_120 0.0804
K4214 L31_32 L9_10 0.0524
K4215 L31_32 L46_47 0.0401
K4216 L31_32 L195_196 0.0377
K4217 L31_32 L67_68 0.0435
K4218 L31_32 L187_188 0.0668
K4219 L31_32 L134_135 0.0727
K4220 L31_32 L41_69 0.0662
K4221 L31_32 L171_172 0.1203
K4222 L31_32 L104_105 0.0345
K4223 L31_32 L151_210 0.0508
K4224 L31_32 L79_94 0.0498
K4225 L31_32 L37_38 0.1258
K4226 L31_32 L75_76 0.0369
K4227 L31_32 L112_113 0.0523
K4228 L31_32 L183_184 0.0596
K4229 L31_32 L59_60 0.0579
K4230 L31_32 L11_57 0.0817
K4231 L31_32 L38_39 0.12
K4232 L31_32 L108_109 0.0581
K4233 L31_32 L71_72 0.0455
K4234 L31_32 L27_28 0.1258
K4235 L31_32 L78_79 0.0621
K4236 L31_32 L44_45 0.0741
K4237 L31_32 L47_48 0.0485
K4238 L31_32 L29_30 0.1122
K4239 L31_32 L76_77 0.0438
K4240 L31_32 L114_115 0.073
K4241 L31_32 L185_186 0.0569
K4242 L31_32 L177_178 0.0419
K4243 L31_32 L16_17 0.0688
K4244 L31_32 L188_189 0.0653
K4245 L31_32 L86_87 0.0383
K4246 L31_32 L118_119 0.0681
K4247 L31_32 L176_177 0.0429
K4248 L31_32 L3_4 0.0434
K4249 L31_32 L6_53 0.074
K4250 L31_32 L149_150 0.0438
K4251 L31_32 L2_3 0.0441
K4252 L31_32 L98_99 0.0454
K4253 L31_32 L55_56 0.0553
K4254 L31_32 L84_98 0.0456
K4255 L31_32 L48_49 0.0587
K4256 L31_32 L110_175 0.0437
K4257 L31_32 L124_125 0.0893
K4258 L31_32 L113_114 0.0634
K4259 L31_32 L52_53 0.0641
K4260 L31_32 L80_81 0.036
K4261 L31_32 L17_18 0.0683
K4262 L31_32 L141_202 0.0615
K4263 L31_32 L87_88 0.0447
K4264 L31_32 L146_147 0.0451
K4265 L31_32 L209_210 0.0445
K4266 L31_32 L94_95 0.0496
K4267 L31_32 L136_137 0.054
K4268 L31_32 L127_128 0.0567
K4269 L31_32 L138_139 0.053
K4270 L31_32 L42_43 0.0782
K4271 L31_32 L181_182 0.0518
K4272 L31_32 L28_29 0.12
K4273 L31_32 L157_158 0.0843
K4274 L31_32 L122_123 0.0575
K4275 L31_32 L96_97 0.048
K4276 L31_32 L66_67 0.036
K4277 L31_32 L129_130 0.0963
K4278 L31_32 L21_22 0.0897
K4279 L31_32 L117_118 0.0549
K4280 L31_32 L51_52 0.0527
K4281 L31_32 L56_57 0.0689
K4282 L31_32 L24_25 0.0828
K4283 L31_32 L116_117 0.0445
K4284 L31_32 L6_7 0.0548
K4285 L31_32 L173_174 0.1084
K4286 L31_32 L154_155 0.0343
K4287 L31_32 L95_96 0.049
K4288 L31_32 L85_86 0.0329
K4289 L31_32 L7_8 0.0545
K4290 L31_32 L82_83 0.0499
K4291 L31_32 L14_15 0.0578
K4292 L31_32 L184_185 0.0585
K4293 L31_32 L141_142 0.0492
K4294 L31_32 L62_63 0.0446
K4295 L31_32 L125_187 0.0673
K4296 L31_32 L58_59 0.0461
K4297 L31_32 L103_104 0.0351
K4298 L31_32 L70_71 0.0379
K4299 L31_32 L68_69 0.0537
K4300 L31_32 L180_181 0.053
K4301 L31_32 L89_102 0.0355
K4302 L31_32 L26_27 0.1279
K4303 L31_32 L50_51 0.0434
K4304 L31_32 L83_84 0.0578
K4305 L31_32 L90_91 0.0545
K4306 L31_32 L139_140 0.0518
K4307 L31_32 L161_162 0.1203
K4308 L31_32 L111_112 0.0432
K4309 L31_32 L162_163 0.1153
K4310 L31_32 L137_138 0.0538
K4311 L31_32 L179_180 0.0538
K4312 L31_32 L12_13 0.0606
K4313 L31_32 L207_208 0.0328
K4314 L31_32 L142_143 0.049
K4315 L31_32 L123_124 0.0732
K4316 L31_32 L152_153 0.0351
K4317 L31_32 L191_192 0.0358
K4318 L31_32 L39_40 0.1122
K4319 L31_32 L18_19 0.0667
K4320 L31_32 L130_156 0.0873
K4321 L31_32 L156_157 0.0865
K4322 L31_32 L189_190 0.063
K4323 L31_32 L11_12 0.061
K4324 L31_32 L54_55 0.0448
K4325 L31_32 L201_202 0.0522
K4326 L73_74 L167_168 0.0606
K4327 L73_74 L199_200 0.0653
K4328 L73_74 L115_179 0.0314
K4329 L73_74 L128_129 0.0508
K4330 L73_74 L147_148 0.1165
K4331 L73_74 L95_96 0.1196
K4332 L73_74 L143_144 0.1117
K4333 L73_74 L1_2 0.0258
K4334 L73_74 L23_24 0.0419
K4335 L73_74 L158_159 0.0405
K4336 L73_74 L163_164 0.0488
K4337 L73_74 L144_145 0.095
K4338 L73_74 L120_183 0.0331
K4339 L73_74 L160_161 0.0537
K4340 L73_74 L151_152 0.0965
K4341 L73_74 L126_127 0.0402
K4342 L73_74 L22_23 0.0431
K4343 L73_74 L204_205 0.0931
K4344 L73_74 L153_154 0.0775
K4345 L73_74 L4_5 0.0243
K4346 L73_74 L34_35 0.0582
K4347 L73_74 L41_42 0.1069
K4348 L73_74 L201_202 0.1743
K4349 L73_74 L191_192 0.0615
K4350 L73_74 L200_201 0.0969
K4351 L73_74 L205_206 0.1537
K4352 L73_74 L36_37 0.0861
K4353 L73_74 L131_132 0.1032
K4354 L73_74 L100_101 0.0921
K4355 L73_74 L203_204 0.0642
K4356 L73_74 L81_82 0.0952
K4357 L73_74 L13_14 0.0319
K4358 L73_74 L131_194 0.2931
K4359 L73_74 L148_149 0.1014
K4360 L73_74 L19_20 0.0327
K4361 L73_74 L187_188 0.0343
K4362 L73_74 L165_166 0.0662
K4363 L73_74 L102_103 0.092
K4364 L73_74 L106_107 0.0349
K4365 L73_74 L60_61 0.0506
K4366 L73_74 L64_65 0.0512
K4367 L73_74 L133_134 0.082
K4368 L73_74 L8_9 0.0303
K4369 L73_74 L107_108 0.0385
K4370 L73_74 L170_171 0.0845
K4371 L73_74 L193_194 0.1765
K4372 L73_74 L63_64 0.0462
K4373 L73_74 L21_65 0.0532
K4374 L73_74 L121_122 0.041
K4375 L73_74 L119_120 0.0488
K4376 L73_74 L9_10 0.0296
K4377 L73_74 L46_47 0.035
K4378 L73_74 L67_68 0.0947
K4379 L73_74 L33_34 0.0611
K4380 L73_74 L134_135 0.074
K4381 L73_74 L41_69 0.4331
K4382 L73_74 L171_172 0.079
K4383 L73_74 L104_105 0.0713
K4384 L73_74 L151_210 0.1684
K4385 L73_74 L79_94 0.1855
K4386 L73_74 L37_38 0.0802
K4387 L73_74 L75_76 0.066
K4388 L73_74 L112_113 0.0418
K4389 L73_74 L183_184 0.0325
K4390 L73_74 L59_60 0.0464
K4391 L73_74 L11_57 0.0491
K4392 L73_74 L38_39 0.0747
K4393 L73_74 L108_109 0.0412
K4394 L73_74 L27_28 0.0525
K4395 L73_74 L78_79 0.3334
K4396 L73_74 L44_45 0.0753
K4397 L73_74 L47_48 0.0386
K4398 L73_74 L29_30 0.0491
K4399 L73_74 L76_77 0.0993
K4400 L73_74 L114_115 0.046
K4401 L73_74 L166_167 0.0634
K4402 L73_74 L185_186 0.031
K4403 L73_74 L177_178 0.0242
K4404 L73_74 L16_17 0.0352
K4405 L73_74 L188_189 0.0334
K4406 L73_74 L86_87 0.0854
K4407 L73_74 L118_119 0.0474
K4408 L73_74 L176_177 0.0247
K4409 L73_74 L3_4 0.0248
K4410 L73_74 L6_53 0.0462
K4411 L73_74 L149_150 0.0885
K4412 L73_74 L2_3 0.0253
K4413 L73_74 L98_99 0.1252
K4414 L73_74 L55_56 0.0441
K4415 L73_74 L84_98 0.1459
K4416 L73_74 L48_49 0.0414
K4417 L73_74 L110_175 0.0257
K4418 L73_74 L124_125 0.052
K4419 L73_74 L113_114 0.0448
K4420 L73_74 L52_53 0.045
K4421 L73_74 L80_81 0.0648
K4422 L73_74 L17_18 0.0345
K4423 L73_74 L141_202 0.2659
K4424 L73_74 L87_88 0.1369
K4425 L73_74 L146_147 0.1327
K4426 L73_74 L209_210 0.13
K4427 L73_74 L94_95 0.1476
K4428 L73_74 L127_128 0.0459
K4429 L73_74 L42_43 0.0942
K4430 L73_74 L181_182 0.0295
K4431 L73_74 L28_29 0.0508
K4432 L73_74 L157_158 0.0417
K4433 L73_74 L122_123 0.0461
K4434 L73_74 L96_97 0.0996
K4435 L73_74 L66_67 0.0621
K4436 L73_74 L129_130 0.0528
K4437 L73_74 L21_22 0.0441
K4438 L73_74 L117_118 0.0439
K4439 L73_74 L51_52 0.0419
K4440 L73_74 L56_57 0.0477
K4441 L73_74 L24_25 0.0407
K4442 L73_74 L116_117 0.0393
K4443 L73_74 L6_7 0.0315
K4444 L73_74 L173_174 0.0687
K4445 L73_74 L154_155 0.0689
K4446 L73_74 L32_33 0.0641
K4447 L73_74 L103_104 0.081
K4448 L73_74 L85_86 0.0594
K4449 L73_74 L7_8 0.0309
K4450 L73_74 L82_83 0.1646
K4451 L73_74 L14_15 0.0311
K4452 L73_74 L184_185 0.0317
K4453 L73_74 L141_142 0.1583
K4454 L73_74 L62_63 0.0404
K4455 L73_74 L125_187 0.035
K4456 L73_74 L58_59 0.0411
K4457 L73_74 L68_69 0.2045
K4458 L73_74 L180_181 0.0302
K4459 L73_74 L89_102 0.1034
K4460 L73_74 L26_27 0.054
K4461 L73_74 L50_51 0.0379
K4462 L73_74 L168_169 0.0577
K4463 L73_74 L83_84 0.2392
K4464 L73_74 L161_162 0.0521
K4465 L73_74 L111_112 0.0378
K4466 L73_74 L162_163 0.0505
K4467 L73_74 L179_180 0.0308
K4468 L73_74 L12_13 0.0326
K4469 L73_74 L207_208 0.0588
K4470 L73_74 L142_143 0.133
K4471 L73_74 L123_124 0.0504
K4472 L73_74 L152_153 0.087
K4473 L73_74 L39_40 0.0696
K4474 L73_74 L18_19 0.0336
K4475 L73_74 L130_156 0.0438
K4476 L73_74 L156_157 0.0428
K4477 L73_74 L189_190 0.0325
K4478 L73_74 L11_12 0.0333
K4479 L73_74 L54_55 0.0395
K4480 L118_123 L181_185 0.0398
K4481 L118_123 L140_145 0.0227
K4482 L118_123 L1_6 0.0673
K4483 L118_123 L13_18 0.0424
K4484 L118_123 L35_40 0.0387
K4485 L118_123 L23_28 0.0531
K4486 L118_123 L73_78 0.0513
K4487 L118_123 L6_11 0.0681
K4488 L118_123 L163_168 0.0473
K4489 L118_123 L91_95 0.0289
K4490 L118_123 L144_149 0.0271
K4491 L118_123 L130_160 0.0561
K4492 L118_123 L4_9 0.0392
K4493 L118_123 L202_206 0.0489
K4494 L118_123 L109_114 0.1103
K4495 L118_123 L57_61 0.1114
K4496 L118_123 L164_169 0.0419
K4497 L118_123 L195_199 0.0412
K4498 L118_123 L106_111 0.0796
K4499 L118_123 L34_39 0.0435
K4500 L118_123 L148_153 0.027
K4501 L118_123 L204_208 0.0466
K4502 L118_123 L53_57 0.1104
K4503 L118_123 L69_73 0.054
K4504 L118_123 L200_204 0.0489
K4505 L118_123 L150_155 0.0213
K4506 L118_123 L145_150 0.0219
K4507 L118_123 L30_35 0.0417
K4508 L118_123 L194_198 0.0543
K4509 L118_123 L131_136 0.0428
K4510 L118_123 L101_105 0.0212
K4511 L118_123 L46_50 0.0782
K4512 L118_123 L196_200 0.0515
K4513 L118_123 L92_96 0.0279
K4514 L118_123 L81_86 0.0464
K4515 L118_123 L19_24 0.0395
K4516 L118_123 L120_125 0.0692
K4517 L118_123 L8_13 0.0423
K4518 L118_123 L157_188 0.0426
K4519 L118_123 L133_138 0.03
K4520 L118_123 L37_42 0.043
K4521 L118_123 L198_202 0.0515
K4522 L118_123 L168_173 0.0437
K4523 L118_123 L7_12 0.0455
K4524 L118_123 L137_142 0.03
K4525 L118_123 L20_25 0.0312
K4526 L118_123 L167_172 0.0459
K4527 L118_123 L121_126 0.0812
K4528 L118_123 L119_124 0.1145
K4529 L118_123 L97_101 0.0219
K4530 L118_123 L110_115 0.0681
K4531 L118_123 L134_139 0.029
K4532 L118_123 L141_146 0.0393
K4533 L118_123 L182_186 0.0313
K4534 L118_123 L100_104 0.0261
K4535 L118_123 L166_171 0.0483
K4536 L118_123 L9_14 0.0395
K4537 L118_123 L138_143 0.029
K4538 L118_123 L33_38 0.0457
K4539 L118_123 L18_23 0.0423
K4540 L118_123 L132_171 0.0432
K4541 L118_123 L124_129 0.1134
K4542 L118_123 L107_112 0.1103
K4543 L118_123 L78_83 0.0487
K4544 L118_123 L112_117 0.1134
K4545 L118_123 L40_45 0.0355
K4546 L118_123 L183_187 0.0461
K4547 L118_123 L136_141 0.041
K4548 L118_123 L59_63 0.1104
K4549 L118_123 L5_10 0.031
K4550 L118_123 L71_76 0.0513
K4551 L118_123 L15_20 0.0312
K4552 L118_123 L51_55 0.1104
K4553 L118_123 L58_62 0.0797
K4554 L118_123 L67_71 0.054
K4555 L118_123 L36_41 0.0409
K4556 L118_123 L29_34 0.0471
K4557 L118_123 L179_183 0.0459
K4558 L118_123 L158_189 0.0398
K4559 L118_123 L206_210 0.0466
K4560 L118_123 L41_74 0.0426
K4561 L118_123 L131_170 0.0411
K4562 L118_123 L28_33 0.0499
K4563 L118_123 L191_195 0.0433
K4564 L118_123 L66_70 0.0431
K4565 L118_123 L98_102 0.0277
K4566 L118_123 L27_32 0.0531
K4567 L118_123 L142_147 0.0288
K4568 L118_123 L147_152 0.0278
K4569 L118_123 L178_182 0.0312
K4570 L118_123 L180_184 0.0426
K4571 L118_123 L3_8 0.042
K4572 L118_123 L157_162 0.0535
K4573 L118_123 L149_154 0.0262
K4574 L118_123 L203_207 0.0375
K4575 L118_123 L2_7 0.0451
K4576 L118_123 L117_122 0.1145
K4577 L118_123 L22_27 0.057
K4578 L118_123 L17_22 0.0455
K4579 L118_123 L38_43 0.0412
K4580 L118_123 L47_51 0.1076
K4581 L118_123 L55_59 0.1114
K4582 L118_123 L135_174 0.0356
K4583 L118_123 L94_98 0.0287
K4584 L118_123 L160_165 0.0518
K4585 L118_123 L115_120 0.069
K4586 L118_123 L80_85 0.0373
K4587 L118_123 L10_15 0.0312
K4588 L118_123 L16_21 0.0681
K4589 L118_123 L158_163 0.05
K4590 L118_123 L185_189 0.0398
K4591 L118_123 L96_100 0.027
K4592 L118_123 L49_53 0.1076
K4593 L118_123 L186_190 0.0314
K4594 L118_123 L156_161 0.0574
K4595 L118_123 L125_130 0.069
K4596 L118_123 L184_188 0.0427
K4597 L118_123 L159_164 0.044
K4598 L118_123 L24_29 0.0497
K4599 L118_123 L169_174 0.0389
K4600 L118_123 L25_30 0.0438
K4601 L118_123 L32_37 0.0481
K4602 L118_123 L133_172 0.0414
K4603 L118_123 L14_19 0.0396
K4604 L118_123 L44_92 0.0289
K4605 L118_123 L161_166 0.0534
K4606 L118_123 L21_26 0.0556
K4607 L118_123 L95_99 0.0279
K4608 L118_123 L84_89 0.0375
K4609 L118_123 L116_121 0.0818
K4610 L118_123 L74_79 0.0408
K4611 L118_123 L165_170 0.0464
K4612 L118_123 L199_203 0.0393
K4613 L118_123 L75_80 0.0391
K4614 L118_123 L143_148 0.028
K4615 L118_123 L70_75 0.041
K4616 L118_123 L50_54 0.0797
K4617 L118_123 L79_84 0.0391
K4618 L118_123 L159_190 0.0313
K4619 L118_123 L93_97 0.0226
K4620 L118_123 L90_94 0.0298
K4621 L118_123 L134_173 0.0397
K4622 L118_123 L139_144 0.028
K4623 L118_123 L83_88 0.0464
K4624 L118_123 L177_181 0.0395
K4625 L118_123 L111_116 0.0812
K4626 L118_123 L162_167 0.0502
K4627 L118_123 L43_91 0.0299
K4628 L118_123 L122_127 0.1134
K4629 L118_123 L135_140 0.0234
K4630 L118_123 L39_44 0.0396
K4631 L118_123 L12_17 0.0457
K4632 L118_123 L54_58 0.0802
K4633 L118_123 L146_151 0.0377
K4634 L118_123 L114_119 0.1134
K4635 L118_123 L61_65 0.1104
K4636 L118_123 L11_16 0.0684
K4637 L194_198 L140_145 0.0421
K4638 L194_198 L1_6 0.0435
K4639 L194_198 L13_18 0.0344
K4640 L194_198 L35_40 0.0512
K4641 L194_198 L23_28 0.0463
K4642 L194_198 L17_22 0.0374
K4643 L194_198 L184_188 0.0345
K4644 L194_198 L6_11 0.0458
K4645 L194_198 L163_168 0.0514
K4646 L194_198 L91_95 0.059
K4647 L194_198 L144_149 0.0537
K4648 L194_198 L130_160 0.0458
K4649 L194_198 L4_9 0.0305
K4650 L194_198 L156_161 0.0483
K4651 L194_198 L181_185 0.032
K4652 L194_198 L164_169 0.0457
K4653 L194_198 L106_111 0.035
K4654 L194_198 L34_39 0.0582
K4655 L194_198 L148_153 0.0575
K4656 L194_198 L201_205 0.1103
K4657 L194_198 L9_14 0.0318
K4658 L194_198 L200_204 0.0733
K4659 L194_198 L150_155 0.0409
K4660 L194_198 L145_150 0.0417
K4661 L194_198 L30_35 0.0454
K4662 L194_198 L131_136 0.1098
K4663 L194_198 L101_105 0.0405
K4664 L194_198 L46_50 0.0349
K4665 L194_198 L196_200 0.0741
K4666 L194_198 L92_96 0.0537
K4667 L194_198 L81_86 0.0713
K4668 L194_198 L19_24 0.0347
K4669 L194_198 L120_125 0.0487
K4670 L194_198 L8_13 0.0328
K4671 L194_198 L157_188 0.0362
K4672 L194_198 L133_138 0.0602
K4673 L194_198 L60_64 0.057
K4674 L194_198 L72_77 0.1104
K4675 L194_198 L193_197 0.1145
K4676 L194_198 L168_173 0.0587
K4677 L194_198 L7_12 0.0338
K4678 L194_198 L137_142 0.0667
K4679 L194_198 L20_25 0.028
K4680 L194_198 L167_172 0.0627
K4681 L194_198 L121_126 0.0393
K4682 L194_198 L195_199 0.0558
K4683 L194_198 L97_101 0.0412
K4684 L194_198 L110_115 0.0437
K4685 L194_198 L113_118 0.0515
K4686 L194_198 L134_139 0.0546
K4687 L194_198 L141_146 0.1051
K4688 L194_198 L182_186 0.0258
K4689 L194_198 L100_104 0.052
K4690 L194_198 L166_171 0.0672
K4691 L194_198 L24_29 0.0446
K4692 L194_198 L138_143 0.0599
K4693 L194_198 L33_38 0.0621
K4694 L194_198 L18_23 0.0361
K4695 L194_198 L132_171 0.0781
K4696 L194_198 L107_112 0.0439
K4697 L194_198 L112_117 0.0457
K4698 L194_198 L40_45 0.0565
K4699 L194_198 L183_187 0.0357
K4700 L194_198 L136_141 0.1086
K4701 L194_198 L59_63 0.0494
K4702 L194_198 L5_10 0.0247
K4703 L194_198 L71_76 0.0734
K4704 L194_198 L15_20 0.0268
K4705 L194_198 L51_55 0.0455
K4706 L194_198 L58_62 0.0391
K4707 L194_198 L67_71 0.0736
K4708 L194_198 L36_41 0.0761
K4709 L194_198 L48_52 0.0487
K4710 L194_198 L29_34 0.0511
K4711 L194_198 L179_183 0.034
K4712 L194_198 L41_74 0.1064
K4713 L194_198 L131_170 0.0775
K4714 L194_198 L28_33 0.0536
K4715 L194_198 L205_209 0.1057
K4716 L194_198 L191_195 0.056
K4717 L194_198 L66_70 0.0555
K4718 L194_198 L98_102 0.0624
K4719 L194_198 L27_32 0.0564
K4720 L194_198 L142_147 0.0654
K4721 L194_198 L147_152 0.0634
K4722 L194_198 L178_182 0.0248
K4723 L194_198 L180_184 0.033
K4724 L194_198 L3_8 0.0314
K4725 L194_198 L157_162 0.0465
K4726 L194_198 L149_154 0.0526
K4727 L194_198 L203_207 0.0545
K4728 L194_198 L2_7 0.0322
K4729 L194_198 L117_122 0.0476
K4730 L194_198 L22_27 0.048
K4731 L194_198 L158_189 0.0349
K4732 L194_198 L38_43 0.0704
K4733 L194_198 L47_51 0.0437
K4734 L194_198 L55_59 0.0474
K4735 L194_198 L135_174 0.057
K4736 L194_198 L94_98 0.0643
K4737 L194_198 L160_165 0.0544
K4738 L194_198 L52_56 0.0513
K4739 L194_198 L115_120 0.046
K4740 L194_198 L80_85 0.0541
K4741 L194_198 L10_15 0.0257
K4742 L194_198 L16_21 0.0512
K4743 L194_198 L158_163 0.0448
K4744 L194_198 L185_189 0.0334
K4745 L194_198 L96_100 0.0531
K4746 L194_198 L165_170 0.0654
K4747 L194_198 L186_190 0.0269
K4748 L194_198 L82_87 0.1034
K4749 L194_198 L125_130 0.0516
K4750 L194_198 L108_113 0.0489
K4751 L194_198 L159_164 0.0402
K4752 L194_198 L84_89 0.0977
K4753 L194_198 L68_72 0.1114
K4754 L194_198 L169_174 0.0516
K4755 L194_198 L204_208 0.072
K4756 L194_198 L37_42 0.0769
K4757 L194_198 L25_30 0.04
K4758 L194_198 L32_37 0.0664
K4759 L194_198 L133_172 0.0713
K4760 L194_198 L14_19 0.0332
K4761 L194_198 L44_92 0.054
K4762 L194_198 L161_166 0.0568
K4763 L194_198 L21_26 0.0455
K4764 L194_198 L95_99 0.0581
K4765 L194_198 L116_121 0.0378
K4766 L194_198 L74_79 0.1053
K4767 L194_198 L199_203 0.0553
K4768 L194_198 L75_80 0.0549
K4769 L194_198 L70_75 0.0554
K4770 L194_198 L50_54 0.0362
K4771 L194_198 L79_84 0.1022
K4772 L194_198 L56_60 0.054
K4773 L194_198 L159_190 0.0281
K4774 L194_198 L93_97 0.0417
K4775 L194_198 L90_94 0.0655
K4776 L194_198 L134_173 0.0655
K4777 L194_198 L139_144 0.0544
K4778 L194_198 L177_181 0.0306
K4779 L194_198 L111_116 0.0364
K4780 L194_198 L162_167 0.054
K4781 L194_198 L43_91 0.0593
K4782 L194_198 L122_127 0.0496
K4783 L194_198 L135_140 0.0423
K4784 L194_198 L39_44 0.0648
K4785 L194_198 L123_128 0.0574
K4786 L194_198 L12_17 0.0355
K4787 L194_198 L54_58 0.0376
K4788 L194_198 L146_151 0.1002
K4789 L194_198 L143_148 0.059
K4790 L194_198 L11_16 0.0484
K4791 L194_198 L77_82 0.1076
K4792 L17_22 L24_29 0.1437
K4793 L17_22 L181_185 0.1015
K4794 L17_22 L140_145 0.0229
K4795 L17_22 L1_6 0.1012
K4796 L17_22 L13_18 0.1832
K4797 L17_22 L35_40 0.0544
K4798 L17_22 L23_28 0.1879
K4799 L17_22 L73_78 0.0357
K4800 L17_22 L184_188 0.1438
K4801 L17_22 L6_11 0.1129
K4802 L17_22 L163_168 0.086
K4803 L17_22 L91_95 0.0285
K4804 L17_22 L144_149 0.0262
K4805 L17_22 L130_160 0.2105
K4806 L17_22 L4_9 0.0953
K4807 L17_22 L202_206 0.0338
K4808 L17_22 L109_114 0.0624
K4809 L17_22 L57_61 0.0667
K4810 L17_22 L164_169 0.0742
K4811 L17_22 L195_199 0.0214
K4812 L17_22 L106_111 0.0267
K4813 L17_22 L34_39 0.061
K4814 L17_22 L148_153 0.0248
K4815 L17_22 L201_205 0.0298
K4816 L17_22 L53_57 0.0654
K4817 L17_22 L69_73 0.0376
K4818 L17_22 L200_204 0.0262
K4819 L17_22 L150_155 0.0202
K4820 L17_22 L145_150 0.0215
K4821 L17_22 L30_35 0.077
K4822 L17_22 L131_136 0.0378
K4823 L17_22 L101_105 0.0203
K4824 L17_22 L46_50 0.0268
K4825 L17_22 L196_200 0.0269
K4826 L17_22 L92_96 0.0281
K4827 L17_22 L81_86 0.0255
K4828 L17_22 L19_24 0.1354
K4829 L17_22 L120_125 0.1131
K4830 L17_22 L8_13 0.1439
K4831 L17_22 L157_188 0.1536
K4832 L17_22 L133_138 0.0304
K4833 L17_22 L60_64 0.0461
K4834 L17_22 L72_77 0.0311
K4835 L17_22 L198_202 0.0355
K4836 L17_22 L193_197 0.0322
K4837 L17_22 L168_173 0.0598
K4838 L17_22 L20_25 0.0891
K4839 L17_22 L167_172 0.0619
K4840 L17_22 L121_126 0.0271
K4841 L17_22 L119_124 0.0655
K4842 L17_22 L97_101 0.0216
K4843 L17_22 L110_115 0.0959
K4844 L17_22 L113_118 0.0451
K4845 L17_22 L141_146 0.0332
K4846 L17_22 L182_186 0.073
K4847 L17_22 L100_104 0.0247
K4848 L17_22 L9_14 0.1124
K4849 L17_22 L138_143 0.0283
K4850 L17_22 L33_38 0.0633
K4851 L17_22 L18_23 0.2054
K4852 L17_22 L134_139 0.03
K4853 L17_22 L124_129 0.0659
K4854 L17_22 L107_112 0.0344
K4855 L17_22 L78_83 0.034
K4856 L17_22 L112_117 0.0347
K4857 L17_22 L40_45 0.0412
K4858 L17_22 L136_141 0.0353
K4859 L17_22 L59_63 0.0351
K4860 L17_22 L5_10 0.0696
K4861 L17_22 L71_76 0.027
K4862 L17_22 L15_20 0.0861
K4863 L17_22 L51_55 0.0349
K4864 L17_22 L58_62 0.0272
K4865 L17_22 L67_71 0.0278
K4866 L17_22 L36_41 0.053
K4867 L17_22 L48_52 0.0448
K4868 L17_22 L29_34 0.0898
K4869 L17_22 L206_210 0.0322
K4870 L17_22 L41_74 0.038
K4871 L17_22 L131_170 0.052
K4872 L17_22 L28_33 0.098
K4873 L17_22 L205_209 0.0287
K4874 L17_22 L191_195 0.022
K4875 L17_22 L178_182 0.0657
K4876 L17_22 L180_184 0.1226
K4877 L17_22 L3_8 0.1124
K4878 L17_22 L157_162 0.1572
K4879 L17_22 L149_154 0.0246
K4880 L17_22 L203_207 0.0203
K4881 L17_22 L66_70 0.022
K4882 L17_22 L117_122 0.0349
K4883 L17_22 L114_119 0.0643
K4884 L17_22 L158_189 0.1173
K4885 L17_22 L38_43 0.0465
K4886 L17_22 L47_51 0.0346
K4887 L17_22 L55_59 0.0351
K4888 L17_22 L135_174 0.0408
K4889 L17_22 L160_165 0.1339
K4890 L17_22 L52_56 0.0455
K4891 L17_22 L115_120 0.1056
K4892 L17_22 L80_85 0.0203
K4893 L17_22 L10_15 0.0787
K4894 L17_22 L16_21 0.1262
K4895 L17_22 L158_163 0.1293
K4896 L17_22 L185_189 0.1127
K4897 L17_22 L96_100 0.0263
K4898 L17_22 L49_53 0.0634
K4899 L17_22 L186_190 0.0789
K4900 L17_22 L82_87 0.0288
K4901 L17_22 L125_130 0.1161
K4902 L17_22 L108_113 0.0445
K4903 L17_22 L159_164 0.1037
K4904 L17_22 L84_89 0.0314
K4905 L17_22 L68_72 0.0324
K4906 L17_22 L169_174 0.0534
K4907 L17_22 L204_208 0.0254
K4908 L17_22 L25_30 0.1117
K4909 L17_22 L133_172 0.0459
K4910 L17_22 L14_19 0.1284
K4911 L17_22 L44_92 0.0302
K4912 L17_22 L21_26 0.3319
K4913 L17_22 L95_99 0.0266
K4914 L17_22 L116_121 0.027
K4915 L17_22 L74_79 0.0356
K4916 L17_22 L165_170 0.0763
K4917 L17_22 L199_203 0.0208
K4918 L17_22 L75_80 0.0209
K4919 L17_22 L143_148 0.0265
K4920 L17_22 L70_75 0.0214
K4921 L17_22 L50_54 0.027
K4922 L17_22 L79_84 0.0334
K4923 L17_22 L56_60 0.0459
K4924 L17_22 L159_190 0.0811
K4925 L17_22 L93_97 0.023
K4926 L17_22 L134_173 0.045
K4927 L17_22 L139_144 0.0279
K4928 L17_22 L83_88 0.0324
K4929 L17_22 L177_181 0.0884
K4930 L17_22 L111_116 0.0269
K4931 L17_22 L162_167 0.093
K4932 L17_22 L43_91 0.0306
K4933 L17_22 L122_127 0.0349
K4934 L17_22 L135_140 0.0245
K4935 L17_22 L39_44 0.0455
K4936 L17_22 L123_128 0.0457
K4937 L17_22 L54_58 0.0271
K4938 L17_22 L146_151 0.0313
K4939 L17_22 L61_65 0.0671
K4940 L17_22 L11_16 0.1224
K4941 L17_22 L77_82 0.03
K4942 L131_194 L167_168 0.0598
K4943 L131_194 L74_90 0.1668
K4944 L131_194 L199_200 0.0613
K4945 L131_194 L115_179 0.0306
K4946 L131_194 L128_129 0.0502
K4947 L131_194 L196_197 0.0947
K4948 L131_194 L1_2 0.0249
K4949 L131_194 L23_24 0.0405
K4950 L131_194 L158_159 0.0395
K4951 L131_194 L136_198 0.4331
K4952 L131_194 L163_164 0.0477
K4953 L131_194 L144_145 0.0913
K4954 L131_194 L120_183 0.0324
K4955 L131_194 L91_92 0.1103
K4956 L131_194 L160_161 0.053
K4957 L131_194 L151_152 0.0917
K4958 L131_194 L126_127 0.0388
K4959 L131_194 L22_23 0.0417
K4960 L131_194 L153_154 0.0732
K4961 L131_194 L4_5 0.0233
K4962 L131_194 L34_35 0.0562
K4963 L131_194 L197_198 0.2045
K4964 L131_194 L204_205 0.0877
K4965 L131_194 L143_144 0.1086
K4966 L131_194 L200_201 0.0917
K4967 L131_194 L205_206 0.1475
K4968 L131_194 L36_37 0.0841
K4969 L131_194 L141_142 0.1616
K4970 L131_194 L100_101 0.0809
K4971 L131_194 L203_204 0.0601
K4972 L131_194 L92_93 0.0922
K4973 L131_194 L81_82 0.0858
K4974 L131_194 L13_14 0.0308
K4975 L131_194 L185_186 0.0301
K4976 L131_194 L148_149 0.0967
K4977 L131_194 L19_20 0.0315
K4978 L131_194 L187_188 0.0335
K4979 L131_194 L165_166 0.0662
K4980 L131_194 L102_103 0.0783
K4981 L131_194 L106_107 0.0336
K4982 L131_194 L60_61 0.0492
K4983 L131_194 L64_65 0.0498
K4984 L131_194 L8_9 0.0292
K4985 L131_194 L107_108 0.0373
K4986 L131_194 L170_171 0.0859
K4987 L131_194 L63_64 0.0446
K4988 L131_194 L21_65 0.052
K4989 L131_194 L121_122 0.0395
K4990 L131_194 L119_120 0.048
K4991 L131_194 L9_10 0.0285
K4992 L131_194 L46_47 0.0335
K4993 L131_194 L195_196 0.0621
K4994 L131_194 L33_34 0.0592
K4995 L131_194 L171_172 0.0793
K4996 L131_194 L104_105 0.0629
K4997 L131_194 L151_210 0.1605
K4998 L131_194 L79_94 0.1412
K4999 L131_194 L37_38 0.0779
K5000 L131_194 L75_76 0.0607
K5001 L131_194 L112_113 0.0406
K5002 L131_194 L183_184 0.0317
K5003 L131_194 L59_60 0.0447
K5004 L131_194 L11_57 0.0477
K5005 L131_194 L38_39 0.0721
K5006 L131_194 L108_109 0.0403
K5007 L131_194 L71_72 0.0923
K5008 L131_194 L27_28 0.0509
K5009 L131_194 L96_97 0.0872
K5010 L131_194 L78_79 0.2334
K5011 L131_194 L138_139 0.1194
K5012 L131_194 L47_48 0.0372
K5013 L131_194 L29_30 0.0474
K5014 L131_194 L76_77 0.0896
K5015 L131_194 L114_115 0.0451
K5016 L131_194 L166_167 0.063
K5017 L131_194 L177_178 0.0234
K5018 L131_194 L16_17 0.0341
K5019 L131_194 L188_189 0.0326
K5020 L131_194 L86_87 0.077
K5021 L131_194 L118_119 0.0465
K5022 L131_194 L176_177 0.024
K5023 L131_194 L3_4 0.0239
K5024 L131_194 L6_53 0.0448
K5025 L131_194 L149_150 0.084
K5026 L131_194 L2_3 0.0244
K5027 L131_194 L98_99 0.1049
K5028 L131_194 L55_56 0.0425
K5029 L131_194 L184_185 0.0309
K5030 L131_194 L84_98 0.1183
K5031 L131_194 L48_49 0.0401
K5032 L131_194 L110_175 0.025
K5033 L131_194 L124_125 0.0513
K5034 L131_194 L113_114 0.0438
K5035 L131_194 L52_53 0.0436
K5036 L131_194 L80_81 0.0595
K5037 L131_194 L17_18 0.0333
K5038 L131_194 L141_202 0.2809
K5039 L131_194 L87_88 0.1173
K5040 L131_194 L146_147 0.1286
K5041 L131_194 L209_210 0.123
K5042 L131_194 L94_95 0.1201
K5043 L131_194 L127_128 0.0449
K5044 L131_194 L181_182 0.0286
K5045 L131_194 L28_29 0.0492
K5046 L131_194 L157_158 0.0407
K5047 L131_194 L122_123 0.045
K5048 L131_194 L103_104 0.0703
K5049 L131_194 L129_130 0.0524
K5050 L131_194 L21_22 0.0428
K5051 L131_194 L117_118 0.0427
K5052 L131_194 L51_52 0.0404
K5053 L131_194 L56_57 0.0462
K5054 L131_194 L24_25 0.0393
K5055 L131_194 L116_117 0.0379
K5056 L131_194 L6_7 0.0304
K5057 L131_194 L173_174 0.0678
K5058 L131_194 L154_155 0.0649
K5059 L131_194 L32_33 0.0623
K5060 L131_194 L95_96 0.1019
K5061 L131_194 L85_86 0.0545
K5062 L131_194 L7_8 0.0299
K5063 L131_194 L82_83 0.1387
K5064 L131_194 L14_15 0.03
K5065 L131_194 L147_148 0.112
K5066 L131_194 L62_63 0.0387
K5067 L131_194 L125_187 0.0344
K5068 L131_194 L58_59 0.0394
K5069 L131_194 L70_71 0.0615
K5070 L131_194 L136_137 0.213
K5071 L131_194 L180_181 0.0293
K5072 L131_194 L89_102 0.0863
K5073 L131_194 L26_27 0.0525
K5074 L131_194 L50_51 0.0363
K5075 L131_194 L168_169 0.0567
K5076 L131_194 L83_84 0.1866
K5077 L131_194 L90_91 0.135
K5078 L131_194 L139_140 0.0972
K5079 L131_194 L161_162 0.0513
K5080 L131_194 L111_112 0.0364
K5081 L131_194 L162_163 0.0495
K5082 L131_194 L137_138 0.1546
K5083 L131_194 L179_180 0.03
K5084 L131_194 L12_13 0.0315
K5085 L131_194 L207_208 0.055
K5086 L131_194 L142_143 0.132
K5087 L131_194 L123_124 0.0495
K5088 L131_194 L152_153 0.0824
K5089 L131_194 L39_40 0.0669
K5090 L131_194 L18_19 0.0324
K5091 L131_194 L130_156 0.0431
K5092 L131_194 L156_157 0.0419
K5093 L131_194 L189_190 0.0317
K5094 L131_194 L11_12 0.0322
K5095 L131_194 L54_55 0.0378
K5096 L131_194 L201_202 0.1727
K5097 L33_34 L74_90 0.0537
K5098 L33_34 L199_200 0.034
K5099 L33_34 L115_179 0.053
K5100 L33_34 L128_129 0.065
K5101 L33_34 L147_148 0.045
K5102 L33_34 L196_197 0.0412
K5103 L33_34 L1_2 0.0434
K5104 L33_34 L23_24 0.0897
K5105 L33_34 L158_159 0.0865
K5106 L33_34 L136_198 0.0606
K5107 L33_34 L163_164 0.1203
K5108 L33_34 L144_145 0.049
K5109 L33_34 L120_183 0.0585
K5110 L33_34 L91_92 0.0548
K5111 L33_34 L160_161 0.1153
K5112 L33_34 L151_152 0.0348
K5113 L33_34 L126_127 0.0398
K5114 L33_34 L22_23 0.0888
K5115 L33_34 L204_205 0.0388
K5116 L33_34 L153_154 0.0352
K5117 L33_34 L4_5 0.0441
K5118 L33_34 L41_42 0.0766
K5119 L33_34 L197_198 0.0498
K5120 L33_34 L143_144 0.0492
K5121 L33_34 L200_201 0.04
K5122 L33_34 L205_206 0.0457
K5123 L33_34 L36_37 0.12
K5124 L33_34 L131_132 0.0751
K5125 L33_34 L100_101 0.0454
K5126 L33_34 L203_204 0.0332
K5127 L33_34 L92_93 0.0545
K5128 L33_34 L81_82 0.0389
K5129 L33_34 L13_14 0.061
K5130 L33_34 L148_149 0.0451
K5131 L33_34 L19_20 0.0683
K5132 L33_34 L102_103 0.0354
K5133 L33_34 L106_107 0.0365
K5134 L33_34 L60_61 0.0656
K5135 L33_34 L64_65 0.0658
K5136 L33_34 L133_134 0.0772
K5137 L33_34 L8_9 0.0548
K5138 L33_34 L107_108 0.0438
K5139 L33_34 L170_171 0.1153
K5140 L33_34 L193_194 0.048
K5141 L33_34 L63_64 0.0502
K5142 L33_34 L21_65 0.0881
K5143 L33_34 L121_122 0.0415
K5144 L33_34 L119_120 0.0749
K5145 L33_34 L9_10 0.0545
K5146 L33_34 L46_47 0.0366
K5147 L33_34 L195_196 0.0347
K5148 L33_34 L67_68 0.0394
K5149 L33_34 L187_188 0.0668
K5150 L33_34 L134_135 0.0767
K5151 L33_34 L41_69 0.0598
K5152 L33_34 L171_172 0.1203
K5153 L33_34 L104_105 0.0354
K5154 L33_34 L151_210 0.0478
K5155 L33_34 L79_94 0.049
K5156 L33_34 L37_38 0.1258
K5157 L33_34 L75_76 0.0341
K5158 L33_34 L112_113 0.0475
K5159 L33_34 L183_184 0.0596
K5160 L33_34 L59_60 0.0515
K5161 L33_34 L11_57 0.0759
K5162 L33_34 L38_39 0.1279
K5163 L33_34 L108_109 0.0531
K5164 L33_34 L71_72 0.0414
K5165 L33_34 L27_28 0.1258
K5166 L33_34 L78_79 0.0574
K5167 L33_34 L44_45 0.0782
K5168 L33_34 L47_48 0.044
K5169 L33_34 L29_30 0.1258
K5170 L33_34 L76_77 0.0402
K5171 L33_34 L114_115 0.0688
K5172 L33_34 L185_186 0.0596
K5173 L33_34 L177_178 0.0435
K5174 L33_34 L16_17 0.0667
K5175 L33_34 L188_189 0.0673
K5176 L33_34 L86_87 0.0354
K5177 L33_34 L118_119 0.0612
K5178 L33_34 L176_177 0.0437
K5179 L33_34 L3_4 0.0443
K5180 L33_34 L6_53 0.0696
K5181 L33_34 L149_150 0.045
K5182 L33_34 L2_3 0.0441
K5183 L33_34 L98_99 0.0454
K5184 L33_34 L55_56 0.0496
K5185 L33_34 L84_98 0.045
K5186 L33_34 L48_49 0.0535
K5187 L33_34 L110_175 0.0429
K5188 L33_34 L124_125 0.0819
K5189 L33_34 L113_114 0.0577
K5190 L33_34 L52_53 0.0582
K5191 L33_34 L80_81 0.0333
K5192 L33_34 L17_18 0.0683
K5193 L33_34 L141_202 0.0569
K5194 L33_34 L87_88 0.0414
K5195 L33_34 L146_147 0.0445
K5196 L33_34 L209_210 0.0412
K5197 L33_34 L94_95 0.0496
K5198 L33_34 L136_137 0.053
K5199 L33_34 L127_128 0.0498
K5200 L33_34 L138_139 0.054
K5201 L33_34 L42_43 0.0782
K5202 L33_34 L181_182 0.0538
K5203 L33_34 L28_29 0.1279
K5204 L33_34 L157_158 0.0873
K5205 L33_34 L122_123 0.0512
K5206 L33_34 L96_97 0.0496
K5207 L33_34 L66_67 0.033
K5208 L33_34 L129_130 0.0861
K5209 L33_34 L21_22 0.0864
K5210 L33_34 L117_118 0.0493
K5211 L33_34 L51_52 0.0477
K5212 L33_34 L56_57 0.0618
K5213 L33_34 L24_25 0.0888
K5214 L33_34 L116_117 0.0405
K5215 L33_34 L6_7 0.0537
K5216 L33_34 L173_174 0.1203
K5217 L33_34 L154_155 0.0351
K5218 L33_34 L95_96 0.0498
K5219 L33_34 L85_86 0.0305
K5220 L33_34 L7_8 0.0545
K5221 L33_34 L82_83 0.0459
K5222 L33_34 L14_15 0.0606
K5223 L33_34 L184_185 0.0599
K5224 L33_34 L141_142 0.0484
K5225 L33_34 L62_63 0.04
K5226 L33_34 L125_187 0.0653
K5227 L33_34 L58_59 0.0417
K5228 L33_34 L103_104 0.0355
K5229 L33_34 L70_71 0.0348
K5230 L33_34 L68_69 0.0483
K5231 L33_34 L180_181 0.054
K5232 L33_34 L89_102 0.0351
K5233 L33_34 L26_27 0.12
K5234 L33_34 L50_51 0.0396
K5235 L33_34 L83_84 0.0539
K5236 L33_34 L90_91 0.0545
K5237 L33_34 L139_140 0.0538
K5238 L33_34 L161_162 0.1203
K5239 L33_34 L111_112 0.0394
K5240 L33_34 L162_163 0.1221
K5241 L33_34 L137_138 0.0538
K5242 L33_34 L179_180 0.0538
K5243 L33_34 L12_13 0.0606
K5244 L33_34 L207_208 0.0304
K5245 L33_34 L142_143 0.049
K5246 L33_34 L123_124 0.0649
K5247 L33_34 L152_153 0.0351
K5248 L33_34 L191_192 0.0329
K5249 L33_34 L39_40 0.1258
K5250 L33_34 L18_19 0.0688
K5251 L33_34 L130_156 0.0843
K5252 L33_34 L156_157 0.0865
K5253 L33_34 L189_190 0.0668
K5254 L33_34 L11_12 0.0595
K5255 L33_34 L54_55 0.0406
K5256 L33_34 L201_202 0.0477
K5257 L157_188 L24_29 0.1572
K5258 L157_188 L181_185 0.1439
K5259 L157_188 L140_145 0.0234
K5260 L157_188 L1_6 0.0836
K5261 L157_188 L72_77 0.0299
K5262 L157_188 L35_40 0.0557
K5263 L157_188 L73_78 0.0344
K5264 L157_188 L6_11 0.0897
K5265 L157_188 L163_168 0.098
K5266 L157_188 L144_149 0.0266
K5267 L157_188 L130_160 0.2007
K5268 L157_188 L4_9 0.1015
K5269 L157_188 L202_206 0.033
K5270 L157_188 L109_114 0.0575
K5271 L157_188 L57_61 0.059
K5272 L157_188 L164_169 0.0849
K5273 L157_188 L195_199 0.0207
K5274 L157_188 L106_111 0.0254
K5275 L157_188 L34_39 0.0619
K5276 L157_188 L201_205 0.029
K5277 L157_188 L53_57 0.0581
K5278 L157_188 L69_73 0.0361
K5279 L157_188 L200_204 0.0254
K5280 L157_188 L150_155 0.0206
K5281 L157_188 L145_150 0.0219
K5282 L157_188 L30_35 0.0812
K5283 L157_188 L131_136 0.0371
K5284 L157_188 L101_105 0.0204
K5285 L157_188 L46_50 0.0253
K5286 L157_188 L196_200 0.0261
K5287 L157_188 L92_96 0.0283
K5288 L157_188 L81_86 0.0246
K5289 L157_188 L19_24 0.1536
K5290 L157_188 L120_125 0.0991
K5291 L157_188 L160_165 0.1305
K5292 L157_188 L185_189 0.1832
K5293 L157_188 L60_64 0.0424
K5294 L157_188 L198_202 0.0345
K5295 L157_188 L193_197 0.0311
K5296 L157_188 L168_173 0.0633
K5297 L157_188 L7_12 0.1226
K5298 L157_188 L137_142 0.0285
K5299 L157_188 L20_25 0.1033
K5300 L157_188 L121_126 0.0257
K5301 L157_188 L119_124 0.0599
K5302 L157_188 L97_101 0.0218
K5303 L157_188 L110_115 0.0869
K5304 L157_188 L113_118 0.0423
K5305 L157_188 L141_146 0.0327
K5306 L157_188 L182_186 0.0985
K5307 L157_188 L100_104 0.0248
K5308 L157_188 L166_171 0.083
K5309 L157_188 L9_14 0.1226
K5310 L157_188 L132_171 0.0565
K5311 L157_188 L134_139 0.0306
K5312 L157_188 L124_129 0.0602
K5313 L157_188 L107_112 0.0327
K5314 L157_188 L78_83 0.0328
K5315 L157_188 L112_117 0.0329
K5316 L157_188 L40_45 0.0418
K5317 L157_188 L183_187 0.1832
K5318 L157_188 L136_141 0.0348
K5319 L157_188 L59_63 0.033
K5320 L157_188 L5_10 0.0759
K5321 L157_188 L71_76 0.026
K5322 L157_188 L15_20 0.0988
K5323 L157_188 L51_55 0.0328
K5324 L157_188 L58_62 0.0256
K5325 L157_188 L67_71 0.0267
K5326 L157_188 L36_41 0.051
K5327 L157_188 L48_52 0.0415
K5328 L157_188 L29_34 0.093
K5329 L157_188 L179_183 0.1439
K5330 L157_188 L158_189 0.2054
K5331 L157_188 L206_210 0.0315
K5332 L157_188 L41_74 0.0368
K5333 L157_188 L131_170 0.0518
K5334 L157_188 L205_209 0.028
K5335 L157_188 L191_195 0.0212
K5336 L157_188 L66_70 0.0212
K5337 L157_188 L98_102 0.0248
K5338 L157_188 L27_32 0.1319
K5339 L157_188 L142_147 0.0266
K5340 L157_188 L147_152 0.025
K5341 L157_188 L178_182 0.0823
K5342 L157_188 L149_154 0.025
K5343 L157_188 L203_207 0.0197
K5344 L157_188 L2_7 0.1015
K5345 L157_188 L117_122 0.0331
K5346 L157_188 L22_27 0.1886
K5347 L157_188 L47_51 0.0325
K5348 L157_188 L55_59 0.0329
K5349 L157_188 L135_174 0.0423
K5350 L157_188 L94_98 0.0265
K5351 L157_188 L52_56 0.042
K5352 L157_188 L115_120 0.0939
K5353 L157_188 L80_85 0.0196
K5354 L157_188 L10_15 0.088
K5355 L157_188 L16_21 0.0958
K5356 L157_188 L158_163 0.1879
K5357 L157_188 L96_100 0.0265
K5358 L157_188 L49_53 0.0568
K5359 L157_188 L186_190 0.1144
K5360 L157_188 L156_161 0.2444
K5361 L157_188 L82_87 0.0279
K5362 L157_188 L125_130 0.1011
K5363 L157_188 L108_113 0.0418
K5364 L157_188 L159_164 0.1407
K5365 L157_188 L84_89 0.0307
K5366 L157_188 L68_72 0.031
K5367 L157_188 L169_174 0.0569
K5368 L157_188 L204_208 0.0247
K5369 L157_188 L37_42 0.0555
K5370 L157_188 L25_30 0.1252
K5371 L157_188 L32_37 0.08
K5372 L157_188 L14_19 0.1438
K5373 L157_188 L44_92 0.0304
K5374 L157_188 L161_166 0.1482
K5375 L157_188 L21_26 0.1627
K5376 L157_188 L116_121 0.0257
K5377 L157_188 L74_79 0.0346
K5378 L157_188 L165_170 0.0756
K5379 L157_188 L199_203 0.0202
K5380 L157_188 L75_80 0.0201
K5381 L157_188 L70_75 0.0207
K5382 L157_188 L50_54 0.0255
K5383 L157_188 L79_84 0.0326
K5384 L157_188 L56_60 0.0423
K5385 L157_188 L159_190 0.1216
K5386 L157_188 L93_97 0.0232
K5387 L157_188 L90_94 0.0283
K5388 L157_188 L134_173 0.0465
K5389 L157_188 L139_144 0.0285
K5390 L157_188 L83_88 0.0314
K5391 L157_188 L177_181 0.1124
K5392 L157_188 L111_116 0.0256
K5393 L157_188 L122_127 0.0331
K5394 L157_188 L135_140 0.0251
K5395 L157_188 L39_44 0.0459
K5396 L157_188 L123_128 0.0427
K5397 L157_188 L12_17 0.1438
K5398 L157_188 L54_58 0.0256
K5399 L157_188 L146_151 0.0309
K5400 L157_188 L114_119 0.059
K5401 L157_188 L61_65 0.0593
K5402 L157_188 L11_16 0.0941
K5403 L157_188 L77_82 0.0289
K5404 L133_138 L24_29 0.0391
K5405 L133_138 L181_185 0.0266
K5406 L133_138 L140_145 0.1144
K5407 L133_138 L1_6 0.0307
K5408 L133_138 L72_77 0.0423
K5409 L133_138 L35_40 0.0625
K5410 L133_138 L73_78 0.059
K5411 L133_138 L6_11 0.0326
K5412 L133_138 L163_168 0.051
K5413 L133_138 L144_149 0.1439
K5414 L133_138 L130_160 0.0427
K5415 L133_138 L4_9 0.0248
K5416 L133_138 L202_206 0.059
K5417 L133_138 L109_114 0.0315
K5418 L133_138 L57_61 0.0344
K5419 L133_138 L164_169 0.0463
K5420 L133_138 L195_199 0.0257
K5421 L133_138 L106_111 0.0197
K5422 L133_138 L34_39 0.0699
K5423 L133_138 L201_205 0.0423
K5424 L133_138 L53_57 0.0328
K5425 L133_138 L69_73 0.0593
K5426 L133_138 L200_204 0.0329
K5427 L133_138 L150_155 0.0823
K5428 L133_138 L145_150 0.0985
K5429 L133_138 L30_35 0.0457
K5430 L133_138 L131_136 0.1011
K5431 L133_138 L101_105 0.0759
K5432 L133_138 L46_50 0.0196
K5433 L133_138 L196_200 0.0331
K5434 L133_138 L92_96 0.1438
K5435 L133_138 L81_86 0.0325
K5436 L133_138 L19_24 0.0304
K5437 L133_138 L120_125 0.0348
K5438 L133_138 L160_165 0.058
K5439 L133_138 L185_189 0.0285
K5440 L133_138 L60_64 0.031
K5441 L133_138 L198_202 0.0599
K5442 L133_138 L193_197 0.0427
K5443 L133_138 L168_173 0.0718
K5444 L133_138 L7_12 0.0265
K5445 L133_138 L137_142 0.1832
K5446 L133_138 L20_25 0.0249
K5447 L133_138 L121_126 0.0212
K5448 L133_138 L119_124 0.0345
K5449 L133_138 L97_101 0.088
K5450 L133_138 L110_115 0.0309
K5451 L133_138 L113_118 0.029
K5452 L133_138 L141_146 0.0939
K5453 L133_138 L182_186 0.0219
K5454 L133_138 L100_104 0.1015
K5455 L133_138 L166_171 0.098
K5456 L133_138 L9_14 0.0265
K5457 L133_138 L132_171 0.1879
K5458 L133_138 L134_139 0.2054
K5459 L133_138 L124_129 0.0362
K5460 L133_138 L107_112 0.0247
K5461 L133_138 L78_83 0.0581
K5462 L133_138 L112_117 0.0254
K5463 L133_138 L40_45 0.094
K5464 L133_138 L183_187 0.0285
K5465 L133_138 L136_141 0.0991
K5466 L133_138 L59_63 0.0267
K5467 L133_138 L5_10 0.0204
K5468 L133_138 L71_76 0.0329
K5469 L133_138 L15_20 0.0232
K5470 L133_138 L51_55 0.0253
K5471 L133_138 L58_62 0.0212
K5472 L133_138 L67_71 0.033
K5473 L133_138 L36_41 0.1381
K5474 L133_138 L48_52 0.0279
K5475 L133_138 L29_34 0.0503
K5476 L133_138 L179_183 0.0266
K5477 L133_138 L158_189 0.0306
K5478 L133_138 L206_210 0.0575
K5479 L133_138 L41_74 0.0958
K5480 L133_138 L131_170 0.1607
K5481 L133_138 L205_209 0.0418
K5482 L133_138 L191_195 0.0257
K5483 L133_138 L66_70 0.0256
K5484 L133_138 L98_102 0.1015
K5485 L133_138 L27_32 0.0619
K5486 L133_138 L142_147 0.1439
K5487 L133_138 L147_152 0.1124
K5488 L133_138 L178_182 0.0206
K5489 L133_138 L149_154 0.1124
K5490 L133_138 L203_207 0.0254
K5491 L133_138 L2_7 0.0248
K5492 L133_138 L117_122 0.0261
K5493 L133_138 L22_27 0.0459
K5494 L133_138 L47_51 0.0246
K5495 L133_138 L55_59 0.026
K5496 L133_138 L135_174 0.1
K5497 L133_138 L94_98 0.1226
K5498 L133_138 L52_56 0.0289
K5499 L133_138 L115_120 0.0327
K5500 L133_138 L80_85 0.0253
K5501 L133_138 L10_15 0.0218
K5502 L133_138 L16_21 0.0368
K5503 L133_138 L158_163 0.0394
K5504 L133_138 L96_100 0.1226
K5505 L133_138 L49_53 0.0314
K5506 L133_138 L186_190 0.0234
K5507 L133_138 L156_161 0.0465
K5508 L133_138 L82_87 0.0415
K5509 L133_138 L125_130 0.0371
K5510 L133_138 L108_113 0.028
K5511 L133_138 L159_164 0.036
K5512 L133_138 L84_89 0.0836
K5513 L133_138 L68_72 0.0424
K5514 L133_138 L169_174 0.0641
K5515 L133_138 L204_208 0.0327
K5516 L133_138 L37_42 0.1572
K5517 L133_138 L25_30 0.0357
K5518 L133_138 L32_37 0.093
K5519 L133_138 L14_19 0.0283
K5520 L133_138 L44_92 0.1536
K5521 L133_138 L161_166 0.0633
K5522 L133_138 L21_26 0.0422
K5523 L133_138 L116_121 0.0207
K5524 L133_138 L74_79 0.0941
K5525 L133_138 L165_170 0.0887
K5526 L133_138 L199_203 0.0256
K5527 L133_138 L75_80 0.0255
K5528 L133_138 L70_75 0.0256
K5529 L133_138 L50_54 0.0201
K5530 L133_138 L79_84 0.0897
K5531 L133_138 L56_60 0.0299
K5532 L133_138 L159_190 0.0251
K5533 L133_138 L93_97 0.0988
K5534 L133_138 L90_94 0.1438
K5535 L133_138 L134_173 0.1187
K5536 L133_138 L139_144 0.1832
K5537 L133_138 L83_88 0.0568
K5538 L133_138 L177_181 0.025
K5539 L133_138 L111_116 0.0202
K5540 L133_138 L122_127 0.0268
K5541 L133_138 L135_140 0.1216
K5542 L133_138 L39_44 0.1101
K5543 L133_138 L123_128 0.0311
K5544 L133_138 L12_17 0.0283
K5545 L133_138 L54_58 0.0207
K5546 L133_138 L146_151 0.0869
K5547 L133_138 L114_119 0.033
K5548 L133_138 L61_65 0.0361
K5549 L133_138 L11_16 0.0346
K5550 L133_138 L77_82 0.042
K5551 L60_61 L167_168 0.0649
K5552 L60_61 L74_90 0.0345
K5553 L60_61 L199_200 0.0439
K5554 L60_61 L115_179 0.0564
K5555 L60_61 L128_129 0.2623
K5556 L60_61 L147_148 0.0302
K5557 L60_61 L196_197 0.0504
K5558 L60_61 L95_96 0.0311
K5559 L60_61 L1_2 0.0471
K5560 L60_61 L23_24 0.0783
K5561 L60_61 L158_159 0.0694
K5562 L60_61 L136_198 0.0504
K5563 L60_61 L163_164 0.0706
K5564 L60_61 L144_145 0.0302
K5565 L60_61 L120_183 0.0579
K5566 L60_61 L91_92 0.0327
K5567 L60_61 L160_161 0.0918
K5568 L60_61 L151_152 0.0246
K5569 L60_61 L126_127 0.0911
K5570 L60_61 L22_23 0.0881
K5571 L60_61 L204_205 0.0448
K5572 L60_61 L153_154 0.0236
K5573 L60_61 L4_5 0.0364
K5574 L60_61 L34_35 0.0616
K5575 L60_61 L41_42 0.0457
K5576 L60_61 L197_198 0.052
K5577 L60_61 L143_144 0.031
K5578 L60_61 L200_201 0.0474
K5579 L60_61 L205_206 0.046
K5580 L60_61 L36_37 0.0598
K5581 L60_61 L131_132 0.0454
K5582 L60_61 L100_101 0.0289
K5583 L60_61 L203_204 0.0418
K5584 L60_61 L92_93 0.0317
K5585 L60_61 L81_82 0.045
K5586 L60_61 L13_14 0.0488
K5587 L60_61 L148_149 0.0295
K5588 L60_61 L165_166 0.0732
K5589 L60_61 L102_103 0.0242
K5590 L60_61 L106_107 0.0858
K5591 L60_61 L64_65 0.3407
K5592 L60_61 L133_134 0.0427
K5593 L60_61 L26_27 0.0939
K5594 L60_61 L107_108 0.1387
K5595 L60_61 L170_171 0.0592
K5596 L60_61 L193_194 0.051
K5597 L60_61 L63_64 0.1877
K5598 L60_61 L21_65 0.1877
K5599 L60_61 L119_120 0.1743
K5600 L60_61 L9_10 0.0442
K5601 L60_61 L46_47 0.0877
K5602 L60_61 L195_196 0.0461
K5603 L60_61 L67_68 0.0495
K5604 L60_61 L134_135 0.0413
K5605 L60_61 L41_69 0.0495
K5606 L60_61 L171_172 0.0569
K5607 L60_61 L104_105 0.0232
K5608 L60_61 L151_210 0.0401
K5609 L60_61 L79_94 0.0326
K5610 L60_61 L37_38 0.0574
K5611 L60_61 L75_76 0.0441
K5612 L60_61 L112_113 0.1537
K5613 L60_61 L183_184 0.0527
K5614 L60_61 L11_57 0.1933
K5615 L60_61 L38_39 0.0549
K5616 L60_61 L108_109 0.1866
K5617 L60_61 L71_72 0.0506
K5618 L60_61 L27_28 0.0853
K5619 L60_61 L78_79 0.0477
K5620 L60_61 L44_45 0.0415
K5621 L60_61 L47_48 0.1475
K5622 L60_61 L29_30 0.0715
K5623 L60_61 L76_77 0.0477
K5624 L60_61 L114_115 0.1537
K5625 L60_61 L166_167 0.069
K5626 L60_61 L185_186 0.0445
K5627 L60_61 L177_178 0.0361
K5628 L60_61 L191_192 0.0447
K5629 L60_61 L86_87 0.0403
K5630 L60_61 L118_119 0.2659
K5631 L60_61 L176_177 0.039
K5632 L60_61 L3_4 0.0394
K5633 L60_61 L6_53 0.1646
K5634 L60_61 L149_150 0.0288
K5635 L60_61 L2_3 0.0429
K5636 L60_61 L98_99 0.0303
K5637 L60_61 L55_56 0.1933
K5638 L60_61 L84_98 0.0309
K5639 L60_61 L48_49 0.2072
K5640 L60_61 L110_175 0.0464
K5641 L60_61 L113_114 0.2117
K5642 L60_61 L52_53 0.2392
K5643 L60_61 L80_81 0.0419
K5644 L60_61 L141_202 0.0474
K5645 L60_61 L87_88 0.0413
K5646 L60_61 L146_147 0.0308
K5647 L60_61 L209_210 0.0411
K5648 L60_61 L94_95 0.0319
K5649 L60_61 L136_137 0.0343
K5650 L60_61 L127_128 0.1674
K5651 L60_61 L138_139 0.0325
K5652 L60_61 L42_43 0.0443
K5653 L60_61 L181_182 0.0438
K5654 L60_61 L28_29 0.0779
K5655 L60_61 L157_158 0.0768
K5656 L60_61 L96_97 0.0303
K5657 L60_61 L66_67 0.045
K5658 L60_61 L129_130 0.1674
K5659 L60_61 L21_22 0.1004
K5660 L60_61 L117_118 0.1743
K5661 L60_61 L51_52 0.1646
K5662 L60_61 L56_57 0.3334
K5663 L60_61 L24_25 0.0705
K5664 L60_61 L116_117 0.0969
K5665 L60_61 L6_7 0.0573
K5666 L60_61 L173_174 0.0522
K5667 L60_61 L154_155 0.0231
K5668 L60_61 L32_33 0.0698
K5669 L60_61 L103_104 0.0237
K5670 L60_61 L85_86 0.0377
K5671 L60_61 L7_8 0.0521
K5672 L60_61 L82_83 0.0462
K5673 L60_61 L14_15 0.0449
K5674 L60_61 L184_185 0.0482
K5675 L60_61 L141_142 0.0325
K5676 L60_61 L62_63 0.0934
K5677 L60_61 L70_71 0.0464
K5678 L60_61 L68_69 0.0513
K5679 L60_61 L180_181 0.0474
K5680 L60_61 L89_102 0.0247
K5681 L60_61 L8_9 0.0478
K5682 L60_61 L50_51 0.0952
K5683 L60_61 L168_169 0.061
K5684 L60_61 L83_84 0.045
K5685 L60_61 L90_91 0.0336
K5686 L60_61 L139_140 0.0316
K5687 L60_61 L161_162 0.0838
K5688 L60_61 L111_112 0.0931
K5689 L60_61 L162_163 0.0767
K5690 L60_61 L137_138 0.0334
K5691 L60_61 L179_180 0.0515
K5692 L60_61 L12_13 0.0533
K5693 L60_61 L207_208 0.0376
K5694 L60_61 L142_143 0.0317
K5695 L60_61 L152_153 0.0241
K5696 L60_61 L39_40 0.0525
K5697 L60_61 L130_156 0.0972
K5698 L60_61 L156_157 0.0859
K5699 L60_61 L11_12 0.0589
K5700 L60_61 L54_55 0.0993
K5701 L60_61 L201_202 0.0488
K5702 L37_42 L24_29 0.0708
K5703 L37_42 L181_185 0.045
K5704 L37_42 L140_145 0.0842
K5705 L37_42 L1_6 0.0457
K5706 L37_42 L13_18 0.051
K5707 L37_42 L35_40 0.1278
K5708 L37_42 L23_28 0.073
K5709 L37_42 L73_78 0.0746
K5710 L37_42 L184_188 0.0503
K5711 L37_42 L6_11 0.0489
K5712 L37_42 L163_168 0.0976
K5713 L37_42 L91_95 0.1482
K5714 L37_42 L144_149 0.0989
K5715 L37_42 L130_160 0.0672
K5716 L37_42 L4_9 0.0419
K5717 L37_42 L202_206 0.07
K5718 L37_42 L109_114 0.0456
K5719 L37_42 L57_61 0.0509
K5720 L37_42 L164_169 0.0853
K5721 L37_42 L195_199 0.0334
K5722 L37_42 L106_111 0.0274
K5723 L37_42 L34_39 0.159
K5724 L37_42 L148_153 0.093
K5725 L37_42 L201_205 0.0531
K5726 L37_42 L53_57 0.0483
K5727 L37_42 L69_73 0.0781
K5728 L37_42 L200_204 0.0422
K5729 L37_42 L150_155 0.0666
K5730 L37_42 L145_150 0.075
K5731 L37_42 L30_35 0.0879
K5732 L37_42 L131_136 0.1107
K5733 L37_42 L101_105 0.0691
K5734 L37_42 L46_50 0.0275
K5735 L37_42 L196_200 0.0429
K5736 L37_42 L92_96 0.1233
K5737 L37_42 L81_86 0.0416
K5738 L37_42 L19_24 0.0548
K5739 L37_42 L120_125 0.0521
K5740 L37_42 L8_13 0.0465
K5741 L37_42 L60_64 0.0448
K5742 L37_42 L72_77 0.055
K5743 L37_42 L198_202 0.0736
K5744 L37_42 L193_197 0.0559
K5745 L37_42 L168_173 0.1463
K5746 L37_42 L20_25 0.0442
K5747 L37_42 L167_172 0.1706
K5748 L37_42 L121_126 0.0296
K5749 L37_42 L119_124 0.0506
K5750 L37_42 L97_101 0.0787
K5751 L37_42 L110_115 0.0454
K5752 L37_42 L113_118 0.0413
K5753 L37_42 L141_146 0.0891
K5754 L37_42 L182_186 0.0366
K5755 L37_42 L100_104 0.0898
K5756 L37_42 L9_14 0.0455
K5757 L37_42 L138_143 0.1319
K5758 L37_42 L33_38 0.1944
K5759 L37_42 L18_23 0.0565
K5760 L37_42 L134_139 0.1293
K5761 L37_42 L124_129 0.0534
K5762 L37_42 L107_112 0.0345
K5763 L37_42 L78_83 0.0709
K5764 L37_42 L112_117 0.0355
K5765 L37_42 L40_45 0.1566
K5766 L37_42 L136_141 0.0992
K5767 L37_42 L59_63 0.0377
K5768 L37_42 L5_10 0.0342
K5769 L37_42 L71_76 0.0431
K5770 L37_42 L15_20 0.0403
K5771 L37_42 L51_55 0.0357
K5772 L37_42 L58_62 0.0297
K5773 L37_42 L67_71 0.0438
K5774 L37_42 L36_41 0.3972
K5775 L37_42 L48_52 0.0399
K5776 L37_42 L29_34 0.101
K5777 L37_42 L206_210 0.0664
K5778 L37_42 L41_74 0.1156
K5779 L37_42 L131_170 0.2588
K5780 L37_42 L28_33 0.1081
K5781 L37_42 L205_209 0.0515
K5782 L37_42 L191_195 0.0339
K5783 L37_42 L178_182 0.0339
K5784 L37_42 L180_184 0.0459
K5785 L37_42 L3_8 0.0427
K5786 L37_42 L157_162 0.0717
K5787 L37_42 L149_154 0.086
K5788 L37_42 L203_207 0.0323
K5789 L37_42 L66_70 0.034
K5790 L37_42 L117_122 0.0366
K5791 L37_42 L114_119 0.048
K5792 L37_42 L158_189 0.054
K5793 L37_42 L38_43 0.2991
K5794 L37_42 L47_51 0.0346
K5795 L37_42 L55_59 0.0367
K5796 L37_42 L135_174 0.1436
K5797 L37_42 L160_165 0.0992
K5798 L37_42 L52_56 0.0415
K5799 L37_42 L115_120 0.0486
K5800 L37_42 L80_85 0.0325
K5801 L37_42 L10_15 0.037
K5802 L37_42 L16_21 0.0568
K5803 L37_42 L158_163 0.0696
K5804 L37_42 L185_189 0.0491
K5805 L37_42 L96_100 0.1049
K5806 L37_42 L49_53 0.0458
K5807 L37_42 L186_190 0.0398
K5808 L37_42 L82_87 0.0518
K5809 L37_42 L125_130 0.0562
K5810 L37_42 L108_113 0.0398
K5811 L37_42 L159_164 0.0625
K5812 L37_42 L84_89 0.082
K5813 L37_42 L68_72 0.0563
K5814 L37_42 L169_174 0.1202
K5815 L37_42 L204_208 0.0414
K5816 L37_42 L25_30 0.0635
K5817 L37_42 L133_172 0.2341
K5818 L37_42 L14_19 0.0498
K5819 L37_42 L44_92 0.1437
K5820 L37_42 L21_26 0.0685
K5821 L37_42 L95_99 0.1187
K5822 L37_42 L116_121 0.0289
K5823 L37_42 L74_79 0.1027
K5824 L37_42 L165_170 0.1747
K5825 L37_42 L199_203 0.0329
K5826 L37_42 L75_80 0.033
K5827 L37_42 L143_148 0.1101
K5828 L37_42 L70_75 0.0336
K5829 L37_42 L50_54 0.0282
K5830 L37_42 L79_84 0.0915
K5831 L37_42 L56_60 0.0432
K5832 L37_42 L159_190 0.0435
K5833 L37_42 L93_97 0.0895
K5834 L37_42 L134_173 0.1838
K5835 L37_42 L139_144 0.1139
K5836 L37_42 L83_88 0.0672
K5837 L37_42 L177_181 0.0415
K5838 L37_42 L111_116 0.0282
K5839 L37_42 L162_167 0.1038
K5840 L37_42 L43_91 0.1879
K5841 L37_42 L122_127 0.0376
K5842 L37_42 L135_140 0.093
K5843 L37_42 L39_44 0.2092
K5844 L37_42 L123_128 0.0446
K5845 L37_42 L54_58 0.029
K5846 L37_42 L146_151 0.0803
K5847 L37_42 L61_65 0.0537
K5848 L37_42 L11_16 0.0526
K5849 L37_42 L77_82 0.0534
K5850 L72_77 L181_185 0.027
K5851 L72_77 L140_145 0.0312
K5852 L72_77 L1_6 0.0377
K5853 L72_77 L13_18 0.029
K5854 L72_77 L35_40 0.0399
K5855 L72_77 L23_28 0.0385
K5856 L72_77 L73_78 0.1145
K5857 L72_77 L6_11 0.0393
K5858 L72_77 L163_168 0.0409
K5859 L72_77 L91_95 0.0427
K5860 L72_77 L144_149 0.0395
K5861 L72_77 L130_160 0.0377
K5862 L72_77 L4_9 0.0262
K5863 L72_77 L202_206 0.1104
K5864 L72_77 L109_114 0.0464
K5865 L72_77 L57_61 0.0515
K5866 L72_77 L164_169 0.0365
K5867 L72_77 L195_199 0.0802
K5868 L72_77 L106_111 0.0373
K5869 L72_77 L34_39 0.0449
K5870 L72_77 L148_153 0.042
K5871 L72_77 L204_208 0.1076
K5872 L72_77 L53_57 0.0489
K5873 L72_77 L69_73 0.1134
K5874 L72_77 L200_204 0.1104
K5875 L72_77 L150_155 0.031
K5876 L72_77 L145_150 0.0312
K5877 L72_77 L30_35 0.0367
K5878 L72_77 L131_136 0.0681
K5879 L72_77 L101_105 0.0312
K5880 L72_77 L46_50 0.0375
K5881 L72_77 L196_200 0.1114
K5882 L72_77 L92_96 0.0398
K5883 L72_77 L81_86 0.1103
K5884 L72_77 L19_24 0.029
K5885 L72_77 L120_125 0.0408
K5886 L72_77 L8_13 0.028
K5887 L72_77 L198_202 0.1114
K5888 L72_77 L168_173 0.0447
K5889 L72_77 L7_12 0.0288
K5890 L72_77 L137_142 0.0457
K5891 L72_77 L20_25 0.0234
K5892 L72_77 L167_172 0.0471
K5893 L72_77 L121_126 0.0431
K5894 L72_77 L119_124 0.0513
K5895 L72_77 L97_101 0.0313
K5896 L72_77 L110_115 0.0375
K5897 L72_77 L134_139 0.0395
K5898 L72_77 L141_146 0.0681
K5899 L72_77 L182_186 0.0219
K5900 L72_77 L100_104 0.0395
K5901 L72_77 L166_171 0.0498
K5902 L72_77 L9_14 0.0271
K5903 L72_77 L138_143 0.0424
K5904 L72_77 L33_38 0.0474
K5905 L72_77 L18_23 0.03
K5906 L72_77 L132_171 0.0546
K5907 L72_77 L124_129 0.054
K5908 L72_77 L107_112 0.0464
K5909 L72_77 L78_83 0.1134
K5910 L72_77 L112_117 0.0487
K5911 L72_77 L40_45 0.0427
K5912 L72_77 L183_187 0.0298
K5913 L72_77 L136_141 0.0684
K5914 L72_77 L59_63 0.0543
K5915 L72_77 L5_10 0.0213
K5916 L72_77 L71_76 0.1145
K5917 L72_77 L15_20 0.0227
K5918 L72_77 L51_55 0.0489
K5919 L72_77 L58_62 0.0433
K5920 L72_77 L67_71 0.1134
K5921 L72_77 L36_41 0.0534
K5922 L72_77 L29_34 0.041
K5923 L72_77 L179_183 0.0287
K5924 L72_77 L158_189 0.0289
K5925 L72_77 L206_210 0.1076
K5926 L72_77 L41_74 0.069
K5927 L72_77 L131_170 0.053
K5928 L72_77 L28_33 0.0429
K5929 L72_77 L191_195 0.0797
K5930 L72_77 L66_70 0.0812
K5931 L72_77 L98_102 0.0455
K5932 L72_77 L27_32 0.0448
K5933 L72_77 L142_147 0.0455
K5934 L72_77 L147_152 0.0451
K5935 L72_77 L178_182 0.0212
K5936 L72_77 L180_184 0.0279
K5937 L72_77 L3_8 0.027
K5938 L72_77 L157_162 0.0384
K5939 L72_77 L149_154 0.0392
K5940 L72_77 L203_207 0.0782
K5941 L72_77 L2_7 0.0278
K5942 L72_77 L117_122 0.0513
K5943 L72_77 L22_27 0.0399
K5944 L72_77 L38_43 0.0515
K5945 L72_77 L47_51 0.0466
K5946 L72_77 L55_59 0.0515
K5947 L72_77 L135_174 0.0425
K5948 L72_77 L94_98 0.0459
K5949 L72_77 L160_165 0.0426
K5950 L72_77 L115_120 0.0391
K5951 L72_77 L80_85 0.0796
K5952 L72_77 L10_15 0.0219
K5953 L72_77 L16_21 0.0428
K5954 L72_77 L158_163 0.0371
K5955 L72_77 L185_189 0.0279
K5956 L72_77 L96_100 0.0398
K5957 L72_77 L49_53 0.0466
K5958 L72_77 L186_190 0.0226
K5959 L72_77 L156_161 0.0398
K5960 L72_77 L125_130 0.0426
K5961 L72_77 L184_188 0.0289
K5962 L72_77 L159_164 0.0333
K5963 L72_77 L24_29 0.0372
K5964 L72_77 L169_174 0.0397
K5965 L72_77 L25_30 0.0334
K5966 L72_77 L32_37 0.0501
K5967 L72_77 L133_172 0.0511
K5968 L72_77 L14_19 0.028
K5969 L72_77 L44_92 0.0398
K5970 L72_77 L161_166 0.0446
K5971 L72_77 L21_26 0.0379
K5972 L72_77 L95_99 0.0426
K5973 L72_77 L84_89 0.0681
K5974 L72_77 L116_121 0.041
K5975 L72_77 L74_79 0.0692
K5976 L72_77 L165_170 0.0479
K5977 L72_77 L199_203 0.0797
K5978 L72_77 L75_80 0.0812
K5979 L72_77 L143_148 0.0423
K5980 L72_77 L70_75 0.0818
K5981 L72_77 L50_54 0.0393
K5982 L72_77 L79_84 0.069
K5983 L72_77 L159_190 0.0233
K5984 L72_77 L93_97 0.0314
K5985 L72_77 L90_94 0.0461
K5986 L72_77 L134_173 0.0481
K5987 L72_77 L139_144 0.0396
K5988 L72_77 L83_88 0.1103
K5989 L72_77 L177_181 0.0261
K5990 L72_77 L111_116 0.0391
K5991 L72_77 L162_167 0.0427
K5992 L72_77 L43_91 0.0426
K5993 L72_77 L122_127 0.054
K5994 L72_77 L135_140 0.0312
K5995 L72_77 L39_44 0.0484
K5996 L72_77 L12_17 0.03
K5997 L72_77 L54_58 0.0412
K5998 L72_77 L146_151 0.0673
K5999 L72_77 L114_119 0.0487
K6000 L72_77 L61_65 0.0543
K6001 L72_77 L11_16 0.041
K6002 L133_134 L167_168 0.0788
K6003 L133_134 L74_90 0.1128
K6004 L133_134 L199_200 0.0343
K6005 L133_134 L115_179 0.0313
K6006 L133_134 L128_129 0.0428
K6007 L133_134 L196_197 0.0433
K6008 L133_134 L1_2 0.0254
K6009 L133_134 L23_24 0.0454
K6010 L133_134 L158_159 0.0457
K6011 L133_134 L136_198 0.0838
K6012 L133_134 L163_164 0.0577
K6013 L133_134 L144_145 0.1076
K6014 L133_134 L120_183 0.0334
K6015 L133_134 L91_92 0.1276
K6016 L133_134 L160_161 0.057
K6017 L133_134 L151_152 0.0621
K6018 L133_134 L126_127 0.0311
K6019 L133_134 L22_23 0.0453
K6020 L133_134 L153_154 0.0652
K6021 L133_134 L4_5 0.0255
K6022 L133_134 L34_35 0.0767
K6023 L133_134 L197_198 0.0574
K6024 L133_134 L204_205 0.0418
K6025 L133_134 L143_144 0.1104
K6026 L133_134 L200_201 0.0426
K6027 L133_134 L205_206 0.054
K6028 L133_134 L36_37 0.1106
K6029 L133_134 L141_142 0.1004
K6030 L133_134 L100_101 0.0844
K6031 L133_134 L203_204 0.0339
K6032 L133_134 L92_93 0.1234
K6033 L133_134 L81_82 0.0415
K6034 L133_134 L13_14 0.0335
K6035 L133_134 L185_186 0.0337
K6036 L133_134 L148_149 0.0898
K6037 L133_134 L19_20 0.0359
K6038 L133_134 L187_188 0.0362
K6039 L133_134 L165_166 0.0766
K6040 L133_134 L102_103 0.0622
K6041 L133_134 L106_107 0.028
K6042 L133_134 L64_65 0.0425
K6043 L133_134 L8_9 0.0314
K6044 L133_134 L107_108 0.0317
K6045 L133_134 L170_171 0.1157
K6046 L133_134 L63_64 0.0363
K6047 L133_134 L21_65 0.0484
K6048 L133_134 L121_122 0.0321
K6049 L133_134 L119_120 0.045
K6050 L133_134 L9_10 0.0313
K6051 L133_134 L46_47 0.0279
K6052 L133_134 L195_196 0.0346
K6053 L133_134 L171_172 0.122
K6054 L133_134 L104_105 0.0622
K6055 L133_134 L151_210 0.0657
K6056 L133_134 L79_94 0.0947
K6057 L133_134 L37_38 0.116
K6058 L133_134 L75_76 0.0342
K6059 L133_134 L112_113 0.0344
K6060 L133_134 L183_184 0.0337
K6061 L133_134 L59_60 0.0371
K6062 L133_134 L11_57 0.0448
K6063 L133_134 L38_39 0.118
K6064 L133_134 L108_109 0.0356
K6065 L133_134 L71_72 0.043
K6066 L133_134 L27_28 0.057
K6067 L133_134 L96_97 0.1006
K6068 L133_134 L78_79 0.0776
K6069 L133_134 L138_139 0.1436
K6070 L133_134 L47_48 0.0316
K6071 L133_134 L29_30 0.057
K6072 L133_134 L76_77 0.0423
K6073 L133_134 L114_115 0.0424
K6074 L133_134 L166_167 0.0782
K6075 L133_134 L177_178 0.0257
K6076 L133_134 L16_17 0.0356
K6077 L133_134 L188_189 0.0363
K6078 L133_134 L86_87 0.0381
K6079 L133_134 L118_119 0.0407
K6080 L133_134 L176_177 0.0257
K6081 L133_134 L3_4 0.0256
K6082 L133_134 L6_53 0.0421
K6083 L133_134 L149_150 0.0883
K6084 L133_134 L2_3 0.0255
K6085 L133_134 L98_99 0.0844
K6086 L133_134 L55_56 0.0356
K6087 L133_134 L184_185 0.0338
K6088 L133_134 L84_98 0.0808
K6089 L133_134 L48_49 0.0355
K6090 L133_134 L110_175 0.0255
K6091 L133_134 L124_125 0.0481
K6092 L133_134 L113_114 0.0387
K6093 L133_134 L52_53 0.0385
K6094 L133_134 L80_81 0.0337
K6095 L133_134 L17_18 0.0359
K6096 L133_134 L141_202 0.0791
K6097 L133_134 L87_88 0.0486
K6098 L133_134 L146_147 0.0842
K6099 L133_134 L209_210 0.049
K6100 L133_134 L94_95 0.1006
K6101 L133_134 L127_128 0.0365
K6102 L133_134 L181_182 0.0315
K6103 L133_134 L28_29 0.0572
K6104 L133_134 L157_158 0.0458
K6105 L133_134 L122_123 0.0372
K6106 L133_134 L103_104 0.0629
K6107 L133_134 L129_130 0.0488
K6108 L133_134 L21_22 0.0449
K6109 L133_134 L117_118 0.0358
K6110 L133_134 L51_52 0.0343
K6111 L133_134 L56_57 0.0405
K6112 L133_134 L24_25 0.0453
K6113 L133_134 L116_117 0.0312
K6114 L133_134 L6_7 0.0311
K6115 L133_134 L173_174 0.122
K6116 L133_134 L154_155 0.0644
K6117 L133_134 L32_33 0.0767
K6118 L133_134 L95_96 0.1029
K6119 L133_134 L85_86 0.0311
K6120 L133_134 L7_8 0.0313
K6121 L133_134 L82_83 0.0535
K6122 L133_134 L14_15 0.0335
K6123 L133_134 L147_148 0.0883
K6124 L133_134 L62_63 0.031
K6125 L133_134 L125_187 0.0359
K6126 L133_134 L58_59 0.032
K6127 L133_134 L70_71 0.0345
K6128 L133_134 L136_137 0.1231
K6129 L133_134 L180_181 0.0316
K6130 L133_134 L89_102 0.06
K6131 L133_134 L26_27 0.0564
K6132 L133_134 L50_51 0.0302
K6133 L133_134 L168_169 0.0782
K6134 L133_134 L83_84 0.0729
K6135 L133_134 L90_91 0.1234
K6136 L133_134 L139_140 0.1375
K6137 L133_134 L161_162 0.0577
K6138 L133_134 L111_112 0.0303
K6139 L133_134 L162_163 0.0579
K6140 L133_134 L137_138 0.1375
K6141 L133_134 L179_180 0.0315
K6142 L133_134 L12_13 0.0335
K6143 L133_134 L207_208 0.0312
K6144 L133_134 L142_143 0.1076
K6145 L133_134 L123_124 0.0429
K6146 L133_134 L152_153 0.0644
K6147 L133_134 L39_40 0.116
K6148 L133_134 L18_19 0.036
K6149 L133_134 L130_156 0.0453
K6150 L133_134 L156_157 0.0457
K6151 L133_134 L189_190 0.0362
K6152 L133_134 L11_12 0.0332
K6153 L133_134 L54_55 0.0311
K6154 L133_134 L201_202 0.0558
K6155 L107_108 L167_168 0.044
K6156 L107_108 L74_90 0.0259
K6157 L107_108 L199_200 0.0393
K6158 L107_108 L115_179 0.0503
K6159 L107_108 L128_129 0.123
K6160 L107_108 L147_148 0.0234
K6161 L107_108 L196_197 0.0425
K6162 L107_108 L13_14 0.0413
K6163 L107_108 L23_24 0.0476
K6164 L107_108 L158_159 0.0448
K6165 L107_108 L136_198 0.0386
K6166 L107_108 L163_164 0.0465
K6167 L107_108 L144_145 0.0232
K6168 L107_108 L120_183 0.0495
K6169 L107_108 L91_92 0.0246
K6170 L107_108 L151_152 0.0193
K6171 L107_108 L126_127 0.123
K6172 L107_108 L22_23 0.0511
K6173 L107_108 L204_205 0.0381
K6174 L107_108 L153_154 0.0185
K6175 L107_108 L34_35 0.0418
K6176 L107_108 L41_42 0.0336
K6177 L107_108 L197_198 0.0414
K6178 L107_108 L143_144 0.0238
K6179 L107_108 L200_201 0.0402
K6180 L107_108 L205_206 0.0373
K6181 L107_108 L36_37 0.0419
K6182 L107_108 L131_132 0.0337
K6183 L107_108 L100_101 0.0223
K6184 L107_108 L203_204 0.0373
K6185 L107_108 L92_93 0.0239
K6186 L107_108 L81_82 0.038
K6187 L107_108 L148_149 0.0229
K6188 L107_108 L19_20 0.0378
K6189 L107_108 L187_188 0.0444
K6190 L107_108 L102_103 0.0188
K6191 L107_108 L160_161 0.0559
K6192 L107_108 L64_65 0.1173
K6193 L107_108 L26_27 0.0554
K6194 L107_108 L165_166 0.0485
K6195 L107_108 L170_171 0.0421
K6196 L107_108 L193_194 0.0403
K6197 L107_108 L63_64 0.1492
K6198 L107_108 L21_65 0.077
K6199 L107_108 L121_122 0.1475
K6200 L107_108 L119_120 0.0917
K6201 L107_108 L9_10 0.0387
K6202 L107_108 L195_196 0.0414
K6203 L107_108 L67_68 0.0412
K6204 L107_108 L134_135 0.0308
K6205 L107_108 L41_69 0.0372
K6206 L107_108 L171_172 0.0405
K6207 L107_108 L104_105 0.018
K6208 L107_108 L151_210 0.0318
K6209 L107_108 L79_94 0.0249
K6210 L107_108 L37_38 0.0404
K6211 L107_108 L75_76 0.0391
K6212 L107_108 L112_113 0.4331
K6213 L107_108 L183_184 0.0453
K6214 L107_108 L59_60 0.1866
K6215 L107_108 L11_57 0.0896
K6216 L107_108 L38_39 0.0389
K6217 L107_108 L71_72 0.0423
K6218 L107_108 L27_28 0.0521
K6219 L107_108 L96_97 0.0231
K6220 L107_108 L78_79 0.0367
K6221 L107_108 L44_45 0.0307
K6222 L107_108 L29_30 0.0462
K6223 L107_108 L76_77 0.04
K6224 L107_108 L114_115 0.0947
K6225 L107_108 L166_167 0.0462
K6226 L107_108 L185_186 0.0387
K6227 L107_108 L16_17 0.0477
K6228 L107_108 L188_189 0.041
K6229 L107_108 L86_87 0.0341
K6230 L107_108 L118_119 0.1727
K6231 L107_108 L180_181 0.0422
K6232 L107_108 L6_53 0.0923
K6233 L107_108 L149_150 0.0224
K6234 L107_108 L98_99 0.0234
K6235 L107_108 L55_56 0.2334
K6236 L107_108 L84_98 0.0239
K6237 L107_108 L124_125 0.0877
K6238 L107_108 L113_114 0.2045
K6239 L107_108 L52_53 0.1765
K6240 L107_108 L80_81 0.0372
K6241 L107_108 L17_18 0.0439
K6242 L107_108 L141_202 0.0369
K6243 L107_108 L87_88 0.0334
K6244 L107_108 L146_147 0.024
K6245 L107_108 L209_210 0.0335
K6246 L107_108 L94_95 0.0243
K6247 L107_108 L136_137 0.026
K6248 L107_108 L127_128 0.1605
K6249 L107_108 L138_139 0.0247
K6250 L107_108 L42_43 0.0326
K6251 L107_108 L181_182 0.0391
K6252 L107_108 L28_29 0.049
K6253 L107_108 L157_158 0.048
K6254 L107_108 L122_123 0.2072
K6255 L107_108 L103_104 0.0184
K6256 L107_108 L66_67 0.0401
K6257 L107_108 L129_130 0.0785
K6258 L107_108 L21_22 0.0552
K6259 L107_108 L117_118 0.2809
K6260 L107_108 L51_52 0.2931
K6261 L107_108 L56_57 0.1576
K6262 L107_108 L24_25 0.0445
K6263 L107_108 L116_117 0.1727
K6264 L107_108 L6_7 0.0496
K6265 L107_108 L173_174 0.0376
K6266 L107_108 L154_155 0.018
K6267 L107_108 L32_33 0.0459
K6268 L107_108 L95_96 0.0237
K6269 L107_108 L85_86 0.0334
K6270 L107_108 L7_8 0.0454
K6271 L107_108 L82_83 0.0372
K6272 L107_108 L14_15 0.0384
K6273 L107_108 L184_185 0.0417
K6274 L107_108 L141_142 0.025
K6275 L107_108 L62_63 0.1173
K6276 L107_108 L125_187 0.0483
K6277 L107_108 L58_59 0.1387
K6278 L107_108 L70_71 0.0412
K6279 L107_108 L68_69 0.0401
K6280 L107_108 L89_102 0.0192
K6281 L107_108 L8_9 0.0418
K6282 L107_108 L50_51 0.1765
K6283 L107_108 L168_169 0.042
K6284 L107_108 L83_84 0.0351
K6285 L107_108 L90_91 0.0253
K6286 L107_108 L139_140 0.024
K6287 L107_108 L161_162 0.0525
K6288 L107_108 L111_112 0.2045
K6289 L107_108 L162_163 0.0493
K6290 L107_108 L137_138 0.0254
K6291 L107_108 L179_180 0.0459
K6292 L107_108 L12_13 0.0448
K6293 L107_108 L207_208 0.0335
K6294 L107_108 L142_143 0.0244
K6295 L107_108 L123_124 0.1475
K6296 L107_108 L152_153 0.0189
K6297 L107_108 L191_192 0.0403
K6298 L107_108 L39_40 0.0375
K6299 L107_108 L18_19 0.0406
K6300 L107_108 L130_156 0.0558
K6301 L107_108 L156_157 0.0516
K6302 L107_108 L189_190 0.0381
K6303 L107_108 L11_12 0.0489
K6304 L107_108 L54_55 0.1576
K6305 L107_108 L201_202 0.0393
K6306 L63_64 L167_168 0.0498
K6307 L63_64 L74_90 0.0304
K6308 L63_64 L115_179 0.0375
K6309 L63_64 L196_197 0.0528
K6310 L63_64 L1_2 0.0311
K6311 L63_64 L102_103 0.0216
K6312 L63_64 L136_198 0.0459
K6313 L63_64 L163_164 0.0506
K6314 L63_64 L144_145 0.0262
K6315 L63_64 L120_183 0.0381
K6316 L63_64 L91_92 0.0283
K6317 L63_64 L160_161 0.0634
K6318 L63_64 L151_152 0.0222
K6319 L63_64 L146_147 0.0277
K6320 L63_64 L204_205 0.0462
K6321 L63_64 L153_154 0.021
K6322 L63_64 L4_5 0.0258
K6323 L63_64 L34_35 0.0472
K6324 L63_64 L41_42 0.0396
K6325 L63_64 L46_47 0.123
K6326 L63_64 L197_198 0.0508
K6327 L63_64 L143_144 0.0271
K6328 L63_64 L200_201 0.0493
K6329 L63_64 L205_206 0.0449
K6330 L63_64 L36_37 0.0497
K6331 L63_64 L131_132 0.0394
K6332 L63_64 L100_101 0.0253
K6333 L63_64 L203_204 0.0449
K6334 L63_64 L92_93 0.0273
K6335 L63_64 L81_82 0.0465
K6336 L63_64 L13_14 0.0336
K6337 L63_64 L148_149 0.0261
K6338 L63_64 L19_20 0.0318
K6339 L63_64 L187_188 0.036
K6340 L63_64 L165_166 0.0567
K6341 L63_64 L106_107 0.1173
K6342 L63_64 L8_9 0.0331
K6343 L63_64 L170_171 0.0494
K6344 L63_64 L193_194 0.0498
K6345 L63_64 L141_142 0.0289
K6346 L63_64 L121_122 0.1674
K6347 L63_64 L119_120 0.0878
K6348 L63_64 L108_109 0.1173
K6349 L63_64 L195_196 0.0508
K6350 L63_64 L67_68 0.0524
K6351 L63_64 L134_135 0.0349
K6352 L63_64 L41_69 0.0449
K6353 L63_64 L171_172 0.0469
K6354 L63_64 L104_105 0.0204
K6355 L63_64 L151_210 0.0372
K6356 L63_64 L79_94 0.029
K6357 L63_64 L37_38 0.0472
K6358 L63_64 L75_76 0.0479
K6359 L63_64 L112_113 0.1684
K6360 L63_64 L183_184 0.0356
K6361 L63_64 L59_60 0.3407
K6362 L63_64 L11_57 0.0898
K6363 L63_64 L38_39 0.0449
K6364 L63_64 L71_72 0.0532
K6365 L63_64 L27_28 0.0591
K6366 L63_64 L96_97 0.0263
K6367 L63_64 L78_79 0.0438
K6368 L63_64 L44_45 0.035
K6369 L63_64 L47_48 0.1605
K6370 L63_64 L29_30 0.0509
K6371 L63_64 L76_77 0.0496
K6372 L63_64 L166_167 0.0531
K6373 L63_64 L185_186 0.0314
K6374 L63_64 L177_178 0.0256
K6375 L63_64 L16_17 0.0389
K6376 L63_64 L188_189 0.0337
K6377 L63_64 L86_87 0.0414
K6378 L63_64 L118_119 0.1479
K6379 L63_64 L176_177 0.0272
K6380 L63_64 L3_4 0.0273
K6381 L63_64 L6_53 0.0854
K6382 L63_64 L149_150 0.0253
K6383 L63_64 L2_3 0.0291
K6384 L63_64 L98_99 0.027
K6385 L63_64 L55_56 0.2387
K6386 L63_64 L184_185 0.0334
K6387 L63_64 L84_98 0.0278
K6388 L63_64 L48_49 0.123
K6389 L63_64 L110_175 0.0309
K6390 L63_64 L124_125 0.0911
K6391 L63_64 L113_114 0.13
K6392 L63_64 L52_53 0.1369
K6393 L63_64 L80_81 0.0451
K6394 L63_64 L17_18 0.0362
K6395 L63_64 L141_202 0.0436
K6396 L63_64 L87_88 0.0403
K6397 L63_64 L209_210 0.0401
K6398 L63_64 L94_95 0.0281
K6399 L63_64 L136_137 0.0302
K6400 L63_64 L138_139 0.0282
K6401 L63_64 L42_43 0.038
K6402 L63_64 L181_182 0.031
K6403 L63_64 L28_29 0.0547
K6404 L63_64 L122_123 0.2623
K6405 L63_64 L103_104 0.021
K6406 L63_64 L66_67 0.0502
K6407 L63_64 L9_10 0.0312
K6408 L63_64 L117_118 0.2081
K6409 L63_64 L51_52 0.1829
K6410 L63_64 L56_57 0.1593
K6411 L63_64 L114_115 0.0837
K6412 L63_64 L116_117 0.1479
K6413 L63_64 L6_7 0.0377
K6414 L63_64 L173_174 0.0425
K6415 L63_64 L154_155 0.0204
K6416 L63_64 L32_33 0.0535
K6417 L63_64 L95_96 0.0272
K6418 L63_64 L85_86 0.0403
K6419 L63_64 L7_8 0.0353
K6420 L63_64 L82_83 0.0451
K6421 L63_64 L14_15 0.0316
K6422 L63_64 L147_148 0.0269
K6423 L63_64 L199_200 0.0477
K6424 L63_64 L125_187 0.0386
K6425 L63_64 L58_59 0.1877
K6426 L63_64 L70_71 0.0512
K6427 L63_64 L68_69 0.0502
K6428 L63_64 L180_181 0.0329
K6429 L63_64 L89_102 0.0223
K6430 L63_64 L26_27 0.0642
K6431 L63_64 L50_51 0.1369
K6432 L63_64 L168_169 0.0469
K6433 L63_64 L83_84 0.0416
K6434 L63_64 L90_91 0.0293
K6435 L63_64 L139_140 0.0272
K6436 L63_64 L161_162 0.0585
K6437 L63_64 L111_112 0.13
K6438 L63_64 L162_163 0.0543
K6439 L63_64 L137_138 0.0292
K6440 L63_64 L179_180 0.0351
K6441 L63_64 L12_13 0.0358
K6442 L63_64 L207_208 0.0401
K6443 L63_64 L142_143 0.028
K6444 L63_64 L123_124 0.1674
K6445 L63_64 L152_153 0.0216
K6446 L63_64 L191_192 0.0498
K6447 L63_64 L39_40 0.0428
K6448 L63_64 L18_19 0.0339
K6449 L63_64 L189_190 0.0317
K6450 L63_64 L11_12 0.0384
K6451 L63_64 L54_55 0.1593
K6452 L63_64 L201_202 0.0477
K6453 L168_173 L140_145 0.0697
K6454 L168_173 L1_6 0.0524
K6455 L168_173 L13_18 0.0555
K6456 L168_173 L35_40 0.2296
K6457 L168_173 L23_28 0.1038
K6458 L168_173 L73_78 0.0558
K6459 L168_173 L184_188 0.0565
K6460 L168_173 L6_11 0.0562
K6461 L168_173 L91_95 0.0619
K6462 L168_173 L130_160 0.0915
K6463 L168_173 L22_27 0.0976
K6464 L168_173 L202_206 0.0538
K6465 L168_173 L109_114 0.0491
K6466 L168_173 L57_61 0.0534
K6467 L168_173 L164_169 0.189
K6468 L168_173 L195_199 0.0291
K6469 L168_173 L106_111 0.0275
K6470 L168_173 L148_153 0.051
K6471 L168_173 L201_205 0.0437
K6472 L168_173 L53_57 0.0511
K6473 L168_173 L69_73 0.0582
K6474 L168_173 L200_204 0.0363
K6475 L168_173 L150_155 0.0528
K6476 L168_173 L145_150 0.0601
K6477 L168_173 L30_35 0.1634
K6478 L168_173 L131_136 0.0714
K6479 L168_173 L101_105 0.0517
K6480 L168_173 L46_50 0.0274
K6481 L168_173 L196_200 0.037
K6482 L168_173 L81_86 0.0354
K6483 L168_173 L120_125 0.0611
K6484 L168_173 L8_13 0.0503
K6485 L168_173 L60_64 0.0447
K6486 L168_173 L198_202 0.0562
K6487 L168_173 L193_197 0.0462
K6488 L168_173 L7_12 0.0491
K6489 L168_173 L137_142 0.061
K6490 L168_173 L20_25 0.0671
K6491 L168_173 L167_172 0.2991
K6492 L168_173 L121_126 0.0291
K6493 L168_173 L119_124 0.0538
K6494 L168_173 L97_101 0.0584
K6495 L168_173 L110_115 0.0529
K6496 L168_173 L141_146 0.0611
K6497 L168_173 L182_186 0.0528
K6498 L168_173 L166_171 0.2092
K6499 L168_173 L122_127 0.037
K6500 L168_173 L138_143 0.0633
K6501 L168_173 L33_38 0.2341
K6502 L168_173 L18_23 0.0619
K6503 L168_173 L132_171 0.159
K6504 L168_173 L124_129 0.0562
K6505 L168_173 L107_112 0.0348
K6506 L168_173 L78_83 0.0534
K6507 L168_173 L112_117 0.0356
K6508 L168_173 L40_45 0.1634
K6509 L168_173 L183_187 0.0548
K6510 L168_173 L136_141 0.066
K6511 L168_173 L59_63 0.0369
K6512 L168_173 L5_10 0.0463
K6513 L168_173 L71_76 0.0369
K6514 L168_173 L15_20 0.0584
K6515 L168_173 L51_55 0.0354
K6516 L168_173 L58_62 0.029
K6517 L168_173 L67_71 0.0376
K6518 L168_173 L36_41 0.1298
K6519 L168_173 L48_52 0.0409
K6520 L168_173 L179_183 0.0498
K6521 L168_173 L206_210 0.0514
K6522 L168_173 L41_74 0.0703
K6523 L168_173 L131_170 0.1398
K6524 L168_173 L28_33 0.1706
K6525 L168_173 L205_209 0.0424
K6526 L168_173 L191_195 0.0296
K6527 L168_173 L2_7 0.045
K6528 L168_173 L98_102 0.0491
K6529 L168_173 L27_32 0.1463
K6530 L168_173 L147_152 0.0498
K6531 L168_173 L178_182 0.0471
K6532 L168_173 L180_184 0.051
K6533 L168_173 L3_8 0.0459
K6534 L168_173 L157_162 0.1081
K6535 L168_173 L203_207 0.028
K6536 L168_173 L66_70 0.0295
K6537 L168_173 L117_122 0.0363
K6538 L168_173 L114_119 0.0514
K6539 L168_173 L38_43 0.1706
K6540 L168_173 L47_51 0.0347
K6541 L168_173 L55_59 0.0362
K6542 L168_173 L135_174 0.189
K6543 L168_173 L94_98 0.054
K6544 L168_173 L160_165 0.1398
K6545 L168_173 L52_56 0.0422
K6546 L168_173 L115_120 0.0568
K6547 L168_173 L80_85 0.028
K6548 L168_173 L10_15 0.0517
K6549 L168_173 L16_21 0.0651
K6550 L168_173 L113_118 0.0424
K6551 L168_173 L49_53 0.0488
K6552 L168_173 L186_190 0.0601
K6553 L168_173 L156_161 0.101
K6554 L168_173 L125_130 0.066
K6555 L168_173 L108_113 0.041
K6556 L168_173 L159_164 0.1013
K6557 L168_173 L84_89 0.0562
K6558 L168_173 L68_72 0.0459
K6559 L168_173 L169_174 0.305
K6560 L168_173 L204_208 0.0356
K6561 L168_173 L25_30 0.0972
K6562 L168_173 L32_37 0.1838
K6563 L168_173 L133_172 0.1944
K6564 L168_173 L82_87 0.0422
K6565 L168_173 L161_166 0.159
K6566 L168_173 L21_26 0.0885
K6567 L168_173 L95_99 0.0555
K6568 L168_173 L116_121 0.0286
K6569 L168_173 L74_79 0.0651
K6570 L168_173 L165_170 0.1786
K6571 L168_173 L199_203 0.0286
K6572 L168_173 L75_80 0.0285
K6573 L168_173 L143_148 0.0565
K6574 L168_173 L70_75 0.029
K6575 L168_173 L50_54 0.028
K6576 L168_173 L79_84 0.0604
K6577 L168_173 L56_60 0.0435
K6578 L168_173 L159_190 0.0697
K6579 L168_173 L93_97 0.0671
K6580 L168_173 L90_94 0.0598
K6581 L168_173 L83_88 0.0511
K6582 L168_173 L111_116 0.028
K6583 L168_173 L162_167 0.1944
K6584 L168_173 L43_91 0.0699
K6585 L168_173 L142_147 0.0548
K6586 L168_173 L135_140 0.0827
K6587 L168_173 L123_128 0.0449
K6588 L168_173 L12_17 0.054
K6589 L168_173 L54_58 0.0285
K6590 L168_173 L146_151 0.0568
K6591 L168_173 L61_65 0.0558
K6592 L168_173 L11_16 0.0604
K6593 L168_173 L77_82 0.0435
K6594 L20_25 L24_29 0.2249
K6595 L20_25 L181_185 0.1062
K6596 L20_25 L1_6 0.057
K6597 L20_25 L13_18 0.1144
K6598 L20_25 L23_28 0.1498
K6599 L20_25 L73_78 0.0269
K6600 L20_25 L184_188 0.0988
K6601 L20_25 L6_11 0.0597
K6602 L20_25 L163_168 0.1131
K6603 L20_25 L91_95 0.0234
K6604 L20_25 L144_149 0.022
K6605 L20_25 L130_160 0.0893
K6606 L20_25 L4_9 0.0968
K6607 L20_25 L109_114 0.0405
K6608 L20_25 L57_61 0.0421
K6609 L20_25 L195_199 0.0161
K6610 L20_25 L106_111 0.0193
K6611 L20_25 L34_39 0.0697
K6612 L20_25 L148_153 0.0204
K6613 L20_25 L201_205 0.0226
K6614 L20_25 L53_57 0.0417
K6615 L20_25 L69_73 0.0281
K6616 L20_25 L200_204 0.0198
K6617 L20_25 L131_136 0.029
K6618 L20_25 L100_104 0.0207
K6619 L20_25 L46_50 0.0193
K6620 L20_25 L196_200 0.0203
K6621 L20_25 L92_96 0.0237
K6622 L20_25 L81_86 0.0194
K6623 L20_25 L19_24 0.1916
K6624 L20_25 L120_125 0.0598
K6625 L20_25 L8_13 0.0985
K6626 L20_25 L60_64 0.0314
K6627 L20_25 L198_202 0.0268
K6628 L20_25 L193_197 0.0241
K6629 L20_25 L7_12 0.0787
K6630 L20_25 L137_142 0.0229
K6631 L20_25 L143_148 0.0218
K6632 L20_25 L167_172 0.0635
K6633 L20_25 L121_126 0.0195
K6634 L20_25 L119_124 0.0417
K6635 L20_25 L110_115 0.0556
K6636 L20_25 L113_118 0.031
K6637 L20_25 L134_139 0.0252
K6638 L20_25 L141_146 0.0259
K6639 L20_25 L166_171 0.0593
K6640 L20_25 L9_14 0.1268
K6641 L20_25 L138_143 0.0232
K6642 L20_25 L33_38 0.0657
K6643 L20_25 L18_23 0.1216
K6644 L20_25 L132_171 0.0435
K6645 L20_25 L124_129 0.0418
K6646 L20_25 L107_112 0.0246
K6647 L20_25 L78_83 0.0258
K6648 L20_25 L112_117 0.0248
K6649 L20_25 L183_187 0.0789
K6650 L20_25 L136_141 0.0274
K6651 L20_25 L59_63 0.025
K6652 L20_25 L71_76 0.0204
K6653 L20_25 L51_55 0.0249
K6654 L20_25 L58_62 0.0195
K6655 L20_25 L67_71 0.0208
K6656 L20_25 L36_41 0.0404
K6657 L20_25 L48_52 0.0308
K6658 L20_25 L29_34 0.1284
K6659 L20_25 L179_183 0.073
K6660 L20_25 L206_210 0.0247
K6661 L20_25 L41_74 0.0292
K6662 L20_25 L131_170 0.0398
K6663 L20_25 L28_33 0.1068
K6664 L20_25 L205_209 0.0219
K6665 L20_25 L191_195 0.0165
K6666 L20_25 L66_70 0.0165
K6667 L20_25 L98_102 0.0203
K6668 L20_25 L27_32 0.0895
K6669 L20_25 L142_147 0.0215
K6670 L20_25 L147_152 0.0202
K6671 L20_25 L180_184 0.088
K6672 L20_25 L3_8 0.0823
K6673 L20_25 L157_162 0.1286
K6674 L20_25 L149_154 0.0206
K6675 L20_25 L203_207 0.0154
K6676 L20_25 L2_7 0.0696
K6677 L20_25 L117_122 0.0249
K6678 L20_25 L22_27 0.1117
K6679 L20_25 L158_189 0.1363
K6680 L20_25 L38_43 0.0458
K6681 L20_25 L47_51 0.0247
K6682 L20_25 L108_113 0.0307
K6683 L20_25 L94_98 0.0216
K6684 L20_25 L160_165 0.0748
K6685 L20_25 L52_56 0.0312
K6686 L20_25 L115_120 0.0581
K6687 L20_25 L80_85 0.0155
K6688 L20_25 L16_21 0.0622
K6689 L20_25 L158_163 0.1665
K6690 L20_25 L185_189 0.1266
K6691 L20_25 L96_100 0.0221
K6692 L20_25 L49_53 0.0409
K6693 L20_25 L156_161 0.1021
K6694 L20_25 L82_87 0.0219
K6695 L20_25 L125_130 0.0604
K6696 L20_25 L55_59 0.025
K6697 L20_25 L84_89 0.0247
K6698 L20_25 L68_72 0.0241
K6699 L20_25 L204_208 0.0193
K6700 L20_25 L202_206 0.0257
K6701 L20_25 L32_37 0.061
K6702 L20_25 L133_172 0.0451
K6703 L20_25 L14_19 0.1673
K6704 L20_25 L44_92 0.0254
K6705 L20_25 L161_166 0.0842
K6706 L20_25 L21_26 0.0966
K6707 L20_25 L95_99 0.0219
K6708 L20_25 L116_121 0.0194
K6709 L20_25 L74_79 0.0275
K6710 L20_25 L165_170 0.0537
K6711 L20_25 L199_203 0.0158
K6712 L20_25 L75_80 0.0158
K6713 L20_25 L70_75 0.0162
K6714 L20_25 L50_54 0.0194
K6715 L20_25 L79_84 0.026
K6716 L20_25 L56_60 0.0313
K6717 L20_25 L90_94 0.023
K6718 L20_25 L134_173 0.0463
K6719 L20_25 L139_144 0.0235
K6720 L20_25 L83_88 0.0248
K6721 L20_25 L177_181 0.0867
K6722 L20_25 L111_116 0.0194
K6723 L20_25 L162_167 0.0979
K6724 L20_25 L43_91 0.0251
K6725 L20_25 L122_127 0.0249
K6726 L20_25 L39_44 0.0471
K6727 L20_25 L123_128 0.0312
K6728 L20_25 L12_17 0.0861
K6729 L20_25 L54_58 0.0195
K6730 L20_25 L146_151 0.0246
K6731 L20_25 L114_119 0.0412
K6732 L20_25 L61_65 0.0423
K6733 L20_25 L11_16 0.0615
K6734 L20_25 L77_82 0.0227
K6735 L119_120 L167_168 0.0759
K6736 L119_120 L74_90 0.0346
K6737 L119_120 L199_200 0.0379
K6738 L119_120 L115_179 0.0996
K6739 L119_120 L128_129 0.1593
K6740 L119_120 L147_148 0.0307
K6741 L119_120 L196_197 0.0441
K6742 L119_120 L1_2 0.0775
K6743 L119_120 L23_24 0.1168
K6744 L119_120 L158_159 0.1069
K6745 L119_120 L136_198 0.0491
K6746 L119_120 L163_164 0.0944
K6747 L119_120 L144_145 0.0315
K6748 L119_120 L91_92 0.0337
K6749 L119_120 L160_161 0.1179
K6750 L119_120 L151_152 0.0246
K6751 L119_120 L126_127 0.0608
K6752 L119_120 L22_23 0.1324
K6753 L119_120 L204_205 0.04
K6754 L119_120 L153_154 0.0242
K6755 L119_120 L4_5 0.0529
K6756 L119_120 L34_35 0.0715
K6757 L119_120 L41_42 0.0461
K6758 L119_120 L197_198 0.0477
K6759 L119_120 L143_144 0.032
K6760 L119_120 L200_201 0.0419
K6761 L119_120 L205_206 0.0427
K6762 L119_120 L36_37 0.0616
K6763 L119_120 L131_132 0.0465
K6764 L119_120 L100_101 0.0298
K6765 L119_120 L203_204 0.0365
K6766 L119_120 L92_93 0.0331
K6767 L119_120 L81_82 0.0399
K6768 L119_120 L148_149 0.0303
K6769 L119_120 L19_20 0.095
K6770 L119_120 L187_188 0.1476
K6771 L119_120 L165_166 0.0817
K6772 L119_120 L102_103 0.0244
K6773 L119_120 L106_107 0.0613
K6774 L119_120 L64_65 0.1479
K6775 L119_120 L26_27 0.1139
K6776 L119_120 L170_171 0.0622
K6777 L119_120 L193_194 0.0465
K6778 L119_120 L21_65 0.2081
K6779 L119_120 L121_122 0.066
K6780 L119_120 L9_10 0.0643
K6781 L119_120 L46_47 0.0607
K6782 L119_120 L195_196 0.0395
K6783 L119_120 L67_68 0.0425
K6784 L119_120 L134_135 0.0441
K6785 L119_120 L41_69 0.0477
K6786 L119_120 L171_172 0.061
K6787 L119_120 L104_105 0.0238
K6788 L119_120 L151_210 0.0391
K6789 L119_120 L138_139 0.0339
K6790 L119_120 L37_38 0.0605
K6791 L119_120 L75_76 0.0378
K6792 L119_120 L112_113 0.0993
K6793 L119_120 L59_60 0.0969
K6794 L119_120 L129_130 0.2387
K6795 L119_120 L38_39 0.059
K6796 L119_120 L108_109 0.1727
K6797 L119_120 L71_72 0.0439
K6798 L119_120 L27_28 0.1072
K6799 L119_120 L96_97 0.0314
K6800 L119_120 L78_79 0.046
K6801 L119_120 L44_45 0.0438
K6802 L119_120 L47_48 0.0896
K6803 L119_120 L29_30 0.0923
K6804 L119_120 L76_77 0.0418
K6805 L119_120 L114_115 0.3334
K6806 L119_120 L166_167 0.0791
K6807 L119_120 L177_178 0.054
K6808 L119_120 L16_17 0.1583
K6809 L119_120 L188_189 0.1196
K6810 L119_120 L86_87 0.0359
K6811 L119_120 L176_177 0.0608
K6812 L119_120 L3_4 0.0594
K6813 L119_120 L149_150 0.0299
K6814 L119_120 L2_3 0.0674
K6815 L119_120 L98_99 0.0306
K6816 L119_120 L6_53 0.2659
K6817 L119_120 L84_98 0.0308
K6818 L119_120 L48_49 0.1576
K6819 L119_120 L110_175 0.0811
K6820 L119_120 L124_125 0.3334
K6821 L119_120 L113_114 0.1933
K6822 L119_120 L52_53 0.1743
K6823 L119_120 L80_81 0.0364
K6824 L119_120 L17_18 0.133
K6825 L119_120 L141_202 0.0462
K6826 L119_120 L87_88 0.0381
K6827 L119_120 L146_147 0.031
K6828 L119_120 L209_210 0.0383
K6829 L119_120 L94_95 0.0323
K6830 L119_120 L136_137 0.0347
K6831 L119_120 L127_128 0.0898
K6832 L119_120 L42_43 0.0455
K6833 L119_120 L181_182 0.0656
K6834 L119_120 L28_29 0.0998
K6835 L119_120 L157_158 0.1225
K6836 L119_120 L122_123 0.0993
K6837 L119_120 L103_104 0.0241
K6838 L119_120 L66_67 0.0378
K6839 L119_120 L21_22 0.1485
K6840 L119_120 L51_52 0.0969
K6841 L119_120 L79_94 0.0326
K6842 L119_120 L24_25 0.1032
K6843 L119_120 L6_7 0.095
K6844 L119_120 L173_174 0.0578
K6845 L119_120 L154_155 0.0239
K6846 L119_120 L32_33 0.0779
K6847 L119_120 L95_96 0.0319
K6848 L119_120 L85_86 0.033
K6849 L119_120 L7_8 0.0822
K6850 L119_120 L82_83 0.0425
K6851 L119_120 L58_59 0.0653
K6852 L119_120 L141_142 0.0328
K6853 L119_120 L62_63 0.0602
K6854 L119_120 L125_187 0.1855
K6855 L119_120 L70_71 0.0393
K6856 L119_120 L68_69 0.0462
K6857 L119_120 L180_181 0.0741
K6858 L119_120 L89_102 0.0246
K6859 L119_120 L8_9 0.0723
K6860 L119_120 L50_51 0.0653
K6861 L119_120 L168_169 0.0725
K6862 L119_120 L83_84 0.0435
K6863 L119_120 L90_91 0.0342
K6864 L119_120 L139_140 0.0333
K6865 L119_120 L161_162 0.1105
K6866 L119_120 L111_112 0.066
K6867 L119_120 L162_163 0.1024
K6868 L119_120 L137_138 0.0344
K6869 L119_120 L179_180 0.0851
K6870 L119_120 L207_208 0.033
K6871 L119_120 L142_143 0.0324
K6872 L119_120 L123_124 0.1933
K6873 L119_120 L152_153 0.0244
K6874 L119_120 L191_192 0.0379
K6875 L119_120 L39_40 0.0573
K6876 L119_120 L130_156 0.1609
K6877 L119_120 L156_157 0.1409
K6878 L119_120 L189_190 0.0996
K6879 L119_120 L18_19 0.1117
K6880 L119_120 L201_202 0.045
K6881 L108_109 L167_168 0.0535
K6882 L108_109 L74_90 0.0284
K6883 L108_109 L199_200 0.0369
K6884 L108_109 L115_179 0.0819
K6885 L108_109 L128_129 0.1605
K6886 L108_109 L147_148 0.0254
K6887 L108_109 L196_197 0.0414
K6888 L108_109 L13_14 0.0596
K6889 L108_109 L23_24 0.0651
K6890 L108_109 L158_159 0.0606
K6891 L108_109 L136_198 0.0414
K6892 L108_109 L163_164 0.0597
K6893 L108_109 L144_145 0.0255
K6894 L108_109 L120_183 0.0783
K6895 L108_109 L91_92 0.0272
K6896 L108_109 L151_152 0.0207
K6897 L108_109 L126_127 0.0785
K6898 L108_109 L22_23 0.0712
K6899 L108_109 L204_205 0.0373
K6900 L108_109 L153_154 0.02
K6901 L108_109 L34_35 0.0506
K6902 L108_109 L41_42 0.0372
K6903 L108_109 L197_198 0.0425
K6904 L108_109 L143_144 0.0261
K6905 L108_109 L200_201 0.0393
K6906 L108_109 L205_206 0.0381
K6907 L108_109 L36_37 0.0479
K6908 L108_109 L131_132 0.0374
K6909 L108_109 L100_101 0.0244
K6910 L108_109 L203_204 0.0352
K6911 L108_109 L92_93 0.0266
K6912 L108_109 L81_82 0.0372
K6913 L108_109 L148_149 0.025
K6914 L108_109 L19_20 0.0522
K6915 L108_109 L187_188 0.0653
K6916 L108_109 L102_103 0.0203
K6917 L108_109 L160_161 0.0733
K6918 L108_109 L64_65 0.1492
K6919 L108_109 L26_27 0.0722
K6920 L108_109 L165_166 0.0587
K6921 L108_109 L170_171 0.0482
K6922 L108_109 L193_194 0.0414
K6923 L108_109 L21_65 0.1173
K6924 L108_109 L121_122 0.0877
K6925 L108_109 L9_10 0.0548
K6926 L108_109 L195_196 0.0386
K6927 L108_109 L67_68 0.0401
K6928 L108_109 L134_135 0.0347
K6929 L108_109 L41_69 0.0401
K6930 L108_109 L171_172 0.0467
K6931 L108_109 L104_105 0.0196
K6932 L108_109 L151_210 0.0335
K6933 L108_109 L79_94 0.027
K6934 L108_109 L37_38 0.0464
K6935 L108_109 L75_76 0.0367
K6936 L108_109 L112_113 0.2045
K6937 L108_109 L183_184 0.0685
K6938 L108_109 L59_60 0.1387
K6939 L108_109 L11_57 0.1576
K6940 L108_109 L38_39 0.0449
K6941 L108_109 L71_72 0.0412
K6942 L108_109 L27_28 0.0675
K6943 L108_109 L96_97 0.0254
K6944 L108_109 L78_79 0.0391
K6945 L108_109 L44_45 0.0345
K6946 L108_109 L29_30 0.0591
K6947 L108_109 L76_77 0.0391
K6948 L108_109 L114_115 0.2045
K6949 L108_109 L166_167 0.0561
K6950 L108_109 L185_186 0.0546
K6951 L108_109 L16_17 0.0716
K6952 L108_109 L188_189 0.0585
K6953 L108_109 L86_87 0.0334
K6954 L108_109 L118_119 0.2809
K6955 L108_109 L180_181 0.0623
K6956 L108_109 L6_53 0.1765
K6957 L108_109 L149_150 0.0245
K6958 L108_109 L98_99 0.0253
K6959 L108_109 L55_56 0.1576
K6960 L108_109 L84_98 0.0258
K6961 L108_109 L124_125 0.1475
K6962 L108_109 L113_114 0.4331
K6963 L108_109 L52_53 0.2931
K6964 L108_109 L80_81 0.0351
K6965 L108_109 L17_18 0.0639
K6966 L108_109 L141_202 0.0393
K6967 L108_109 L87_88 0.0341
K6968 L108_109 L146_147 0.0258
K6969 L108_109 L209_210 0.0342
K6970 L108_109 L94_95 0.0265
K6971 L108_109 L136_137 0.0285
K6972 L108_109 L127_128 0.123
K6973 L108_109 L138_139 0.0273
K6974 L108_109 L42_43 0.0364
K6975 L108_109 L181_182 0.0557
K6976 L108_109 L28_29 0.0632
K6977 L108_109 L157_158 0.0661
K6978 L108_109 L122_123 0.1475
K6979 L108_109 L103_104 0.02
K6980 L108_109 L66_67 0.0372
K6981 L108_109 L129_130 0.123
K6982 L108_109 L21_22 0.0783
K6983 L108_109 L117_118 0.1727
K6984 L108_109 L51_52 0.1765
K6985 L108_109 L56_57 0.2334
K6986 L108_109 L24_25 0.0598
K6987 L108_109 L116_117 0.0917
K6988 L108_109 L6_7 0.079
K6989 L108_109 L173_174 0.0436
K6990 L108_109 L154_155 0.0197
K6991 L108_109 L32_33 0.0556
K6992 L108_109 L95_96 0.026
K6993 L108_109 L85_86 0.0317
K6994 L108_109 L7_8 0.0689
K6995 L108_109 L82_83 0.038
K6996 L108_109 L14_15 0.0537
K6997 L108_109 L184_185 0.0608
K6998 L108_109 L141_142 0.0271
K6999 L108_109 L62_63 0.077
K7000 L108_109 L125_187 0.0737
K7001 L108_109 L58_59 0.0858
K7002 L108_109 L70_71 0.0385
K7003 L108_109 L68_69 0.0412
K7004 L108_109 L89_102 0.0206
K7005 L108_109 L8_9 0.061
K7006 L108_109 L50_51 0.0923
K7007 L108_109 L168_169 0.051
K7008 L108_109 L83_84 0.0372
K7009 L108_109 L90_91 0.0278
K7010 L108_109 L139_140 0.0267
K7011 L108_109 L161_162 0.0685
K7012 L108_109 L111_112 0.0947
K7013 L108_109 L162_163 0.0639
K7014 L108_109 L137_138 0.0279
K7015 L108_109 L179_180 0.0708
K7016 L108_109 L12_13 0.0668
K7017 L108_109 L207_208 0.0318
K7018 L108_109 L142_143 0.0266
K7019 L108_109 L123_124 0.2072
K7020 L108_109 L152_153 0.0204
K7021 L108_109 L191_192 0.0373
K7022 L108_109 L39_40 0.0434
K7023 L108_109 L18_19 0.0575
K7024 L108_109 L130_156 0.0801
K7025 L108_109 L156_157 0.0726
K7026 L108_109 L189_190 0.053
K7027 L108_109 L11_12 0.0758
K7028 L108_109 L54_55 0.0896
K7029 L108_109 L201_202 0.0402
K7030 L119_124 L140_145 0.0258
K7031 L119_124 L1_6 0.1022
K7032 L119_124 L13_18 0.0593
K7033 L119_124 L35_40 0.0474
K7034 L119_124 L23_28 0.0726
K7035 L119_124 L184_188 0.0602
K7036 L119_124 L6_11 0.1053
K7037 L119_124 L163_168 0.0611
K7038 L119_124 L91_95 0.0328
K7039 L119_124 L144_149 0.0306
K7040 L119_124 L130_160 0.081
K7041 L119_124 L4_9 0.0531
K7042 L119_124 L156_161 0.0811
K7043 L119_124 L181_185 0.0544
K7044 L119_124 L164_169 0.0536
K7045 L119_124 L106_111 0.0553
K7046 L119_124 L34_39 0.0534
K7047 L119_124 L148_153 0.0301
K7048 L119_124 L201_205 0.0489
K7049 L119_124 L9_14 0.0537
K7050 L119_124 L200_204 0.0439
K7051 L119_124 L150_155 0.0238
K7052 L119_124 L145_150 0.0248
K7053 L119_124 L30_35 0.0531
K7054 L119_124 L131_136 0.0487
K7055 L119_124 L101_105 0.0237
K7056 L119_124 L46_50 0.0549
K7057 L119_124 L196_200 0.0457
K7058 L119_124 L92_96 0.0318
K7059 L119_124 L81_86 0.042
K7060 L119_124 L19_24 0.0537
K7061 L119_124 L120_125 0.1098
K7062 L119_124 L8_13 0.059
K7063 L119_124 L60_64 0.1104
K7064 L119_124 L193_197 0.0543
K7065 L119_124 L7_12 0.0655
K7066 L119_124 L137_142 0.034
K7067 L119_124 L167_172 0.0568
K7068 L119_124 L121_126 0.0558
K7069 L119_124 L195_199 0.0364
K7070 L119_124 L97_101 0.0247
K7071 L119_124 L110_115 0.1051
K7072 L119_124 L113_118 0.1134
K7073 L119_124 L134_139 0.0334
K7074 L119_124 L141_146 0.0437
K7075 L119_124 L182_186 0.0421
K7076 L119_124 L100_104 0.0292
K7077 L119_124 L166_171 0.0601
K7078 L119_124 L24_29 0.0666
K7079 L119_124 L138_143 0.033
K7080 L119_124 L33_38 0.0564
K7081 L119_124 L18_23 0.059
K7082 L119_124 L132_171 0.0509
K7083 L119_124 L107_112 0.0733
K7084 L119_124 L112_117 0.0741
K7085 L119_124 L40_45 0.0418
K7086 L119_124 L183_187 0.0671
K7087 L119_124 L136_141 0.046
K7088 L119_124 L59_63 0.0734
K7089 L119_124 L5_10 0.0412
K7090 L119_124 L71_76 0.0455
K7091 L119_124 L15_20 0.0418
K7092 L119_124 L51_55 0.0734
K7093 L119_124 L58_62 0.0554
K7094 L119_124 L67_71 0.0474
K7095 L119_124 L36_41 0.0481
K7096 L119_124 L48_52 0.1076
K7097 L119_124 L29_34 0.0606
K7098 L119_124 L179_183 0.0667
K7099 L119_124 L41_74 0.0484
K7100 L119_124 L131_170 0.0484
K7101 L119_124 L28_33 0.065
K7102 L119_124 L205_209 0.0466
K7103 L119_124 L191_195 0.0378
K7104 L119_124 L66_70 0.0376
K7105 L119_124 L98_102 0.0308
K7106 L119_124 L27_32 0.07
K7107 L119_124 L142_147 0.0324
K7108 L119_124 L147_152 0.0309
K7109 L119_124 L178_182 0.0417
K7110 L119_124 L180_184 0.0599
K7111 L119_124 L3_8 0.0581
K7112 L119_124 L157_162 0.0736
K7113 L119_124 L149_154 0.0293
K7114 L119_124 L203_207 0.0337
K7115 L119_124 L2_7 0.0643
K7116 L119_124 L117_122 0.0744
K7117 L119_124 L22_27 0.0798
K7118 L119_124 L158_189 0.0544
K7119 L119_124 L38_43 0.0486
K7120 L119_124 L47_51 0.0726
K7121 L119_124 L55_59 0.0736
K7122 L119_124 L135_174 0.042
K7123 L119_124 L94_98 0.0322
K7124 L119_124 L160_165 0.0694
K7125 L119_124 L52_56 0.1104
K7126 L119_124 L115_120 0.1086
K7127 L119_124 L80_85 0.0336
K7128 L119_124 L10_15 0.0417
K7129 L119_124 L16_21 0.1053
K7130 L119_124 L158_163 0.0673
K7131 L119_124 L185_189 0.0546
K7132 L119_124 L96_100 0.0305
K7133 L119_124 L165_170 0.0578
K7134 L119_124 L186_190 0.0423
K7135 L119_124 L82_87 0.0464
K7136 L119_124 L125_130 0.1086
K7137 L119_124 L108_113 0.1103
K7138 L119_124 L159_164 0.0584
K7139 L119_124 L84_89 0.0413
K7140 L119_124 L68_72 0.054
K7141 L119_124 L169_174 0.0477
K7142 L119_124 L204_208 0.0421
K7143 L119_124 L25_30 0.0578
K7144 L119_124 L32_37 0.0595
K7145 L119_124 L133_172 0.0489
K7146 L119_124 L14_19 0.054
K7147 L119_124 L44_92 0.0332
K7148 L119_124 L161_166 0.0709
K7149 L119_124 L21_26 0.0795
K7150 L119_124 L95_99 0.0314
K7151 L119_124 L116_121 0.056
K7152 L119_124 L74_79 0.0458
K7153 L119_124 L199_203 0.035
K7154 L119_124 L75_80 0.0349
K7155 L119_124 L70_75 0.0362
K7156 L119_124 L50_54 0.0554
K7157 L119_124 L79_84 0.0435
K7158 L119_124 L56_60 0.1114
K7159 L119_124 L159_190 0.0421
K7160 L119_124 L93_97 0.0257
K7161 L119_124 L90_94 0.0338
K7162 L119_124 L134_173 0.0469
K7163 L119_124 L139_144 0.032
K7164 L119_124 L177_181 0.0537
K7165 L119_124 L111_116 0.0558
K7166 L119_124 L162_167 0.0657
K7167 L119_124 L43_91 0.0344
K7168 L119_124 L122_127 0.0741
K7169 L119_124 L135_140 0.0269
K7170 L119_124 L39_44 0.0466
K7171 L119_124 L123_128 0.1134
K7172 L119_124 L12_17 0.0659
K7173 L119_124 L54_58 0.0555
K7174 L119_124 L146_151 0.0415
K7175 L119_124 L143_148 0.0315
K7176 L119_124 L11_16 0.1064
K7177 L119_124 L77_82 0.0487
K7178 L46_47 L167_168 0.0365
K7179 L46_47 L74_90 0.0233
K7180 L46_47 L199_200 0.04
K7181 L46_47 L115_179 0.0361
K7182 L46_47 L128_129 0.077
K7183 L46_47 L147_148 0.0212
K7184 L46_47 L196_197 0.0412
K7185 L46_47 L13_14 0.0317
K7186 L46_47 L23_24 0.0373
K7187 L46_47 L158_159 0.0351
K7188 L46_47 L136_198 0.0349
K7189 L46_47 L163_164 0.0374
K7190 L46_47 L144_145 0.0208
K7191 L46_47 L120_183 0.0358
K7192 L46_47 L91_92 0.022
K7193 L46_47 L151_152 0.0176
K7194 L46_47 L126_127 0.1492
K7195 L46_47 L22_23 0.0395
K7196 L46_47 L204_205 0.0372
K7197 L46_47 L153_154 0.0168
K7198 L46_47 L34_35 0.0351
K7199 L46_47 L41_42 0.0298
K7200 L46_47 L197_198 0.0385
K7201 L46_47 L143_144 0.0213
K7202 L46_47 L200_201 0.0391
K7203 L46_47 L205_206 0.0351
K7204 L46_47 L36_37 0.0362
K7205 L46_47 L131_132 0.0297
K7206 L46_47 L100_101 0.0202
K7207 L46_47 L203_204 0.038
K7208 L46_47 L92_93 0.0214
K7209 L46_47 L81_82 0.0373
K7210 L46_47 L148_149 0.0207
K7211 L46_47 L19_20 0.0296
K7212 L46_47 L187_188 0.0332
K7213 L46_47 L102_103 0.0172
K7214 L46_47 L160_161 0.0437
K7215 L46_47 L64_65 0.0785
K7216 L46_47 L26_27 0.044
K7217 L46_47 L165_166 0.0399
K7218 L46_47 L170_171 0.0361
K7219 L46_47 L193_194 0.0372
K7220 L46_47 L21_65 0.055
K7221 L46_47 L121_122 0.1866
K7222 L46_47 L9_10 0.0301
K7223 L46_47 L195_196 0.0423
K7224 L46_47 L67_68 0.0403
K7225 L46_47 L134_135 0.0271
K7226 L46_47 L41_69 0.0336
K7227 L46_47 L171_172 0.0348
K7228 L46_47 L104_105 0.0164
K7229 L46_47 L151_210 0.0293
K7230 L46_47 L79_94 0.0226
K7231 L46_47 L37_38 0.0349
K7232 L46_47 L75_76 0.0402
K7233 L46_47 L112_113 0.1765
K7234 L46_47 L183_184 0.0335
K7235 L46_47 L59_60 0.1475
K7236 L46_47 L11_57 0.0613
K7237 L46_47 L38_39 0.0336
K7238 L46_47 L71_72 0.0414
K7239 L46_47 L27_28 0.0416
K7240 L46_47 L96_97 0.0208
K7241 L46_47 L78_79 0.0337
K7242 L46_47 L44_45 0.0271
K7243 L46_47 L29_30 0.0376
K7244 L46_47 L76_77 0.0393
K7245 L46_47 L114_115 0.0615
K7246 L46_47 L166_167 0.0381
K7247 L46_47 L185_186 0.0298
K7248 L46_47 L16_17 0.0356
K7249 L46_47 L188_189 0.0312
K7250 L46_47 L86_87 0.0335
K7251 L46_47 L118_119 0.0896
K7252 L46_47 L180_181 0.0318
K7253 L46_47 L6_53 0.0621
K7254 L46_47 L149_150 0.0202
K7255 L46_47 L98_99 0.0213
K7256 L46_47 L55_56 0.1727
K7257 L46_47 L84_98 0.0218
K7258 L46_47 L124_125 0.0595
K7259 L46_47 L113_114 0.0923
K7260 L46_47 L52_53 0.0947
K7261 L46_47 L80_81 0.0381
K7262 L46_47 L17_18 0.0334
K7263 L46_47 L141_202 0.0336
K7264 L46_47 L87_88 0.0318
K7265 L46_47 L146_147 0.0218
K7266 L46_47 L209_210 0.0317
K7267 L46_47 L94_95 0.022
K7268 L46_47 L136_137 0.0233
K7269 L46_47 L127_128 0.1173
K7270 L46_47 L138_139 0.022
K7271 L46_47 L42_43 0.0289
K7272 L46_47 L181_182 0.0299
K7273 L46_47 L28_29 0.0395
K7274 L46_47 L157_158 0.0371
K7275 L46_47 L122_123 0.1387
K7276 L46_47 L103_104 0.0168
K7277 L46_47 L66_67 0.0414
K7278 L46_47 L129_130 0.0545
K7279 L46_47 L21_22 0.042
K7280 L46_47 L117_118 0.1576
K7281 L46_47 L51_52 0.2045
K7282 L46_47 L56_57 0.0917
K7283 L46_47 L24_25 0.0353
K7284 L46_47 L116_117 0.2334
K7285 L46_47 L6_7 0.0363
K7286 L46_47 L173_174 0.0323
K7287 L46_47 L154_155 0.0164
K7288 L46_47 L32_33 0.0383
K7289 L46_47 L95_96 0.0214
K7290 L46_47 L85_86 0.0342
K7291 L46_47 L7_8 0.034
K7292 L46_47 L82_83 0.0352
K7293 L46_47 L14_15 0.0299
K7294 L46_47 L184_185 0.0315
K7295 L46_47 L141_142 0.0225
K7296 L46_47 L62_63 0.1605
K7297 L46_47 L125_187 0.0353
K7298 L46_47 L58_59 0.2072
K7299 L46_47 L70_71 0.0425
K7300 L46_47 L68_69 0.0373
K7301 L46_47 L89_102 0.0176
K7302 L46_47 L8_9 0.0319
K7303 L46_47 L50_51 0.4331
K7304 L46_47 L168_169 0.035
K7305 L46_47 L83_84 0.0324
K7306 L46_47 L90_91 0.0227
K7307 L46_47 L139_140 0.0214
K7308 L46_47 L161_162 0.0414
K7309 L46_47 L111_112 0.2931
K7310 L46_47 L162_163 0.0393
K7311 L46_47 L137_138 0.0226
K7312 L46_47 L179_180 0.0338
K7313 L46_47 L12_13 0.0337
K7314 L46_47 L207_208 0.0341
K7315 L46_47 L142_143 0.0219
K7316 L46_47 L123_124 0.0858
K7317 L46_47 L152_153 0.0172
K7318 L46_47 L191_192 0.0412
K7319 L46_47 L39_40 0.0324
K7320 L46_47 L18_19 0.0314
K7321 L46_47 L130_156 0.0417
K7322 L46_47 L156_157 0.0393
K7323 L46_47 L189_190 0.0295
K7324 L46_47 L11_12 0.036
K7325 L46_47 L54_55 0.2809
K7326 L46_47 L201_202 0.0367
K7327 L67_68 L167_168 0.0393
K7328 L67_68 L74_90 0.0503
K7329 L67_68 L199_200 0.1576
K7330 L67_68 L115_179 0.0248
K7331 L67_68 L128_129 0.0498
K7332 L67_68 L196_197 0.2931
K7333 L67_68 L1_2 0.0204
K7334 L67_68 L23_24 0.0308
K7335 L67_68 L158_159 0.0296
K7336 L67_68 L136_198 0.0923
K7337 L67_68 L163_164 0.0345
K7338 L67_68 L144_145 0.0384
K7339 L67_68 L120_183 0.0257
K7340 L67_68 L91_92 0.0422
K7341 L67_68 L160_161 0.0389
K7342 L67_68 L151_152 0.0387
K7343 L67_68 L126_127 0.0498
K7344 L67_68 L22_23 0.032
K7345 L67_68 L153_154 0.0331
K7346 L67_68 L4_5 0.0187
K7347 L67_68 L34_35 0.0376
K7348 L67_68 L197_198 0.1765
K7349 L67_68 L204_205 0.1866
K7350 L67_68 L143_144 0.0413
K7351 L67_68 L200_201 0.2334
K7352 L67_68 L205_206 0.1387
K7353 L67_68 L36_37 0.0479
K7354 L67_68 L141_142 0.0489
K7355 L67_68 L100_101 0.0381
K7356 L67_68 L203_204 0.1387
K7357 L67_68 L92_93 0.0391
K7358 L67_68 L81_82 0.2072
K7359 L67_68 L13_14 0.0242
K7360 L67_68 L185_186 0.0233
K7361 L67_68 L148_149 0.0406
K7362 L67_68 L19_20 0.0241
K7363 L67_68 L187_188 0.0258
K7364 L67_68 L165_166 0.0433
K7365 L67_68 L102_103 0.036
K7366 L67_68 L106_107 0.0401
K7367 L67_68 L64_65 0.0502
K7368 L67_68 L8_9 0.0234
K7369 L67_68 L170_171 0.0476
K7370 L67_68 L21_65 0.0449
K7371 L67_68 L121_122 0.0492
K7372 L67_68 L9_10 0.0227
K7373 L67_68 L195_196 0.1765
K7374 L67_68 L171_172 0.0449
K7375 L67_68 L104_105 0.0311
K7376 L67_68 L151_210 0.077
K7377 L67_68 L79_94 0.0495
K7378 L67_68 L37_38 0.0451
K7379 L67_68 L75_76 0.1727
K7380 L67_68 L112_113 0.0448
K7381 L67_68 L183_184 0.0249
K7382 L67_68 L59_60 0.0513
K7383 L67_68 L11_57 0.0427
K7384 L67_68 L38_39 0.0426
K7385 L67_68 L71_72 0.4331
K7386 L67_68 L27_28 0.0375
K7387 L67_68 L96_97 0.0387
K7388 L67_68 L78_79 0.0917
K7389 L67_68 L138_139 0.0418
K7390 L67_68 L47_48 0.0414
K7391 L67_68 L29_30 0.0346
K7392 L67_68 L76_77 0.2809
K7393 L67_68 L114_115 0.0404
K7394 L67_68 L166_167 0.0412
K7395 L67_68 L177_178 0.0186
K7396 L67_68 L16_17 0.0268
K7397 L67_68 L188_189 0.0249
K7398 L67_68 L86_87 0.1605
K7399 L67_68 L118_119 0.0462
K7400 L67_68 L176_177 0.0192
K7401 L67_68 L3_4 0.0192
K7402 L67_68 L6_53 0.0406
K7403 L67_68 L149_150 0.0378
K7404 L67_68 L2_3 0.0198
K7405 L67_68 L98_99 0.0444
K7406 L67_68 L55_56 0.048
K7407 L67_68 L184_185 0.0241
K7408 L67_68 L84_98 0.0483
K7409 L67_68 L48_49 0.0403
K7410 L67_68 L110_175 0.0204
K7411 L67_68 L124_125 0.0447
K7412 L67_68 L113_114 0.0436
K7413 L67_68 L52_53 0.0438
K7414 L67_68 L80_81 0.1475
K7415 L67_68 L17_18 0.0259
K7416 L67_68 L141_202 0.0896
K7417 L67_68 L87_88 0.123
K7418 L67_68 L146_147 0.0477
K7419 L67_68 L209_210 0.1173
K7420 L67_68 L94_95 0.0453
K7421 L67_68 L127_128 0.052
K7422 L67_68 L181_182 0.0227
K7423 L67_68 L28_29 0.036
K7424 L67_68 L157_158 0.0307
K7425 L67_68 L122_123 0.051
K7426 L67_68 L103_104 0.0334
K7427 L67_68 L129_130 0.0446
K7428 L67_68 L21_22 0.0331
K7429 L67_68 L117_118 0.0477
K7430 L67_68 L51_52 0.0451
K7431 L67_68 L56_57 0.0465
K7432 L67_68 L24_25 0.0297
K7433 L67_68 L116_117 0.0462
K7434 L67_68 L6_7 0.0249
K7435 L67_68 L173_174 0.0402
K7436 L67_68 L154_155 0.0309
K7437 L67_68 L32_33 0.0414
K7438 L67_68 L95_96 0.0417
K7439 L67_68 L85_86 0.123
K7440 L67_68 L7_8 0.0241
K7441 L67_68 L82_83 0.1475
K7442 L67_68 L14_15 0.0234
K7443 L67_68 L147_148 0.0439
K7444 L67_68 L62_63 0.0502
K7445 L67_68 L125_187 0.0267
K7446 L67_68 L58_59 0.0495
K7447 L67_68 L70_71 0.2045
K7448 L67_68 L136_137 0.0496
K7449 L67_68 L180_181 0.0234
K7450 L67_68 L89_102 0.0391
K7451 L67_68 L26_27 0.039
K7452 L67_68 L50_51 0.0438
K7453 L67_68 L168_169 0.0375
K7454 L67_68 L83_84 0.0877
K7455 L67_68 L90_91 0.0459
K7456 L67_68 L139_140 0.0387
K7457 L67_68 L161_162 0.0373
K7458 L67_68 L111_112 0.0436
K7459 L67_68 L162_163 0.0359
K7460 L67_68 L137_138 0.0454
K7461 L67_68 L179_180 0.0241
K7462 L67_68 L12_13 0.025
K7463 L67_68 L207_208 0.1173
K7464 L67_68 L142_143 0.0448
K7465 L67_68 L123_124 0.0492
K7466 L67_68 L152_153 0.0357
K7467 L67_68 L39_40 0.0404
K7468 L67_68 L18_19 0.025
K7469 L67_68 L130_156 0.033
K7470 L67_68 L156_157 0.0318
K7471 L67_68 L189_190 0.0241
K7472 L67_68 L11_12 0.0258
K7473 L67_68 L54_55 0.0465
K7474 L67_68 L201_202 0.1576
K7475 L182_186 L24_29 0.1366
K7476 L182_186 L181_185 0.1916
K7477 L182_186 L1_6 0.0598
K7478 L182_186 L13_18 0.0988
K7479 L182_186 L23_28 0.1123
K7480 L182_186 L73_78 0.0247
K7481 L182_186 L184_188 0.1144
K7482 L182_186 L6_11 0.0604
K7483 L182_186 L163_168 0.0827
K7484 L182_186 L91_95 0.0204
K7485 L182_186 L144_149 0.0195
K7486 L182_186 L130_160 0.0877
K7487 L182_186 L4_9 0.1266
K7488 L182_186 L109_114 0.0421
K7489 L182_186 L57_61 0.0417
K7490 L182_186 L195_199 0.0155
K7491 L182_186 L106_111 0.0195
K7492 L182_186 L34_39 0.0517
K7493 L182_186 L148_153 0.0183
K7494 L182_186 L201_205 0.0213
K7495 L182_186 L53_57 0.0418
K7496 L182_186 L69_73 0.0257
K7497 L182_186 L200_204 0.0189
K7498 L182_186 L131_136 0.026
K7499 L182_186 L100_104 0.0184
K7500 L182_186 L46_50 0.0194
K7501 L182_186 L196_200 0.0194
K7502 L182_186 L92_96 0.0206
K7503 L182_186 L81_86 0.0184
K7504 L182_186 L19_24 0.1062
K7505 L182_186 L120_125 0.0615
K7506 L182_186 L8_13 0.1033
K7507 L182_186 L60_64 0.031
K7508 L182_186 L198_202 0.0248
K7509 L182_186 L193_197 0.0227
K7510 L182_186 L7_12 0.0811
K7511 L182_186 L137_142 0.0203
K7512 L182_186 L143_148 0.0194
K7513 L182_186 L167_172 0.051
K7514 L182_186 L121_126 0.0194
K7515 L182_186 L110_115 0.0615
K7516 L182_186 L113_118 0.0314
K7517 L182_186 L134_139 0.0221
K7518 L182_186 L141_146 0.0234
K7519 L182_186 L166_171 0.0488
K7520 L182_186 L9_14 0.1363
K7521 L182_186 L138_143 0.0206
K7522 L182_186 L33_38 0.05
K7523 L182_186 L18_23 0.088
K7524 L182_186 L132_171 0.037
K7525 L182_186 L124_129 0.0417
K7526 L182_186 L107_112 0.025
K7527 L182_186 L78_83 0.0237
K7528 L182_186 L112_117 0.025
K7529 L182_186 L183_187 0.0861
K7530 L182_186 L136_141 0.0247
K7531 L182_186 L59_63 0.0248
K7532 L182_186 L71_76 0.0193
K7533 L182_186 L51_55 0.0249
K7534 L182_186 L58_62 0.0194
K7535 L182_186 L67_71 0.0198
K7536 L182_186 L36_41 0.0336
K7537 L182_186 L48_52 0.0312
K7538 L182_186 L29_34 0.0784
K7539 L182_186 L179_183 0.0891
K7540 L182_186 L206_210 0.0229
K7541 L182_186 L41_74 0.0259
K7542 L182_186 L131_170 0.0339
K7543 L182_186 L28_33 0.0728
K7544 L182_186 L205_209 0.0206
K7545 L182_186 L191_195 0.0158
K7546 L182_186 L66_70 0.0158
K7547 L182_186 L98_102 0.0181
K7548 L182_186 L27_32 0.0666
K7549 L182_186 L142_147 0.0192
K7550 L182_186 L147_152 0.0181
K7551 L182_186 L180_184 0.1216
K7552 L182_186 L3_8 0.0988
K7553 L182_186 L157_162 0.1262
K7554 L182_186 L149_154 0.0185
K7555 L182_186 L203_207 0.0147
K7556 L182_186 L2_7 0.0789
K7557 L182_186 L117_122 0.025
K7558 L182_186 L22_27 0.093
K7559 L182_186 L158_189 0.1268
K7560 L182_186 L38_43 0.0375
K7561 L182_186 L47_51 0.0249
K7562 L182_186 L108_113 0.0313
K7563 L182_186 L94_98 0.0191
K7564 L182_186 L160_165 0.0622
K7565 L182_186 L52_56 0.0312
K7566 L182_186 L115_120 0.0622
K7567 L182_186 L80_85 0.0147
K7568 L182_186 L16_21 0.0581
K7569 L182_186 L158_163 0.1671
K7570 L182_186 L185_189 0.1673
K7571 L182_186 L96_100 0.0194
K7572 L182_186 L49_53 0.0417
K7573 L182_186 L156_161 0.1002
K7574 L182_186 L82_87 0.0205
K7575 L182_186 L125_130 0.0597
K7576 L182_186 L55_59 0.0249
K7577 L182_186 L84_89 0.0222
K7578 L182_186 L68_72 0.0226
K7579 L182_186 L204_208 0.0184
K7580 L182_186 L202_206 0.0238
K7581 L182_186 L32_37 0.0479
K7582 L182_186 L133_172 0.0379
K7583 L182_186 L14_19 0.1266
K7584 L182_186 L44_92 0.022
K7585 L182_186 L161_166 0.0691
K7586 L182_186 L21_26 0.082
K7587 L182_186 L95_99 0.0193
K7588 L182_186 L116_121 0.0195
K7589 L182_186 L74_79 0.0246
K7590 L182_186 L165_170 0.0445
K7591 L182_186 L199_203 0.0151
K7592 L182_186 L75_80 0.0151
K7593 L182_186 L70_75 0.0154
K7594 L182_186 L50_54 0.0195
K7595 L182_186 L79_84 0.0234
K7596 L182_186 L56_60 0.0312
K7597 L182_186 L90_94 0.0202
K7598 L182_186 L134_173 0.0386
K7599 L182_186 L139_144 0.0207
K7600 L182_186 L83_88 0.0228
K7601 L182_186 L177_181 0.1673
K7602 L182_186 L111_116 0.0195
K7603 L182_186 L162_167 0.0762
K7604 L182_186 L43_91 0.0218
K7605 L182_186 L122_127 0.0249
K7606 L182_186 L39_44 0.0382
K7607 L182_186 L123_128 0.0312
K7608 L182_186 L12_17 0.0789
K7609 L182_186 L54_58 0.0194
K7610 L182_186 L146_151 0.0223
K7611 L182_186 L114_119 0.0423
K7612 L182_186 L61_65 0.0412
K7613 L182_186 L11_16 0.0598
K7614 L182_186 L77_82 0.0212
K7615 L166_171 L24_29 0.0976
K7616 L166_171 L181_185 0.061
K7617 L166_171 L140_145 0.061
K7618 L166_171 L1_6 0.0562
K7619 L166_171 L13_18 0.0699
K7620 L166_171 L35_40 0.1436
K7621 L166_171 L23_28 0.1038
K7622 L166_171 L73_78 0.0629
K7623 L166_171 L184_188 0.0718
K7624 L166_171 L6_11 0.0609
K7625 L166_171 L163_168 0.159
K7626 L166_171 L91_95 0.08
K7627 L166_171 L144_149 0.0685
K7628 L166_171 L130_160 0.1037
K7629 L166_171 L4_9 0.054
K7630 L166_171 L202_206 0.0601
K7631 L166_171 L109_114 0.0537
K7632 L166_171 L57_61 0.0595
K7633 L166_171 L164_169 0.1278
K7634 L166_171 L195_199 0.0318
K7635 L166_171 L106_111 0.0297
K7636 L166_171 L34_39 0.1838
K7637 L166_171 L148_153 0.0633
K7638 L166_171 L201_205 0.0483
K7639 L166_171 L53_57 0.0564
K7640 L166_171 L69_73 0.0664
K7641 L166_171 L200_204 0.0397
K7642 L166_171 L150_155 0.0488
K7643 L166_171 L145_150 0.0543
K7644 L166_171 L30_35 0.1202
K7645 L166_171 L131_136 0.082
K7646 L166_171 L101_105 0.0479
K7647 L166_171 L46_50 0.0296
K7648 L166_171 L196_200 0.0407
K7649 L166_171 L92_96 0.0754
K7650 L166_171 L81_86 0.0386
K7651 L166_171 L19_24 0.0754
K7652 L166_171 L120_125 0.0674
K7653 L166_171 L8_13 0.0619
K7654 L166_171 L60_64 0.0498
K7655 L166_171 L198_202 0.0636
K7656 L166_171 L193_197 0.0518
K7657 L166_171 L167_172 0.2991
K7658 L166_171 L121_126 0.0318
K7659 L166_171 L97_101 0.0531
K7660 L166_171 L110_115 0.0568
K7661 L166_171 L113_118 0.0466
K7662 L166_171 L141_146 0.0674
K7663 L166_171 L100_104 0.0598
K7664 L166_171 L9_14 0.0598
K7665 L166_171 L138_143 0.083
K7666 L166_171 L33_38 0.2341
K7667 L166_171 L18_23 0.08
K7668 L166_171 L134_139 0.0898
K7669 L166_171 L124_129 0.0636
K7670 L166_171 L107_112 0.0377
K7671 L166_171 L78_83 0.0595
K7672 L166_171 L112_117 0.0387
K7673 L166_171 L40_45 0.1202
K7674 L166_171 L136_141 0.0741
K7675 L166_171 L59_63 0.0405
K7676 L166_171 L5_10 0.0435
K7677 L166_171 L71_76 0.0405
K7678 L166_171 L15_20 0.0531
K7679 L166_171 L51_55 0.0386
K7680 L166_171 L58_62 0.0317
K7681 L166_171 L67_71 0.0414
K7682 L166_171 L36_41 0.1747
K7683 L166_171 L48_52 0.0446
K7684 L166_171 L29_34 0.1463
K7685 L166_171 L206_210 0.0568
K7686 L166_171 L41_74 0.0803
K7687 L166_171 L131_170 0.2112
K7688 L166_171 L28_33 0.1706
K7689 L166_171 L205_209 0.0466
K7690 L166_171 L191_195 0.0325
K7691 L166_171 L178_182 0.0442
K7692 L166_171 L180_184 0.0633
K7693 L166_171 L3_8 0.0555
K7694 L166_171 L157_162 0.1081
K7695 L166_171 L149_154 0.061
K7696 L166_171 L203_207 0.0305
K7697 L166_171 L66_70 0.0323
K7698 L166_171 L117_122 0.0397
K7699 L166_171 L114_119 0.0568
K7700 L166_171 L158_189 0.0779
K7701 L166_171 L38_43 0.1706
K7702 L166_171 L47_51 0.0376
K7703 L166_171 L55_59 0.0395
K7704 L166_171 L135_174 0.1278
K7705 L166_171 L160_165 0.2112
K7706 L166_171 L52_56 0.0463
K7707 L166_171 L115_120 0.0617
K7708 L166_171 L80_85 0.0303
K7709 L166_171 L10_15 0.0479
K7710 L166_171 L16_21 0.0728
K7711 L166_171 L158_163 0.101
K7712 L166_171 L185_189 0.0685
K7713 L166_171 L96_100 0.0668
K7714 L166_171 L49_53 0.0534
K7715 L166_171 L186_190 0.0543
K7716 L166_171 L82_87 0.0463
K7717 L166_171 L125_130 0.0741
K7718 L166_171 L108_113 0.0448
K7719 L166_171 L159_164 0.0879
K7720 L166_171 L84_89 0.0609
K7721 L166_171 L68_72 0.0515
K7722 L166_171 L169_174 0.1566
K7723 L166_171 L204_208 0.0387
K7724 L166_171 L25_30 0.0853
K7725 L166_171 L133_172 0.1944
K7726 L166_171 L14_19 0.0668
K7727 L166_171 L44_92 0.086
K7728 L166_171 L21_26 0.0992
K7729 L166_171 L95_99 0.0699
K7730 L166_171 L116_121 0.0312
K7731 L166_171 L74_79 0.0728
K7732 L166_171 L165_170 0.3972
K7733 L166_171 L199_203 0.0312
K7734 L166_171 L75_80 0.031
K7735 L166_171 L143_148 0.0718
K7736 L166_171 L70_75 0.0317
K7737 L166_171 L50_54 0.0303
K7738 L166_171 L79_84 0.0664
K7739 L166_171 L56_60 0.0481
K7740 L166_171 L159_190 0.061
K7741 L166_171 L93_97 0.0593
K7742 L166_171 L134_173 0.159
K7743 L166_171 L139_144 0.0779
K7744 L166_171 L83_88 0.0564
K7745 L166_171 L177_181 0.0548
K7746 L166_171 L111_116 0.0305
K7747 L166_171 L162_167 0.1944
K7748 L166_171 L43_91 0.093
K7749 L166_171 L122_127 0.0407
K7750 L166_171 L135_140 0.0691
K7751 L166_171 L39_44 0.1463
K7752 L166_171 L123_128 0.0501
K7753 L166_171 L54_58 0.031
K7754 L166_171 L146_151 0.0617
K7755 L166_171 L61_65 0.0629
K7756 L166_171 L11_16 0.0664
K7757 L166_171 L77_82 0.0481
K7758 L132_171 L24_29 0.0696
K7759 L132_171 L181_185 0.0455
K7760 L132_171 L140_145 0.0895
K7761 L132_171 L1_6 0.0454
K7762 L132_171 L13_18 0.0503
K7763 L132_171 L35_40 0.1202
K7764 L132_171 L23_28 0.0717
K7765 L132_171 L73_78 0.0736
K7766 L132_171 L184_188 0.051
K7767 L132_171 L6_11 0.0486
K7768 L132_171 L163_168 0.101
K7769 L132_171 L91_95 0.1319
K7770 L132_171 L144_149 0.1049
K7771 L132_171 L130_160 0.0685
K7772 L132_171 L4_9 0.0415
K7773 L132_171 L202_206 0.0709
K7774 L132_171 L109_114 0.0458
K7775 L132_171 L57_61 0.0506
K7776 L132_171 L164_169 0.0879
K7777 L132_171 L195_199 0.0336
K7778 L132_171 L106_111 0.0275
K7779 L132_171 L34_39 0.1463
K7780 L132_171 L148_153 0.098
K7781 L132_171 L201_205 0.0534
K7782 L132_171 L53_57 0.048
K7783 L132_171 L69_73 0.0769
K7784 L132_171 L200_204 0.0424
K7785 L132_171 L150_155 0.0691
K7786 L132_171 L145_150 0.0787
K7787 L132_171 L30_35 0.0853
K7788 L132_171 L131_136 0.1156
K7789 L132_171 L101_105 0.0666
K7790 L132_171 L46_50 0.0274
K7791 L132_171 L196_200 0.0431
K7792 L132_171 L92_96 0.1139
K7793 L132_171 L81_86 0.0414
K7794 L132_171 L19_24 0.054
K7795 L132_171 L120_125 0.0526
K7796 L132_171 L8_13 0.0459
K7797 L132_171 L60_64 0.0446
K7798 L132_171 L198_202 0.0746
K7799 L132_171 L193_197 0.0563
K7800 L132_171 L167_172 0.1944
K7801 L132_171 L121_126 0.0297
K7802 L132_171 L97_101 0.075
K7803 L132_171 L110_115 0.0457
K7804 L132_171 L113_118 0.0415
K7805 L132_171 L141_146 0.0915
K7806 L132_171 L100_104 0.086
K7807 L132_171 L9_14 0.045
K7808 L132_171 L138_143 0.1482
K7809 L132_171 L33_38 0.1706
K7810 L132_171 L18_23 0.0555
K7811 L132_171 L134_139 0.1437
K7812 L132_171 L124_129 0.0537
K7813 L132_171 L107_112 0.0346
K7814 L132_171 L78_83 0.07
K7815 L132_171 L112_117 0.0357
K7816 L132_171 L40_45 0.1436
K7817 L132_171 L136_141 0.1027
K7818 L132_171 L59_63 0.0376
K7819 L132_171 L5_10 0.0339
K7820 L132_171 L71_76 0.0429
K7821 L132_171 L15_20 0.0398
K7822 L132_171 L51_55 0.0355
K7823 L132_171 L58_62 0.0296
K7824 L132_171 L67_71 0.0436
K7825 L132_171 L36_41 0.2588
K7826 L132_171 L48_52 0.0398
K7827 L132_171 L29_34 0.0976
K7828 L132_171 L206_210 0.0672
K7829 L132_171 L41_74 0.1107
K7830 L132_171 L131_170 0.3972
K7831 L132_171 L28_33 0.1038
K7832 L132_171 L205_209 0.0518
K7833 L132_171 L191_195 0.034
K7834 L132_171 L178_182 0.0342
K7835 L132_171 L180_184 0.0465
K7836 L132_171 L3_8 0.0422
K7837 L132_171 L157_162 0.073
K7838 L132_171 L149_154 0.0898
K7839 L132_171 L203_207 0.0325
K7840 L132_171 L66_70 0.0339
K7841 L132_171 L117_122 0.0367
K7842 L132_171 L114_119 0.0483
K7843 L132_171 L158_189 0.0548
K7844 L132_171 L38_43 0.2341
K7845 L132_171 L47_51 0.0345
K7846 L132_171 L55_59 0.0366
K7847 L132_171 L135_174 0.1566
K7848 L132_171 L160_165 0.1037
K7849 L132_171 L52_56 0.0413
K7850 L132_171 L115_120 0.0489
K7851 L132_171 L80_85 0.0323
K7852 L132_171 L10_15 0.0366
K7853 L132_171 L16_21 0.0562
K7854 L132_171 L158_163 0.0708
K7855 L132_171 L185_189 0.0498
K7856 L132_171 L96_100 0.0989
K7857 L132_171 L49_53 0.0456
K7858 L132_171 L186_190 0.0403
K7859 L132_171 L82_87 0.0515
K7860 L132_171 L125_130 0.0568
K7861 L132_171 L108_113 0.0399
K7862 L132_171 L159_164 0.0635
K7863 L132_171 L84_89 0.0803
K7864 L132_171 L68_72 0.0559
K7865 L132_171 L169_174 0.1278
K7866 L132_171 L204_208 0.0416
K7867 L132_171 L25_30 0.0625
K7868 L132_171 L133_172 0.2991
K7869 L132_171 L14_19 0.0491
K7870 L132_171 L44_92 0.1293
K7871 L132_171 L21_26 0.0672
K7872 L132_171 L95_99 0.1101
K7873 L132_171 L116_121 0.029
K7874 L132_171 L74_79 0.0992
K7875 L132_171 L165_170 0.2112
K7876 L132_171 L199_203 0.033
K7877 L132_171 L75_80 0.0329
K7878 L132_171 L143_148 0.1187
K7879 L132_171 L70_75 0.0334
K7880 L132_171 L50_54 0.0282
K7881 L132_171 L79_84 0.0891
K7882 L132_171 L56_60 0.043
K7883 L132_171 L159_190 0.0442
K7884 L132_171 L93_97 0.0842
K7885 L132_171 L134_173 0.2092
K7886 L132_171 L139_144 0.1233
K7887 L132_171 L83_88 0.0664
K7888 L132_171 L177_181 0.0419
K7889 L132_171 L111_116 0.0282
K7890 L132_171 L162_167 0.1081
K7891 L132_171 L43_91 0.1572
K7892 L132_171 L122_127 0.0377
K7893 L132_171 L135_140 0.1002
K7894 L132_171 L39_44 0.1838
K7895 L132_171 L123_128 0.0448
K7896 L132_171 L54_58 0.0289
K7897 L132_171 L146_151 0.082
K7898 L132_171 L61_65 0.0534
K7899 L132_171 L11_16 0.0521
K7900 L132_171 L77_82 0.0531
K7901 L75_76 L167_168 0.034
K7902 L75_76 L74_90 0.0321
K7903 L75_76 L115_179 0.0224
K7904 L75_76 L128_129 0.0436
K7905 L75_76 L196_197 0.1743
K7906 L75_76 L1_2 0.0185
K7907 L75_76 L23_24 0.0275
K7908 L75_76 L158_159 0.0266
K7909 L75_76 L136_198 0.0653
K7910 L75_76 L163_164 0.0307
K7911 L75_76 L120_183 0.0231
K7912 L75_76 L91_92 0.0289
K7913 L75_76 L160_161 0.0339
K7914 L75_76 L151_152 0.0316
K7915 L75_76 L126_127 0.0493
K7916 L75_76 L22_23 0.0284
K7917 L75_76 L204_205 0.1743
K7918 L75_76 L153_154 0.0279
K7919 L75_76 L4_5 0.017
K7920 L75_76 L34_35 0.0328
K7921 L75_76 L41_42 0.038
K7922 L75_76 L197_198 0.0969
K7923 L75_76 L191_192 0.2334
K7924 L75_76 L205_206 0.0969
K7925 L75_76 L36_37 0.0397
K7926 L75_76 L131_132 0.0378
K7927 L75_76 L100_101 0.0321
K7928 L75_76 L203_204 0.2659
K7929 L75_76 L92_93 0.0275
K7930 L75_76 L81_82 0.1933
K7931 L75_76 L13_14 0.0218
K7932 L75_76 L148_149 0.0339
K7933 L75_76 L19_20 0.0217
K7934 L75_76 L187_188 0.023
K7935 L75_76 L165_166 0.0368
K7936 L75_76 L102_103 0.0298
K7937 L75_76 L106_107 0.04
K7938 L75_76 L64_65 0.0438
K7939 L75_76 L8_9 0.0213
K7940 L75_76 L170_171 0.0395
K7941 L75_76 L193_194 0.0896
K7942 L75_76 L21_65 0.0387
K7943 L75_76 L121_122 0.0488
K7944 L75_76 L9_10 0.0207
K7945 L75_76 L195_196 0.2659
K7946 L75_76 L134_135 0.0326
K7947 L75_76 L41_69 0.0613
K7948 L75_76 L171_172 0.0377
K7949 L75_76 L104_105 0.0265
K7950 L75_76 L151_210 0.0602
K7951 L75_76 L138_139 0.0287
K7952 L75_76 L37_38 0.0379
K7953 L75_76 L98_99 0.0363
K7954 L75_76 L112_113 0.0425
K7955 L75_76 L183_184 0.0224
K7956 L75_76 L59_60 0.0477
K7957 L75_76 L11_57 0.0379
K7958 L75_76 L38_39 0.0362
K7959 L75_76 L71_72 0.1933
K7960 L75_76 L27_28 0.0329
K7961 L75_76 L114_115 0.0364
K7962 L75_76 L44_45 0.0327
K7963 L75_76 L47_48 0.0393
K7964 L75_76 L29_30 0.0307
K7965 L75_76 L166_167 0.0353
K7966 L75_76 L185_186 0.0211
K7967 L75_76 L177_178 0.017
K7968 L75_76 L16_17 0.0238
K7969 L75_76 L188_189 0.0223
K7970 L75_76 L86_87 0.1593
K7971 L75_76 L118_119 0.0418
K7972 L75_76 L176_177 0.0175
K7973 L75_76 L3_4 0.0175
K7974 L75_76 L6_53 0.0365
K7975 L75_76 L149_150 0.032
K7976 L75_76 L2_3 0.018
K7977 L75_76 L55_56 0.045
K7978 L75_76 L84_98 0.0387
K7979 L75_76 L48_49 0.0369
K7980 L75_76 L110_175 0.0184
K7981 L75_76 L124_125 0.0393
K7982 L75_76 L113_114 0.0399
K7983 L75_76 L52_53 0.04
K7984 L75_76 L80_81 0.3334
K7985 L75_76 L17_18 0.0231
K7986 L75_76 L87_88 0.0898
K7987 L75_76 L146_147 0.0385
K7988 L75_76 L209_210 0.0878
K7989 L75_76 L136_137 0.032
K7990 L75_76 L127_128 0.0477
K7991 L75_76 L42_43 0.0361
K7992 L75_76 L181_182 0.0206
K7993 L75_76 L28_29 0.0318
K7994 L75_76 L157_158 0.0274
K7995 L75_76 L122_123 0.0474
K7996 L75_76 L161_162 0.0328
K7997 L75_76 L66_67 0.2809
K7998 L75_76 L129_130 0.0386
K7999 L75_76 L21_22 0.0293
K8000 L75_76 L117_118 0.0448
K8001 L75_76 L51_52 0.0427
K8002 L75_76 L56_57 0.0419
K8003 L75_76 L24_25 0.0267
K8004 L75_76 L116_117 0.046
K8005 L75_76 L6_7 0.0225
K8006 L75_76 L173_174 0.0346
K8007 L75_76 L154_155 0.0264
K8008 L75_76 L32_33 0.0355
K8009 L75_76 L103_104 0.0281
K8010 L75_76 L85_86 0.2387
K8011 L75_76 L7_8 0.0219
K8012 L75_76 L82_83 0.0993
K8013 L75_76 L14_15 0.0212
K8014 L75_76 L184_185 0.0218
K8015 L75_76 L147_148 0.0361
K8016 L75_76 L62_63 0.0496
K8017 L75_76 L125_187 0.0237
K8018 L75_76 L58_59 0.0491
K8019 L75_76 L70_71 0.3334
K8020 L75_76 L68_69 0.0917
K8021 L75_76 L180_181 0.0212
K8022 L75_76 L89_102 0.0318
K8023 L75_76 L26_27 0.034
K8024 L75_76 L50_51 0.0437
K8025 L75_76 L168_169 0.0327
K8026 L75_76 L83_84 0.066
K8027 L75_76 L90_91 0.0304
K8028 L75_76 L139_140 0.0274
K8029 L75_76 L111_112 0.0435
K8030 L75_76 L162_163 0.0317
K8031 L75_76 L137_138 0.0303
K8032 L75_76 L179_180 0.0218
K8033 L75_76 L12_13 0.0225
K8034 L75_76 L207_208 0.2081
K8035 L75_76 L123_124 0.0439
K8036 L75_76 L152_153 0.0297
K8037 L75_76 L39_40 0.0347
K8038 L75_76 L18_19 0.0224
K8039 L75_76 L130_156 0.0292
K8040 L75_76 L156_157 0.0283
K8041 L75_76 L189_190 0.0217
K8042 L75_76 L11_12 0.0231
K8043 L75_76 L54_55 0.0462
K8044 L24_25 L167_168 0.0865
K8045 L24_25 L74_90 0.0331
K8046 L24_25 L115_179 0.0868
K8047 L24_25 L196_197 0.0311
K8048 L24_25 L1_2 0.0725
K8049 L24_25 L102_103 0.0233
K8050 L24_25 L136_198 0.0405
K8051 L24_25 L163_164 0.1425
K8052 L24_25 L144_145 0.0314
K8053 L24_25 L120_183 0.1001
K8054 L24_25 L91_92 0.0337
K8055 L24_25 L160_161 0.1183
K8056 L24_25 L151_152 0.023
K8057 L24_25 L146_147 0.029
K8058 L24_25 L204_205 0.0293
K8059 L24_25 L153_154 0.0233
K8060 L24_25 L4_5 0.0863
K8061 L24_25 L34_35 0.0897
K8062 L24_25 L41_42 0.0446
K8063 L24_25 L197_198 0.0356
K8064 L24_25 L143_144 0.0313
K8065 L24_25 L200_201 0.0302
K8066 L24_25 L205_206 0.033
K8067 L24_25 L36_37 0.0609
K8068 L24_25 L131_132 0.0442
K8069 L24_25 L100_101 0.0297
K8070 L24_25 L203_204 0.026
K8071 L24_25 L92_93 0.0338
K8072 L24_25 L81_82 0.0293
K8073 L24_25 L13_14 0.1375
K8074 L24_25 L148_149 0.0294
K8075 L24_25 L19_20 0.2069
K8076 L24_25 L187_188 0.136
K8077 L24_25 L165_166 0.081
K8078 L24_25 L106_107 0.0351
K8079 L24_25 L8_9 0.1076
K8080 L24_25 L170_171 0.0602
K8081 L24_25 L193_194 0.0342
K8082 L24_25 L141_142 0.0308
K8083 L24_25 L121_122 0.0387
K8084 L24_25 L195_196 0.0272
K8085 L24_25 L134_135 0.0454
K8086 L24_25 L41_69 0.0395
K8087 L24_25 L171_172 0.0615
K8088 L24_25 L104_105 0.0235
K8089 L24_25 L151_210 0.033
K8090 L24_25 L79_94 0.031
K8091 L24_25 L37_38 0.0623
K8092 L24_25 L112_113 0.048
K8093 L24_25 L183_184 0.1128
K8094 L24_25 L59_60 0.0501
K8095 L24_25 L11_57 0.1069
K8096 L24_25 L38_39 0.0632
K8097 L24_25 L71_72 0.0312
K8098 L24_25 L27_28 0.1386
K8099 L24_25 L96_97 0.0316
K8100 L24_25 L78_79 0.0387
K8101 L24_25 L44_45 0.0458
K8102 L24_25 L47_48 0.0448
K8103 L24_25 L29_30 0.1549
K8104 L24_25 L76_77 0.0303
K8105 L24_25 L166_167 0.0843
K8106 L24_25 L185_186 0.1276
K8107 L24_25 L177_178 0.081
K8108 L24_25 L16_17 0.1261
K8109 L24_25 L188_189 0.1556
K8110 L24_25 L86_87 0.0267
K8111 L24_25 L118_119 0.0673
K8112 L24_25 L176_177 0.0794
K8113 L24_25 L3_4 0.0843
K8114 L24_25 L6_53 0.0975
K8115 L24_25 L149_150 0.0295
K8116 L24_25 L2_3 0.0792
K8117 L24_25 L98_99 0.0294
K8118 L24_25 L55_56 0.0493
K8119 L24_25 L184_185 0.1234
K8120 L24_25 L84_98 0.0292
K8121 L24_25 L48_49 0.0606
K8122 L24_25 L110_175 0.0694
K8123 L24_25 L124_125 0.1114
K8124 L24_25 L113_114 0.0648
K8125 L24_25 L52_53 0.0656
K8126 L24_25 L80_81 0.026
K8127 L24_25 L17_18 0.1555
K8128 L24_25 L141_202 0.0385
K8129 L24_25 L87_88 0.03
K8130 L24_25 L209_210 0.0299
K8131 L24_25 L94_95 0.0313
K8132 L24_25 L136_137 0.0328
K8133 L24_25 L138_139 0.0335
K8134 L24_25 L42_43 0.0453
K8135 L24_25 L181_182 0.1029
K8136 L24_25 L28_29 0.1502
K8137 L24_25 L122_123 0.0498
K8138 L24_25 L103_104 0.0235
K8139 L24_25 L66_67 0.0259
K8140 L24_25 L9_10 0.1104
K8141 L24_25 L117_118 0.049
K8142 L24_25 L51_52 0.0483
K8143 L24_25 L56_57 0.0683
K8144 L24_25 L114_115 0.0946
K8145 L24_25 L116_117 0.0383
K8146 L24_25 L6_7 0.091
K8147 L24_25 L173_174 0.0627
K8148 L24_25 L154_155 0.0234
K8149 L24_25 L32_33 0.0864
K8150 L24_25 L95_96 0.0315
K8151 L24_25 L85_86 0.0238
K8152 L24_25 L7_8 0.1004
K8153 L24_25 L82_83 0.0331
K8154 L24_25 L14_15 0.1436
K8155 L24_25 L147_148 0.0293
K8156 L24_25 L199_200 0.0266
K8157 L24_25 L125_187 0.1153
K8158 L24_25 L58_59 0.0389
K8159 L24_25 L70_71 0.0273
K8160 L24_25 L68_69 0.0344
K8161 L24_25 L180_181 0.1006
K8162 L24_25 L89_102 0.0231
K8163 L24_25 L26_27 0.1245
K8164 L24_25 L50_51 0.038
K8165 L24_25 L168_169 0.0873
K8166 L24_25 L83_84 0.0369
K8167 L24_25 L90_91 0.0334
K8168 L24_25 L139_140 0.0335
K8169 L24_25 L161_162 0.1299
K8170 L24_25 L111_112 0.0378
K8171 L24_25 L162_163 0.1389
K8172 L24_25 L137_138 0.0332
K8173 L24_25 L179_180 0.0947
K8174 L24_25 L12_13 0.1231
K8175 L24_25 L207_208 0.0238
K8176 L24_25 L142_143 0.0311
K8177 L24_25 L123_124 0.0694
K8178 L24_25 L152_153 0.0232
K8179 L24_25 L191_192 0.0258
K8180 L24_25 L39_40 0.0635
K8181 L24_25 L18_19 0.1891
K8182 L24_25 L189_190 0.1644
K8183 L24_25 L11_12 0.1069
K8184 L24_25 L54_55 0.0385
K8185 L24_25 L201_202 0.0343
K8186 L71_76 L181_185 0.0239
K8187 L71_76 L140_145 0.0249
K8188 L71_76 L1_6 0.0336
K8189 L71_76 L13_18 0.0254
K8190 L71_76 L35_40 0.0331
K8191 L71_76 L23_28 0.0335
K8192 L71_76 L73_78 0.0744
K8193 L71_76 L6_11 0.0348
K8194 L71_76 L163_168 0.0347
K8195 L71_76 L91_95 0.0331
K8196 L71_76 L144_149 0.0312
K8197 L71_76 L130_160 0.0327
K8198 L71_76 L4_9 0.0233
K8199 L71_76 L202_206 0.0734
K8200 L71_76 L109_114 0.042
K8201 L71_76 L57_61 0.0457
K8202 L71_76 L164_169 0.0311
K8203 L71_76 L195_199 0.1437
K8204 L71_76 L106_111 0.0405
K8205 L71_76 L34_39 0.037
K8206 L71_76 L148_153 0.0328
K8207 L71_76 L201_205 0.1104
K8208 L71_76 L9_14 0.0239
K8209 L71_76 L53_57 0.0439
K8210 L71_76 L69_73 0.0741
K8211 L71_76 L205_209 0.1076
K8212 L71_76 L150_155 0.0248
K8213 L71_76 L145_150 0.0249
K8214 L71_76 L30_35 0.0312
K8215 L71_76 L131_136 0.0503
K8216 L71_76 L101_105 0.0249
K8217 L71_76 L46_50 0.0406
K8218 L71_76 L92_96 0.0314
K8219 L71_76 L19_24 0.0252
K8220 L71_76 L120_125 0.0358
K8221 L71_76 L8_13 0.0247
K8222 L71_76 L60_64 0.0543
K8223 L71_76 L198_202 0.0736
K8224 L71_76 L193_197 0.1104
K8225 L71_76 L7_12 0.0255
K8226 L71_76 L137_142 0.0349
K8227 L71_76 L167_172 0.0386
K8228 L71_76 L121_126 0.0481
K8229 L71_76 L97_101 0.025
K8230 L71_76 L110_115 0.0336
K8231 L71_76 L141_146 0.0503
K8232 L71_76 L100_104 0.0312
K8233 L71_76 L24_29 0.0323
K8234 L71_76 L138_143 0.033
K8235 L71_76 L33_38 0.0388
K8236 L71_76 L18_23 0.0261
K8237 L71_76 L124_129 0.0474
K8238 L71_76 L78_83 0.0741
K8239 L71_76 L134_139 0.0312
K8240 L71_76 L40_45 0.0346
K8241 L71_76 L183_187 0.0262
K8242 L71_76 L136_141 0.0504
K8243 L71_76 L5_10 0.0189
K8244 L71_76 L15_20 0.0199
K8245 L71_76 L58_62 0.0484
K8246 L71_76 L36_41 0.0415
K8247 L71_76 L48_52 0.0466
K8248 L71_76 L29_34 0.0348
K8249 L71_76 L179_183 0.0254
K8250 L71_76 L158_189 0.0251
K8251 L71_76 L206_210 0.0726
K8252 L71_76 L41_74 0.0506
K8253 L71_76 L131_170 0.0413
K8254 L71_76 L28_33 0.0362
K8255 L71_76 L191_195 0.1405
K8256 L71_76 L66_70 0.1506
K8257 L71_76 L98_102 0.0349
K8258 L71_76 L27_32 0.0377
K8259 L71_76 L147_152 0.0347
K8260 L71_76 L178_182 0.0189
K8261 L71_76 L180_184 0.0246
K8262 L71_76 L3_8 0.024
K8263 L71_76 L157_162 0.0334
K8264 L71_76 L149_154 0.0311
K8265 L71_76 L203_207 0.1322
K8266 L71_76 L2_7 0.0247
K8267 L71_76 L22_27 0.0346
K8268 L71_76 L38_43 0.0409
K8269 L71_76 L113_118 0.0487
K8270 L71_76 L108_113 0.0464
K8271 L71_76 L135_174 0.0345
K8272 L71_76 L94_98 0.0351
K8273 L71_76 L160_165 0.0358
K8274 L71_76 L52_56 0.0489
K8275 L71_76 L115_120 0.0347
K8276 L71_76 L80_85 0.1402
K8277 L71_76 L10_15 0.0194
K8278 L71_76 L16_21 0.0371
K8279 L71_76 L158_163 0.0322
K8280 L71_76 L185_189 0.0245
K8281 L71_76 L96_100 0.0313
K8282 L71_76 L49_53 0.0421
K8283 L71_76 L186_190 0.0198
K8284 L71_76 L156_161 0.0345
K8285 L71_76 L82_87 0.1103
K8286 L71_76 L125_130 0.037
K8287 L71_76 L184_188 0.0253
K8288 L71_76 L159_164 0.029
K8289 L71_76 L84_89 0.0503
K8290 L71_76 L68_72 0.1134
K8291 L71_76 L169_174 0.033
K8292 L71_76 L25_30 0.0291
K8293 L71_76 L32_37 0.0407
K8294 L71_76 L133_172 0.0407
K8295 L71_76 L14_19 0.0246
K8296 L71_76 L44_92 0.0313
K8297 L71_76 L161_166 0.0376
K8298 L71_76 L21_26 0.0328
K8299 L71_76 L95_99 0.0331
K8300 L71_76 L116_121 0.0453
K8301 L71_76 L74_79 0.0507
K8302 L71_76 L165_170 0.0388
K8303 L71_76 L199_203 0.1405
K8304 L71_76 L75_80 0.1506
K8305 L71_76 L143_148 0.0329
K8306 L71_76 L70_75 0.1548
K8307 L71_76 L50_54 0.043
K8308 L71_76 L79_84 0.0506
K8309 L71_76 L56_60 0.0515
K8310 L71_76 L159_190 0.0203
K8311 L71_76 L93_97 0.025
K8312 L71_76 L90_94 0.0351
K8313 L71_76 L134_173 0.0387
K8314 L71_76 L139_144 0.0313
K8315 L71_76 L83_88 0.0733
K8316 L71_76 L177_181 0.0233
K8317 L71_76 L111_116 0.0427
K8318 L71_76 L162_167 0.0361
K8319 L71_76 L43_91 0.0331
K8320 L71_76 L142_147 0.0349
K8321 L71_76 L135_140 0.0249
K8322 L71_76 L39_44 0.0389
K8323 L71_76 L123_128 0.054
K8324 L71_76 L12_17 0.0262
K8325 L71_76 L54_58 0.0455
K8326 L71_76 L146_151 0.05
K8327 L71_76 L114_119 0.0437
K8328 L71_76 L61_65 0.0476
K8329 L71_76 L11_16 0.0359
K8330 L71_76 L77_82 0.1134
K8331 L120_183 L167_168 0.0595
K8332 L120_183 L74_90 0.025
K8333 L120_183 L199_200 0.0231
K8334 L120_183 L115_179 0.2054
K8335 L120_183 L128_129 0.0538
K8336 L120_183 L147_148 0.0223
K8337 L120_183 L196_197 0.0269
K8338 L120_183 L1_2 0.1183
K8339 L120_183 L23_24 0.1128
K8340 L120_183 L158_159 0.1069
K8341 L120_183 L136_198 0.0333
K8342 L120_183 L163_164 0.0821
K8343 L120_183 L144_145 0.0233
K8344 L120_183 L91_92 0.0248
K8345 L120_183 L160_161 0.0927
K8346 L120_183 L151_152 0.0178
K8347 L120_183 L126_127 0.0298
K8348 L120_183 L22_23 0.1234
K8349 L120_183 L204_205 0.0251
K8350 L120_183 L153_154 0.0177
K8351 L120_183 L4_5 0.0814
K8352 L120_183 L34_35 0.0569
K8353 L120_183 L41_42 0.0335
K8354 L120_183 L197_198 0.0303
K8355 L120_183 L143_144 0.0235
K8356 L120_183 L200_201 0.026
K8357 L120_183 L205_206 0.0277
K8358 L120_183 L36_37 0.0451
K8359 L120_183 L131_132 0.0338
K8360 L120_183 L100_101 0.022
K8361 L120_183 L203_204 0.0225
K8362 L120_183 L92_93 0.0246
K8363 L120_183 L81_82 0.025
K8364 L120_183 L148_149 0.0222
K8365 L120_183 L19_20 0.1015
K8366 L120_183 L187_188 0.1832
K8367 L120_183 L165_166 0.061
K8368 L120_183 L102_103 0.0177
K8369 L120_183 L106_107 0.036
K8370 L120_183 L64_65 0.053
K8371 L120_183 L26_27 0.0888
K8372 L120_183 L170_171 0.0456
K8373 L120_183 L193_194 0.0292
K8374 L120_183 L21_65 0.0842
K8375 L120_183 L121_122 0.0321
K8376 L120_183 L9_10 0.1015
K8377 L120_183 L195_196 0.0238
K8378 L120_183 L134_135 0.0331
K8379 L120_183 L41_69 0.0322
K8380 L120_183 L171_172 0.0454
K8381 L120_183 L104_105 0.0175
K8382 L120_183 L151_210 0.0269
K8383 L120_183 L138_139 0.025
K8384 L120_183 L37_38 0.045
K8385 L120_183 L112_113 0.0533
K8386 L120_183 L59_60 0.0413
K8387 L120_183 L129_130 0.0877
K8388 L120_183 L38_39 0.0445
K8389 L120_183 L71_72 0.0269
K8390 L120_183 L27_28 0.0876
K8391 L120_183 L96_97 0.0232
K8392 L120_183 L78_79 0.0314
K8393 L120_183 L44_45 0.0328
K8394 L120_183 L47_48 0.0489
K8395 L120_183 L29_30 0.0795
K8396 L120_183 L76_77 0.0259
K8397 L120_183 L114_115 0.1855
K8398 L120_183 L166_167 0.0606
K8399 L120_183 L177_178 0.0895
K8400 L120_183 L16_17 0.1536
K8401 L120_183 L188_189 0.1439
K8402 L120_183 L86_87 0.0227
K8403 L120_183 L176_177 0.1116
K8404 L120_183 L3_4 0.0969
K8405 L120_183 L149_150 0.0221
K8406 L120_183 L2_3 0.1117
K8407 L120_183 L98_99 0.0222
K8408 L120_183 L6_53 0.1583
K8409 L120_183 L84_98 0.0223
K8410 L120_183 L48_49 0.0758
K8411 L120_183 L110_175 0.1487
K8412 L120_183 L124_125 0.0996
K8413 L120_183 L113_114 0.0851
K8414 L120_183 L52_53 0.0822
K8415 L120_183 L80_81 0.0224
K8416 L120_183 L17_18 0.1438
K8417 L120_183 L141_202 0.0315
K8418 L120_183 L87_88 0.0249
K8419 L120_183 L146_147 0.0224
K8420 L120_183 L209_210 0.025
K8421 L120_183 L94_95 0.0235
K8422 L120_183 L136_137 0.0252
K8423 L120_183 L127_128 0.0384
K8424 L120_183 L42_43 0.0335
K8425 L120_183 L181_182 0.1124
K8426 L120_183 L28_29 0.0843
K8427 L120_183 L157_158 0.1231
K8428 L120_183 L122_123 0.0416
K8429 L120_183 L103_104 0.0176
K8430 L120_183 L66_67 0.0226
K8431 L120_183 L21_22 0.1276
K8432 L120_183 L51_52 0.0527
K8433 L120_183 L79_94 0.0236
K8434 L120_183 L6_7 0.1536
K8435 L120_183 L173_174 0.0442
K8436 L120_183 L154_155 0.0176
K8437 L120_183 L32_33 0.0596
K8438 L120_183 L95_96 0.0234
K8439 L120_183 L85_86 0.0205
K8440 L120_183 L7_8 0.1438
K8441 L120_183 L82_83 0.0276
K8442 L120_183 L58_59 0.032
K8443 L120_183 L141_142 0.0237
K8444 L120_183 L62_63 0.0297
K8445 L120_183 L125_187 0.2054
K8446 L120_183 L70_71 0.0237
K8447 L120_183 L68_69 0.0291
K8448 L120_183 L180_181 0.1439
K8449 L120_183 L89_102 0.0177
K8450 L120_183 L8_9 0.1226
K8451 L120_183 L50_51 0.0385
K8452 L120_183 L168_169 0.0578
K8453 L120_183 L83_84 0.0298
K8454 L120_183 L90_91 0.025
K8455 L120_183 L139_140 0.0247
K8456 L120_183 L161_162 0.0913
K8457 L120_183 L111_112 0.0387
K8458 L120_183 L162_163 0.0875
K8459 L120_183 L137_138 0.0251
K8460 L120_183 L179_180 0.1832
K8461 L120_183 L207_208 0.0205
K8462 L120_183 L142_143 0.0237
K8463 L120_183 L123_124 0.0589
K8464 L120_183 L152_153 0.0178
K8465 L120_183 L191_192 0.0227
K8466 L120_183 L39_40 0.0438
K8467 L120_183 L130_156 0.1436
K8468 L120_183 L156_157 0.1375
K8469 L120_183 L189_190 0.1124
K8470 L120_183 L18_19 0.1226
K8471 L120_183 L201_202 0.0289
K8472 L71_72 L167_168 0.0412
K8473 L71_72 L199_200 0.1743
K8474 L71_72 L115_179 0.0259
K8475 L71_72 L128_129 0.0508
K8476 L71_72 L147_148 0.0474
K8477 L71_72 L95_96 0.0449
K8478 L71_72 L143_144 0.0445
K8479 L71_72 L1_2 0.0213
K8480 L71_72 L23_24 0.0323
K8481 L71_72 L158_159 0.0311
K8482 L71_72 L163_164 0.0362
K8483 L71_72 L144_145 0.0413
K8484 L71_72 L160_161 0.0406
K8485 L71_72 L151_152 0.0418
K8486 L71_72 L126_127 0.0508
K8487 L71_72 L22_23 0.0334
K8488 L71_72 L204_205 0.2117
K8489 L71_72 L153_154 0.0357
K8490 L71_72 L4_5 0.0196
K8491 L71_72 L34_35 0.0396
K8492 L71_72 L41_42 0.0493
K8493 L71_72 L201_202 0.1743
K8494 L71_72 L191_192 0.1765
K8495 L71_72 L200_201 0.2659
K8496 L71_72 L205_206 0.1537
K8497 L71_72 L36_37 0.0503
K8498 L71_72 L131_132 0.049
K8499 L71_72 L100_101 0.041
K8500 L71_72 L203_204 0.1537
K8501 L71_72 L81_82 0.2392
K8502 L71_72 L13_14 0.0253
K8503 L71_72 L148_149 0.0438
K8504 L71_72 L19_20 0.0253
K8505 L71_72 L187_188 0.027
K8506 L71_72 L165_166 0.0452
K8507 L71_72 L102_103 0.0389
K8508 L71_72 L106_107 0.0412
K8509 L71_72 L64_65 0.0512
K8510 L71_72 L8_9 0.0245
K8511 L71_72 L170_171 0.05
K8512 L71_72 L193_194 0.1765
K8513 L71_72 L21_65 0.0462
K8514 L71_72 L121_122 0.0504
K8515 L71_72 L9_10 0.0238
K8516 L71_72 L134_135 0.0405
K8517 L71_72 L41_69 0.0947
K8518 L71_72 L171_172 0.0472
K8519 L71_72 L104_105 0.0335
K8520 L71_72 L151_210 0.0837
K8521 L71_72 L79_94 0.0533
K8522 L71_72 L37_38 0.0475
K8523 L71_72 L112_113 0.046
K8524 L71_72 L183_184 0.026
K8525 L71_72 L59_60 0.0523
K8526 L71_72 L11_57 0.0441
K8527 L71_72 L38_39 0.0449
K8528 L71_72 L27_28 0.0392
K8529 L71_72 L78_79 0.0993
K8530 L71_72 L44_45 0.0407
K8531 L71_72 L47_48 0.0425
K8532 L71_72 L29_30 0.0363
K8533 L71_72 L76_77 0.3334
K8534 L71_72 L114_115 0.0418
K8535 L71_72 L166_167 0.0432
K8536 L71_72 L185_186 0.0245
K8537 L71_72 L177_178 0.0195
K8538 L71_72 L16_17 0.028
K8539 L71_72 L188_189 0.0261
K8540 L71_72 L86_87 0.1829
K8541 L71_72 L118_119 0.0474
K8542 L71_72 L176_177 0.0201
K8543 L71_72 L3_4 0.0201
K8544 L71_72 L6_53 0.0419
K8545 L71_72 L149_150 0.0407
K8546 L71_72 L2_3 0.0207
K8547 L71_72 L98_99 0.0478
K8548 L71_72 L55_56 0.0491
K8549 L71_72 L84_98 0.0521
K8550 L71_72 L48_49 0.0414
K8551 L71_72 L110_175 0.0213
K8552 L71_72 L124_125 0.0461
K8553 L71_72 L113_114 0.0448
K8554 L71_72 L52_53 0.045
K8555 L71_72 L80_81 0.1646
K8556 L71_72 L17_18 0.027
K8557 L71_72 L141_202 0.0969
K8558 L71_72 L87_88 0.1369
K8559 L71_72 L146_147 0.0515
K8560 L71_72 L209_210 0.13
K8561 L71_72 L94_95 0.0488
K8562 L71_72 L127_128 0.0528
K8563 L71_72 L42_43 0.0461
K8564 L71_72 L181_182 0.0238
K8565 L71_72 L28_29 0.0377
K8566 L71_72 L157_158 0.0322
K8567 L71_72 L122_123 0.052
K8568 L71_72 L96_97 0.0416
K8569 L71_72 L66_67 0.2045
K8570 L71_72 L129_130 0.0459
K8571 L71_72 L21_22 0.0346
K8572 L71_72 L117_118 0.0488
K8573 L71_72 L51_52 0.0462
K8574 L71_72 L56_57 0.0477
K8575 L71_72 L116_117 0.0474
K8576 L71_72 L6_7 0.026
K8577 L71_72 L173_174 0.0424
K8578 L71_72 L154_155 0.0333
K8579 L71_72 L32_33 0.0434
K8580 L71_72 L103_104 0.036
K8581 L71_72 L85_86 0.1369
K8582 L71_72 L7_8 0.0252
K8583 L71_72 L82_83 0.1646
K8584 L71_72 L14_15 0.0245
K8585 L71_72 L184_185 0.0253
K8586 L71_72 L141_142 0.0527
K8587 L71_72 L62_63 0.0512
K8588 L71_72 L125_187 0.0279
K8589 L71_72 L58_59 0.0506
K8590 L71_72 L68_69 0.2045
K8591 L71_72 L180_181 0.0245
K8592 L71_72 L89_102 0.0423
K8593 L71_72 L26_27 0.0407
K8594 L71_72 L50_51 0.045
K8595 L71_72 L168_169 0.0394
K8596 L71_72 L83_84 0.0952
K8597 L71_72 L161_162 0.039
K8598 L71_72 L111_112 0.0448
K8599 L71_72 L162_163 0.0376
K8600 L71_72 L179_180 0.0252
K8601 L71_72 L12_13 0.0261
K8602 L71_72 L207_208 0.13
K8603 L71_72 L142_143 0.0482
K8604 L71_72 L123_124 0.0504
K8605 L71_72 L152_153 0.0385
K8606 L71_72 L39_40 0.0426
K8607 L71_72 L18_19 0.0262
K8608 L71_72 L130_156 0.0344
K8609 L71_72 L156_157 0.0333
K8610 L71_72 L189_190 0.0252
K8611 L71_72 L11_12 0.0269
K8612 L71_72 L54_55 0.0477
K8613 L147_148 L167_168 0.0454
K8614 L147_148 L74_90 0.1127
K8615 L147_148 L199_200 0.0363
K8616 L147_148 L115_179 0.0212
K8617 L147_148 L128_129 0.0301
K8618 L147_148 L196_197 0.0478
K8619 L147_148 L1_2 0.0172
K8620 L147_148 L23_24 0.0294
K8621 L147_148 L158_159 0.0294
K8622 L147_148 L136_198 0.1252
K8623 L147_148 L163_164 0.0361
K8624 L147_148 L144_145 0.1439
K8625 L147_148 L91_92 0.1127
K8626 L147_148 L160_161 0.0363
K8627 L147_148 L151_152 0.1673
K8628 L147_148 L126_127 0.0238
K8629 L147_148 L22_23 0.0295
K8630 L147_148 L138_139 0.1284
K8631 L147_148 L153_154 0.1673
K8632 L147_148 L4_5 0.0172
K8633 L147_148 L34_35 0.0445
K8634 L147_148 L41_42 0.0844
K8635 L147_148 L197_198 0.071
K8636 L147_148 L143_144 0.1832
K8637 L147_148 L200_201 0.0488
K8638 L147_148 L36_37 0.0596
K8639 L147_148 L131_132 0.0883
K8640 L147_148 L122_123 0.0275
K8641 L147_148 L92_93 0.1015
K8642 L147_148 L13_14 0.0222
K8643 L147_148 L19_20 0.0234
K8644 L147_148 L187_188 0.0237
K8645 L147_148 L102_103 0.1363
K8646 L147_148 L106_107 0.0213
K8647 L147_148 L64_65 0.03
K8648 L147_148 L8_9 0.0211
K8649 L147_148 L170_171 0.0606
K8650 L147_148 L193_194 0.0653
K8651 L147_148 L21_65 0.0323
K8652 L147_148 L121_122 0.0245
K8653 L147_148 L9_10 0.021
K8654 L147_148 L195_196 0.0359
K8655 L147_148 L134_135 0.0842
K8656 L147_148 L41_69 0.1049
K8657 L147_148 L171_172 0.061
K8658 L147_148 L104_105 0.1062
K8659 L147_148 L151_210 0.0803
K8660 L147_148 L79_94 0.1438
K8661 L147_148 L37_38 0.0599
K8662 L147_148 L112_113 0.0254
K8663 L147_148 L183_184 0.0224
K8664 L147_148 L59_60 0.0274
K8665 L147_148 L11_57 0.0306
K8666 L147_148 L38_39 0.0596
K8667 L147_148 L27_28 0.0362
K8668 L147_148 L96_97 0.1226
K8669 L147_148 L78_79 0.133
K8670 L147_148 L44_45 0.0808
K8671 L147_148 L47_48 0.0234
K8672 L147_148 L29_30 0.0359
K8673 L147_148 L76_77 0.0482
K8674 L147_148 L166_167 0.0456
K8675 L147_148 L185_186 0.0222
K8676 L147_148 L177_178 0.0172
K8677 L147_148 L16_17 0.0235
K8678 L147_148 L188_189 0.0237
K8679 L147_148 L86_87 0.036
K8680 L147_148 L118_119 0.0289
K8681 L147_148 L176_177 0.0173
K8682 L147_148 L3_4 0.0172
K8683 L147_148 L6_53 0.029
K8684 L147_148 L2_3 0.0173
K8685 L147_148 L55_56 0.0263
K8686 L147_148 L113_114 0.0276
K8687 L147_148 L48_49 0.0253
K8688 L147_148 L110_175 0.0173
K8689 L147_148 L124_125 0.0324
K8690 L147_148 L114_115 0.0291
K8691 L147_148 L52_53 0.0275
K8692 L147_148 L17_18 0.0236
K8693 L147_148 L141_202 0.1476
K8694 L147_148 L87_88 0.0493
K8695 L147_148 L209_210 0.05
K8696 L147_148 L94_95 0.1536
K8697 L147_148 L136_137 0.1284
K8698 L147_148 L127_128 0.027
K8699 L147_148 L42_43 0.0857
K8700 L147_148 L181_182 0.0211
K8701 L147_148 L28_29 0.0361
K8702 L147_148 L157_158 0.0296
K8703 L147_148 L95_96 0.1438
K8704 L147_148 L66_67 0.0332
K8705 L147_148 L129_130 0.0325
K8706 L147_148 L21_22 0.0294
K8707 L147_148 L117_118 0.0264
K8708 L147_148 L51_52 0.0253
K8709 L147_148 L56_57 0.0288
K8710 L147_148 L116_117 0.0237
K8711 L147_148 L6_7 0.0211
K8712 L147_148 L173_174 0.0595
K8713 L147_148 L32_33 0.0451
K8714 L147_148 L103_104 0.1266
K8715 L147_148 L85_86 0.0283
K8716 L147_148 L7_8 0.0211
K8717 L147_148 L154_155 0.1268
K8718 L147_148 L14_15 0.0221
K8719 L147_148 L184_185 0.0223
K8720 L147_148 L141_142 0.1832
K8721 L147_148 L62_63 0.0237
K8722 L147_148 L125_187 0.0237
K8723 L147_148 L58_59 0.0245
K8724 L147_148 L70_71 0.0357
K8725 L147_148 L68_69 0.0639
K8726 L147_148 L180_181 0.0212
K8727 L147_148 L89_102 0.1266
K8728 L147_148 L26_27 0.0361
K8729 L147_148 L50_51 0.0229
K8730 L147_148 L168_169 0.045
K8731 L147_148 L165_166 0.0454
K8732 L147_148 L90_91 0.1173
K8733 L147_148 L139_140 0.1124
K8734 L147_148 L161_162 0.0364
K8735 L147_148 L111_112 0.023
K8736 L147_148 L162_163 0.0363
K8737 L147_148 L137_138 0.1354
K8738 L147_148 L179_180 0.0212
K8739 L147_148 L12_13 0.0223
K8740 L147_148 L207_208 0.0284
K8741 L147_148 L142_143 0.2054
K8742 L147_148 L123_124 0.0303
K8743 L147_148 L152_153 0.1916
K8744 L147_148 L191_192 0.0334
K8745 L147_148 L39_40 0.0585
K8746 L147_148 L18_19 0.0235
K8747 L147_148 L130_156 0.0296
K8748 L147_148 L156_157 0.0297
K8749 L147_148 L189_190 0.0235
K8750 L147_148 L11_12 0.0222
K8751 L147_148 L54_55 0.0237
K8752 L147_148 L201_202 0.0741
K8753 L36_41 L181_185 0.0413
K8754 L36_41 L140_145 0.0748
K8755 L36_41 L13_18 0.0468
K8756 L36_41 L35_40 0.1129
K8757 L36_41 L23_28 0.067
K8758 L36_41 L73_78 0.0735
K8759 L36_41 L184_188 0.0462
K8760 L36_41 L163_168 0.0885
K8761 L36_41 L91_95 0.1305
K8762 L36_41 L144_149 0.0887
K8763 L36_41 L4_9 0.0385
K8764 L36_41 L202_206 0.0685
K8765 L36_41 L109_114 0.0431
K8766 L36_41 L57_61 0.0484
K8767 L36_41 L164_169 0.0772
K8768 L36_41 L195_199 0.0321
K8769 L36_41 L158_189 0.0494
K8770 L36_41 L106_111 0.026
K8771 L36_41 L34_39 0.1398
K8772 L36_41 L148_153 0.0844
K8773 L36_41 L201_205 0.0514
K8774 L36_41 L53_57 0.0458
K8775 L36_41 L69_73 0.0775
K8776 L36_41 L200_204 0.0405
K8777 L36_41 L150_155 0.0601
K8778 L36_41 L145_150 0.0672
K8779 L36_41 L30_35 0.0795
K8780 L36_41 L101_105 0.0622
K8781 L36_41 L46_50 0.0261
K8782 L36_41 L196_200 0.0413
K8783 L36_41 L92_96 0.1087
K8784 L36_41 L81_86 0.0399
K8785 L36_41 L19_24 0.0502
K8786 L36_41 L8_13 0.0427
K8787 L36_41 L60_64 0.0428
K8788 L36_41 L198_202 0.0724
K8789 L36_41 L193_197 0.0544
K8790 L36_41 L7_12 0.0433
K8791 L36_41 L137_142 0.1339
K8792 L36_41 L167_172 0.1517
K8793 L36_41 L121_126 0.0282
K8794 L36_41 L97_101 0.0703
K8795 L36_41 L113_118 0.0393
K8796 L36_41 L134_139 0.1137
K8797 L36_41 L100_104 0.081
K8798 L36_41 L24_29 0.0648
K8799 L36_41 L138_143 0.1175
K8800 L36_41 L33_38 0.17
K8801 L36_41 L18_23 0.0518
K8802 L36_41 L124_129 0.0509
K8803 L36_41 L107_112 0.0327
K8804 L36_41 L78_83 0.0694
K8805 L36_41 L112_117 0.0337
K8806 L36_41 L40_45 0.1357
K8807 L36_41 L183_187 0.047
K8808 L36_41 L59_63 0.0359
K8809 L36_41 L5_10 0.0314
K8810 L36_41 L15_20 0.0369
K8811 L36_41 L51_55 0.0339
K8812 L36_41 L58_62 0.0283
K8813 L36_41 L67_71 0.0422
K8814 L36_41 L48_52 0.0379
K8815 L36_41 L29_34 0.0915
K8816 L36_41 L179_183 0.0428
K8817 L36_41 L206_210 0.0646
K8818 L36_41 L28_33 0.0983
K8819 L36_41 L205_209 0.0497
K8820 L36_41 L191_195 0.0325
K8821 L36_41 L66_70 0.0327
K8822 L36_41 L98_102 0.0951
K8823 L36_41 L27_32 0.1037
K8824 L36_41 L142_147 0.1083
K8825 L36_41 L147_152 0.0898
K8826 L36_41 L178_182 0.0311
K8827 L36_41 L180_184 0.0422
K8828 L36_41 L3_8 0.0392
K8829 L36_41 L157_162 0.0658
K8830 L36_41 L149_154 0.0777
K8831 L36_41 L203_207 0.031
K8832 L36_41 L2_7 0.0397
K8833 L36_41 L117_122 0.0348
K8834 L36_41 L22_27 0.0685
K8835 L36_41 L38_43 0.2473
K8836 L36_41 L47_51 0.0328
K8837 L36_41 L108_113 0.0377
K8838 L36_41 L135_174 0.1257
K8839 L36_41 L94_98 0.1185
K8840 L36_41 L52_56 0.0395
K8841 L36_41 L80_85 0.0311
K8842 L36_41 L10_15 0.0339
K8843 L36_41 L158_163 0.0637
K8844 L36_41 L185_189 0.045
K8845 L36_41 L96_100 0.0937
K8846 L36_41 L49_53 0.0434
K8847 L36_41 L186_190 0.0364
K8848 L36_41 L156_161 0.0672
K8849 L36_41 L82_87 0.0501
K8850 L36_41 L55_59 0.0349
K8851 L36_41 L159_164 0.0571
K8852 L36_41 L9_14 0.0418
K8853 L36_41 L68_72 0.0549
K8854 L36_41 L169_174 0.1068
K8855 L36_41 L204_208 0.0397
K8856 L36_41 L25_30 0.058
K8857 L36_41 L32_37 0.2112
K8858 L36_41 L133_172 0.2027
K8859 L36_41 L14_19 0.0456
K8860 L36_41 L44_92 0.1247
K8861 L36_41 L161_166 0.0992
K8862 L36_41 L95_99 0.1065
K8863 L36_41 L116_121 0.0275
K8864 L36_41 L199_203 0.0316
K8865 L36_41 L75_80 0.0317
K8866 L36_41 L143_148 0.0992
K8867 L36_41 L70_75 0.0322
K8868 L36_41 L50_54 0.0268
K8869 L36_41 L56_60 0.0411
K8870 L36_41 L159_190 0.0398
K8871 L36_41 L93_97 0.0791
K8872 L36_41 L90_94 0.156
K8873 L36_41 L134_173 0.1599
K8874 L36_41 L139_144 0.1012
K8875 L36_41 L83_88 0.0654
K8876 L36_41 L177_181 0.0382
K8877 L36_41 L111_116 0.0267
K8878 L36_41 L162_167 0.0946
K8879 L36_41 L43_91 0.1607
K8880 L36_41 L122_127 0.0358
K8881 L36_41 L135_140 0.082
K8882 L36_41 L39_44 0.1786
K8883 L36_41 L123_128 0.0426
K8884 L36_41 L54_58 0.0276
K8885 L36_41 L114_119 0.0455
K8886 L36_41 L61_65 0.0513
K8887 L36_41 L12_17 0.0477
K8888 L36_41 L77_82 0.0518
K8889 L48_52 L181_185 0.0395
K8890 L48_52 L140_145 0.0212
K8891 L48_52 L1_6 0.0692
K8892 L48_52 L13_18 0.0423
K8893 L48_52 L35_40 0.0367
K8894 L48_52 L23_28 0.0515
K8895 L48_52 L73_78 0.0466
K8896 L48_52 L6_11 0.069
K8897 L48_52 L163_168 0.0447
K8898 L48_52 L91_95 0.027
K8899 L48_52 L144_149 0.0253
K8900 L48_52 L130_160 0.053
K8901 L48_52 L4_9 0.0398
K8902 L48_52 L202_206 0.0443
K8903 L48_52 L109_114 0.1114
K8904 L48_52 L57_61 0.1103
K8905 L48_52 L164_169 0.0397
K8906 L48_52 L195_199 0.0373
K8907 L48_52 L106_111 0.0802
K8908 L48_52 L34_39 0.041
K8909 L48_52 L148_153 0.0251
K8910 L48_52 L204_208 0.0423
K8911 L48_52 L53_57 0.1134
K8912 L48_52 L69_73 0.0489
K8913 L48_52 L200_204 0.0443
K8914 L48_52 L150_155 0.0199
K8915 L48_52 L145_150 0.0205
K8916 L48_52 L30_35 0.0399
K8917 L48_52 L131_136 0.0391
K8918 L48_52 L101_105 0.02
K8919 L48_52 L46_50 0.0818
K8920 L48_52 L196_200 0.0464
K8921 L48_52 L92_96 0.0262
K8922 L48_52 L81_86 0.0425
K8923 L48_52 L19_24 0.0391
K8924 L48_52 L120_125 0.0673
K8925 L48_52 L8_13 0.0426
K8926 L48_52 L198_202 0.0464
K8927 L48_52 L7_12 0.0459
K8928 L48_52 L137_142 0.0277
K8929 L48_52 L167_172 0.0427
K8930 L48_52 L121_126 0.0759
K8931 L48_52 L97_101 0.0206
K8932 L48_52 L110_115 0.0684
K8933 L48_52 L134_139 0.027
K8934 L48_52 L141_146 0.0361
K8935 L48_52 L100_104 0.0246
K8936 L48_52 L9_14 0.0398
K8937 L48_52 L138_143 0.0269
K8938 L48_52 L33_38 0.0429
K8939 L48_52 L18_23 0.0418
K8940 L48_52 L124_129 0.1034
K8941 L48_52 L107_112 0.1114
K8942 L48_52 L78_83 0.0444
K8943 L48_52 L112_117 0.1104
K8944 L48_52 L40_45 0.0334
K8945 L48_52 L183_187 0.0451
K8946 L48_52 L136_141 0.0375
K8947 L48_52 L59_63 0.1057
K8948 L48_52 L5_10 0.0314
K8949 L48_52 L15_20 0.0312
K8950 L48_52 L51_55 0.1134
K8951 L48_52 L58_62 0.0772
K8952 L48_52 L67_71 0.0489
K8953 L48_52 L29_34 0.0449
K8954 L48_52 L179_183 0.0455
K8955 L48_52 L158_189 0.0388
K8956 L48_52 L206_210 0.0423
K8957 L48_52 L41_74 0.0393
K8958 L48_52 L131_170 0.0377
K8959 L48_52 L28_33 0.0474
K8960 L48_52 L191_195 0.0391
K8961 L48_52 L66_70 0.0393
K8962 L48_52 L98_102 0.0258
K8963 L48_52 L27_32 0.0501
K8964 L48_52 L142_147 0.0267
K8965 L48_52 L147_152 0.0257
K8966 L48_52 L178_182 0.0312
K8967 L48_52 L180_184 0.0423
K8968 L48_52 L3_8 0.0427
K8969 L48_52 L157_162 0.0511
K8970 L48_52 L149_154 0.0245
K8971 L48_52 L203_207 0.0342
K8972 L48_52 L2_7 0.0461
K8973 L48_52 L117_122 0.1076
K8974 L48_52 L22_27 0.055
K8975 L48_52 L38_43 0.0385
K8976 L48_52 L47_51 0.1145
K8977 L48_52 L55_59 0.1103
K8978 L48_52 L135_174 0.0333
K8979 L48_52 L94_98 0.0268
K8980 L48_52 L160_165 0.0479
K8981 L48_52 L115_120 0.0681
K8982 L48_52 L80_85 0.0343
K8983 L48_52 L10_15 0.0313
K8984 L48_52 L16_21 0.0668
K8985 L48_52 L158_163 0.0481
K8986 L48_52 L185_189 0.0392
K8987 L48_52 L96_100 0.0254
K8988 L48_52 L49_53 0.1145
K8989 L48_52 L186_190 0.031
K8990 L48_52 L156_161 0.0546
K8991 L48_52 L125_130 0.066
K8992 L48_52 L184_188 0.042
K8993 L48_52 L159_164 0.0425
K8994 L48_52 L24_29 0.0484
K8995 L48_52 L169_174 0.0365
K8996 L48_52 L25_30 0.0427
K8997 L48_52 L32_37 0.0448
K8998 L48_52 L133_172 0.0384
K8999 L48_52 L14_19 0.0395
K9000 L48_52 L44_92 0.0271
K9001 L48_52 L161_166 0.0498
K9002 L48_52 L21_26 0.0534
K9003 L48_52 L95_99 0.0261
K9004 L48_52 L84_89 0.0348
K9005 L48_52 L116_121 0.0782
K9006 L48_52 L74_79 0.0377
K9007 L48_52 L165_170 0.0426
K9008 L48_52 L199_203 0.0357
K9009 L48_52 L75_80 0.0358
K9010 L48_52 L143_148 0.026
K9011 L48_52 L70_75 0.0375
K9012 L48_52 L50_54 0.0812
K9013 L48_52 L79_84 0.0362
K9014 L48_52 L159_190 0.0307
K9015 L48_52 L93_97 0.0213
K9016 L48_52 L90_94 0.0278
K9017 L48_52 L134_173 0.0371
K9018 L48_52 L139_144 0.0261
K9019 L48_52 L83_88 0.0425
K9020 L48_52 L177_181 0.0396
K9021 L48_52 L111_116 0.0797
K9022 L48_52 L162_167 0.0471
K9023 L48_52 L43_91 0.028
K9024 L48_52 L122_127 0.1034
K9025 L48_52 L135_140 0.0219
K9026 L48_52 L39_44 0.0372
K9027 L48_52 L12_17 0.0455
K9028 L48_52 L54_58 0.0796
K9029 L48_52 L146_151 0.0347
K9030 L48_52 L114_119 0.1104
K9031 L48_52 L61_65 0.1057
K9032 L48_52 L11_16 0.0681
K9033 L177_178 L167_168 0.0441
K9034 L177_178 L74_90 0.019
K9035 L177_178 L199_200 0.017
K9036 L177_178 L115_179 0.1036
K9037 L177_178 L128_129 0.0334
K9038 L177_178 L196_197 0.0196
K9039 L177_178 L13_14 0.1117
K9040 L177_178 L23_24 0.0794
K9041 L177_178 L158_159 0.0863
K9042 L177_178 L136_198 0.0243
K9043 L177_178 L163_164 0.063
K9044 L177_178 L144_145 0.0183
K9045 L177_178 L91_92 0.0192
K9046 L177_178 L151_152 0.0137
K9047 L177_178 L126_127 0.0209
K9048 L177_178 L22_23 0.0752
K9049 L177_178 L204_205 0.0184
K9050 L177_178 L153_154 0.0138
K9051 L177_178 L34_35 0.0437
K9052 L177_178 L41_42 0.0251
K9053 L177_178 L197_198 0.0219
K9054 L177_178 L143_144 0.0183
K9055 L177_178 L200_201 0.019
K9056 L177_178 L205_206 0.0203
K9057 L177_178 L36_37 0.033
K9058 L177_178 L131_132 0.0253
K9059 L177_178 L100_101 0.0173
K9060 L177_178 L203_204 0.0166
K9061 L177_178 L92_93 0.0192
K9062 L177_178 L81_82 0.0184
K9063 L177_178 L148_149 0.0173
K9064 L177_178 L19_20 0.0911
K9065 L177_178 L187_188 0.0877
K9066 L177_178 L102_103 0.0137
K9067 L177_178 L160_161 0.058
K9068 L177_178 L64_65 0.0331
K9069 L177_178 L26_27 0.0566
K9070 L177_178 L165_166 0.0424
K9071 L177_178 L170_171 0.0333
K9072 L177_178 L193_194 0.021
K9073 L177_178 L21_65 0.0461
K9074 L177_178 L121_122 0.0226
K9075 L177_178 L9_10 0.1566
K9076 L177_178 L195_196 0.0174
K9077 L177_178 L134_135 0.0257
K9078 L177_178 L41_69 0.0233
K9079 L177_178 L171_172 0.0338
K9080 L177_178 L104_105 0.0138
K9081 L177_178 L151_210 0.02
K9082 L177_178 L79_94 0.018
K9083 L177_178 L37_38 0.0335
K9084 L177_178 L112_113 0.0284
K9085 L177_178 L183_184 0.1116
K9086 L177_178 L59_60 0.0278
K9087 L177_178 L11_57 0.0529
K9088 L177_178 L38_39 0.0338
K9089 L177_178 L27_28 0.0591
K9090 L177_178 L96_97 0.0182
K9091 L177_178 L78_79 0.0231
K9092 L177_178 L44_45 0.0256
K9093 L177_178 L29_30 0.0613
K9094 L177_178 L76_77 0.0189
K9095 L177_178 L114_115 0.0554
K9096 L177_178 L166_167 0.0434
K9097 L177_178 L185_186 0.1487
K9098 L177_178 L16_17 0.0706
K9099 L177_178 L188_189 0.0983
K9100 L177_178 L86_87 0.0168
K9101 L177_178 L118_119 0.0371
K9102 L177_178 L180_181 0.2134
K9103 L177_178 L6_53 0.0542
K9104 L177_178 L149_150 0.0173
K9105 L177_178 L98_99 0.0172
K9106 L177_178 L55_56 0.028
K9107 L177_178 L84_98 0.0171
K9108 L177_178 L124_125 0.052
K9109 L177_178 L113_114 0.0375
K9110 L177_178 L52_53 0.0372
K9111 L177_178 L80_81 0.0166
K9112 L177_178 L17_18 0.0801
K9113 L177_178 L141_202 0.0232
K9114 L177_178 L87_88 0.0184
K9115 L177_178 L146_147 0.0171
K9116 L177_178 L209_210 0.0185
K9117 L177_178 L94_95 0.0181
K9118 L177_178 L136_137 0.0191
K9119 L177_178 L127_128 0.0258
K9120 L177_178 L138_139 0.0193
K9121 L177_178 L42_43 0.0254
K9122 L177_178 L181_182 0.2697
K9123 L177_178 L28_29 0.0607
K9124 L177_178 L157_158 0.0843
K9125 L177_178 L122_123 0.0279
K9126 L177_178 L103_104 0.0138
K9127 L177_178 L66_67 0.0165
K9128 L177_178 L129_130 0.0469
K9129 L177_178 L21_22 0.0694
K9130 L177_178 L117_118 0.0282
K9131 L177_178 L51_52 0.0282
K9132 L177_178 L56_57 0.0367
K9133 L177_178 L116_117 0.0227
K9134 L177_178 L6_7 0.0915
K9135 L177_178 L173_174 0.0342
K9136 L177_178 L154_155 0.0138
K9137 L177_178 L32_33 0.0429
K9138 L177_178 L95_96 0.0182
K9139 L177_178 L85_86 0.0152
K9140 L177_178 L7_8 0.1153
K9141 L177_178 L82_83 0.0203
K9142 L177_178 L14_15 0.1183
K9143 L177_178 L184_185 0.1362
K9144 L177_178 L141_142 0.018
K9145 L177_178 L62_63 0.0208
K9146 L177_178 L125_187 0.0757
K9147 L177_178 L58_59 0.0225
K9148 L177_178 L70_71 0.0174
K9149 L177_178 L68_69 0.021
K9150 L177_178 L89_102 0.0136
K9151 L177_178 L8_9 0.1426
K9152 L177_178 L50_51 0.0227
K9153 L177_178 L168_169 0.0443
K9154 L177_178 L83_84 0.0221
K9155 L177_178 L90_91 0.0191
K9156 L177_178 L139_140 0.0193
K9157 L177_178 L161_162 0.0606
K9158 L177_178 L111_112 0.0228
K9159 L177_178 L162_163 0.0624
K9160 L177_178 L137_138 0.0192
K9161 L177_178 L179_180 0.1437
K9162 L177_178 L12_13 0.0969
K9163 L177_178 L207_208 0.0152
K9164 L177_178 L142_143 0.0182
K9165 L177_178 L123_124 0.0364
K9166 L177_178 L152_153 0.0137
K9167 L177_178 L191_192 0.0166
K9168 L177_178 L39_40 0.0339
K9169 L177_178 L18_19 0.0879
K9170 L177_178 L130_156 0.0725
K9171 L177_178 L156_157 0.0792
K9172 L177_178 L189_190 0.1028
K9173 L177_178 L11_12 0.0814
K9174 L177_178 L54_55 0.0226
K9175 L177_178 L201_202 0.0211
K9176 L28_33 L24_29 0.1944
K9177 L28_33 L181_185 0.093
K9178 L28_33 L140_145 0.0451
K9179 L28_33 L1_6 0.0701
K9180 L28_33 L35_40 0.1538
K9181 L28_33 L73_78 0.0514
K9182 L28_33 L6_11 0.0767
K9183 L28_33 L163_168 0.2341
K9184 L28_33 L144_149 0.0503
K9185 L28_33 L130_160 0.1517
K9186 L28_33 L4_9 0.083
K9187 L28_33 L202_206 0.0486
K9188 L28_33 L109_114 0.0592
K9189 L28_33 L57_61 0.0657
K9190 L28_33 L164_169 0.1794
K9191 L28_33 L195_199 0.0285
K9192 L28_33 L106_111 0.0303
K9193 L28_33 L34_39 0.1944
K9194 L28_33 L201_205 0.0412
K9195 L28_33 L53_57 0.0627
K9196 L28_33 L69_73 0.054
K9197 L28_33 L200_204 0.0352
K9198 L28_33 L150_155 0.0375
K9199 L28_33 L145_150 0.041
K9200 L28_33 L30_35 0.2076
K9201 L28_33 L131_136 0.0586
K9202 L28_33 L101_105 0.0379
K9203 L28_33 L46_50 0.0304
K9204 L28_33 L196_200 0.0361
K9205 L28_33 L92_96 0.0565
K9206 L28_33 L81_86 0.0344
K9207 L28_33 L19_24 0.1482
K9208 L28_33 L120_125 0.0823
K9209 L28_33 L160_165 0.2027
K9210 L28_33 L185_189 0.1101
K9211 L28_33 L60_64 0.0515
K9212 L28_33 L198_202 0.051
K9213 L28_33 L193_197 0.0442
K9214 L28_33 L7_12 0.0718
K9215 L28_33 L137_142 0.0459
K9216 L28_33 L121_126 0.0318
K9217 L28_33 L97_101 0.0415
K9218 L28_33 L110_115 0.069
K9219 L28_33 L113_118 0.0486
K9220 L28_33 L141_146 0.0507
K9221 L28_33 L100_104 0.0465
K9222 L28_33 L9_14 0.098
K9223 L28_33 L134_139 0.0619
K9224 L28_33 L124_129 0.0678
K9225 L28_33 L107_112 0.0386
K9226 L28_33 L78_83 0.0489
K9227 L28_33 L112_117 0.0394
K9228 L28_33 L40_45 0.095
K9229 L28_33 L183_187 0.08
K9230 L28_33 L136_141 0.0544
K9231 L28_33 L59_63 0.0409
K9232 L28_33 L5_10 0.0657
K9233 L28_33 L15_20 0.0897
K9234 L28_33 L51_55 0.0395
K9235 L28_33 L58_62 0.0319
K9236 L28_33 L67_71 0.0371
K9237 L28_33 L29_34 0.2991
K9238 L28_33 L179_183 0.0699
K9239 L28_33 L158_189 0.1319
K9240 L28_33 L206_210 0.0463
K9241 L28_33 L41_74 0.0593
K9242 L28_33 L131_170 0.0946
K9243 L28_33 L205_209 0.0398
K9244 L28_33 L191_195 0.0291
K9245 L28_33 L66_70 0.0292
K9246 L28_33 L98_102 0.0394
K9247 L28_33 L27_32 0.2991
K9248 L28_33 L142_147 0.0422
K9249 L28_33 L147_152 0.0391
K9250 L28_33 L178_182 0.0635
K9251 L28_33 L149_154 0.0459
K9252 L28_33 L203_207 0.0272
K9253 L28_33 L2_7 0.0633
K9254 L28_33 L117_122 0.0401
K9255 L28_33 L22_27 0.1944
K9256 L28_33 L47_51 0.0388
K9257 L28_33 L55_59 0.0403
K9258 L28_33 L135_174 0.0917
K9259 L28_33 L94_98 0.0427
K9260 L28_33 L52_56 0.0488
K9261 L28_33 L115_120 0.0753
K9262 L28_33 L80_85 0.0272
K9263 L28_33 L10_15 0.0762
K9264 L28_33 L16_21 0.0927
K9265 L28_33 L158_163 0.1706
K9266 L28_33 L96_100 0.051
K9267 L28_33 L49_53 0.0597
K9268 L28_33 L186_190 0.0843
K9269 L28_33 L156_161 0.1706
K9270 L28_33 L82_87 0.0399
K9271 L28_33 L125_130 0.0902
K9272 L28_33 L108_113 0.0471
K9273 L28_33 L159_164 0.1403
K9274 L28_33 L84_89 0.0477
K9275 L28_33 L68_72 0.0444
K9276 L28_33 L169_174 0.1403
K9277 L28_33 L204_208 0.0343
K9278 L28_33 L25_30 0.1538
K9279 L28_33 L32_37 0.1944
K9280 L28_33 L14_19 0.1187
K9281 L28_33 L44_92 0.0633
K9282 L28_33 L161_166 0.2341
K9283 L28_33 L21_26 0.17
K9284 L28_33 L116_121 0.0314
K9285 L28_33 L74_79 0.0549
K9286 L28_33 L165_170 0.1517
K9287 L28_33 L199_203 0.0278
K9288 L28_33 L75_80 0.0279
K9289 L28_33 L70_75 0.0286
K9290 L28_33 L50_54 0.031
K9291 L28_33 L79_84 0.0511
K9292 L28_33 L56_60 0.0502
K9293 L28_33 L159_190 0.0979
K9294 L28_33 L93_97 0.0458
K9295 L28_33 L90_94 0.0465
K9296 L28_33 L134_173 0.1038
K9297 L28_33 L139_144 0.0555
K9298 L28_33 L83_88 0.0465
K9299 L28_33 L177_181 0.08
K9300 L28_33 L111_116 0.0309
K9301 L28_33 L122_127 0.0407
K9302 L28_33 L135_140 0.05
K9303 L28_33 L39_44 0.1081
K9304 L28_33 L123_128 0.0511
K9305 L28_33 L12_17 0.083
K9306 L28_33 L54_58 0.0315
K9307 L28_33 L146_151 0.0474
K9308 L28_33 L114_119 0.0621
K9309 L28_33 L61_65 0.0686
K9310 L28_33 L11_16 0.0842
K9311 L28_33 L77_82 0.0414
K9312 L6_7 L167_168 0.053
K9313 L6_7 L74_90 0.0237
K9314 L6_7 L199_200 0.0224
K9315 L6_7 L128_129 0.0513
K9316 L6_7 L196_197 0.0259
K9317 L6_7 L13_14 0.1439
K9318 L6_7 L23_24 0.1004
K9319 L6_7 L158_159 0.0868
K9320 L6_7 L136_198 0.0314
K9321 L6_7 L163_164 0.0704
K9322 L6_7 L144_145 0.022
K9323 L6_7 L91_92 0.0235
K9324 L6_7 L160_161 0.0766
K9325 L6_7 L151_152 0.0168
K9326 L6_7 L126_127 0.0294
K9327 L6_7 L22_23 0.1076
K9328 L6_7 L204_205 0.0241
K9329 L6_7 L153_154 0.0167
K9330 L6_7 L4_5 0.1036
K9331 L6_7 L34_35 0.0524
K9332 L6_7 L41_42 0.0316
K9333 L6_7 L197_198 0.0288
K9334 L6_7 L143_144 0.0221
K9335 L6_7 L200_201 0.025
K9336 L6_7 L205_206 0.0264
K9337 L6_7 L131_132 0.0314
K9338 L6_7 L100_101 0.0209
K9339 L6_7 L203_204 0.0218
K9340 L6_7 L92_93 0.0233
K9341 L6_7 L81_82 0.0242
K9342 L6_7 L1_2 0.2697
K9343 L6_7 L148_149 0.021
K9344 L6_7 L19_20 0.0953
K9345 L6_7 L187_188 0.1127
K9346 L6_7 L165_166 0.054
K9347 L6_7 L102_103 0.0169
K9348 L6_7 L106_107 0.0361
K9349 L6_7 L64_65 0.052
K9350 L6_7 L26_27 0.079
K9351 L6_7 L170_171 0.0417
K9352 L6_7 L193_194 0.0278
K9353 L6_7 L21_65 0.0803
K9354 L6_7 L121_122 0.0317
K9355 L6_7 L195_196 0.0231
K9356 L6_7 L134_135 0.0308
K9357 L6_7 L41_69 0.0306
K9358 L6_7 L171_172 0.0416
K9359 L6_7 L104_105 0.0167
K9360 L6_7 L151_210 0.0255
K9361 L6_7 L79_94 0.0224
K9362 L6_7 L37_38 0.0419
K9363 L6_7 L124_125 0.0885
K9364 L6_7 L183_184 0.1438
K9365 L6_7 L59_60 0.041
K9366 L6_7 L11_57 0.0996
K9367 L6_7 L38_39 0.0415
K9368 L6_7 L27_28 0.0781
K9369 L6_7 L96_97 0.0221
K9370 L6_7 L78_79 0.0299
K9371 L6_7 L44_45 0.031
K9372 L6_7 L47_48 0.0503
K9373 L6_7 L29_30 0.0722
K9374 L6_7 L76_77 0.0251
K9375 L6_7 L166_167 0.0538
K9376 L6_7 L185_186 0.1015
K9377 L6_7 L16_17 0.1354
K9378 L6_7 L86_87 0.022
K9379 L6_7 L118_119 0.0579
K9380 L6_7 L176_177 0.1153
K9381 L6_7 L3_4 0.1437
K9382 L6_7 L149_150 0.0209
K9383 L6_7 L2_3 0.2134
K9384 L6_7 L98_99 0.0212
K9385 L6_7 L55_56 0.0416
K9386 L6_7 L84_98 0.0212
K9387 L6_7 L48_49 0.0819
K9388 L6_7 L110_175 0.1566
K9389 L6_7 L80_81 0.0218
K9390 L6_7 L17_18 0.1284
K9391 L6_7 L141_202 0.0298
K9392 L6_7 L87_88 0.024
K9393 L6_7 L146_147 0.0211
K9394 L6_7 L209_210 0.0239
K9395 L6_7 L94_95 0.0223
K9396 L6_7 L136_137 0.0236
K9397 L6_7 L127_128 0.0375
K9398 L6_7 L138_139 0.0234
K9399 L6_7 L42_43 0.0315
K9400 L6_7 L28_29 0.0757
K9401 L6_7 L157_158 0.0947
K9402 L6_7 L122_123 0.0407
K9403 L6_7 L103_104 0.0168
K9404 L6_7 L66_67 0.022
K9405 L6_7 L129_130 0.0776
K9406 L6_7 L21_22 0.1104
K9407 L6_7 L117_118 0.0413
K9408 L6_7 L56_57 0.0589
K9409 L6_7 L116_117 0.032
K9410 L6_7 L188_189 0.1015
K9411 L6_7 L173_174 0.0406
K9412 L6_7 L154_155 0.0166
K9413 L6_7 L32_33 0.0545
K9414 L6_7 L95_96 0.0222
K9415 L6_7 L85_86 0.0199
K9416 L6_7 L82_83 0.0265
K9417 L6_7 L14_15 0.1124
K9418 L6_7 L184_185 0.1226
K9419 L6_7 L141_142 0.0223
K9420 L6_7 L62_63 0.0295
K9421 L6_7 L125_187 0.1173
K9422 L6_7 L58_59 0.0319
K9423 L6_7 L70_71 0.0231
K9424 L6_7 L68_69 0.0279
K9425 L6_7 L89_102 0.0169
K9426 L6_7 L36_37 0.042
K9427 L6_7 L168_169 0.0518
K9428 L6_7 L83_84 0.0285
K9429 L6_7 L90_91 0.0237
K9430 L6_7 L139_140 0.0232
K9431 L6_7 L161_162 0.0758
K9432 L6_7 L162_163 0.0736
K9433 L6_7 L137_138 0.0235
K9434 L6_7 L12_13 0.1832
K9435 L6_7 L207_208 0.0199
K9436 L6_7 L142_143 0.0222
K9437 L6_7 L123_124 0.0564
K9438 L6_7 L152_153 0.0168
K9439 L6_7 L191_192 0.022
K9440 L6_7 L39_40 0.0409
K9441 L6_7 L18_19 0.1124
K9442 L6_7 L130_156 0.1029
K9443 L6_7 L156_157 0.1006
K9444 L6_7 L189_190 0.0884
K9445 L6_7 L11_12 0.2054
K9446 L6_7 L54_55 0.0321
K9447 L6_7 L201_202 0.0276
K9448 L86_87 L167_168 0.0353
K9449 L86_87 L74_90 0.0377
K9450 L86_87 L115_179 0.0219
K9451 L86_87 L196_197 0.1684
K9452 L86_87 L1_2 0.018
K9453 L86_87 L23_24 0.0275
K9454 L86_87 L158_159 0.0267
K9455 L86_87 L136_198 0.0837
K9456 L86_87 L163_164 0.0311
K9457 L86_87 L144_145 0.0314
K9458 L86_87 L91_92 0.0331
K9459 L86_87 L160_161 0.0342
K9460 L86_87 L126_127 0.0401
K9461 L86_87 L22_23 0.0283
K9462 L86_87 L204_205 0.2623
K9463 L86_87 L4_5 0.0168
K9464 L86_87 L34_35 0.0341
K9465 L86_87 L41_42 0.0431
K9466 L86_87 L197_198 0.13
K9467 L86_87 L143_144 0.0334
K9468 L86_87 L200_201 0.2081
K9469 L86_87 L205_206 0.1674
K9470 L86_87 L36_37 0.0428
K9471 L86_87 L131_132 0.0428
K9472 L86_87 L100_101 0.0318
K9473 L86_87 L203_204 0.1674
K9474 L86_87 L92_93 0.0312
K9475 L86_87 L81_82 0.3407
K9476 L86_87 L13_14 0.0216
K9477 L86_87 L148_149 0.0337
K9478 L86_87 L19_20 0.0217
K9479 L86_87 L187_188 0.0229
K9480 L86_87 L165_166 0.0382
K9481 L86_87 L128_129 0.0401
K9482 L86_87 L106_107 0.0334
K9483 L86_87 L8_9 0.0209
K9484 L86_87 L170_171 0.0425
K9485 L86_87 L193_194 0.1173
K9486 L86_87 L21_65 0.0373
K9487 L86_87 L121_122 0.0401
K9488 L86_87 L9_10 0.0204
K9489 L86_87 L195_196 0.13
K9490 L86_87 L134_135 0.0361
K9491 L86_87 L41_69 0.0785
K9492 L86_87 L171_172 0.0406
K9493 L86_87 L180_181 0.0209
K9494 L86_87 L79_94 0.0384
K9495 L86_87 L37_38 0.0407
K9496 L86_87 L112_113 0.037
K9497 L86_87 L183_184 0.0221
K9498 L86_87 L59_60 0.0413
K9499 L86_87 L11_57 0.036
K9500 L86_87 L38_39 0.0389
K9501 L86_87 L27_28 0.0332
K9502 L86_87 L78_79 0.0898
K9503 L86_87 L44_45 0.0363
K9504 L86_87 L47_48 0.0342
K9505 L86_87 L29_30 0.0312
K9506 L86_87 L76_77 0.2387
K9507 L86_87 L114_115 0.0344
K9508 L86_87 L166_167 0.0367
K9509 L86_87 L185_186 0.021
K9510 L86_87 L16_17 0.0236
K9511 L86_87 L188_189 0.0223
K9512 L86_87 L181_182 0.0204
K9513 L86_87 L118_119 0.0381
K9514 L86_87 L176_177 0.0172
K9515 L86_87 L3_4 0.0172
K9516 L86_87 L6_53 0.0345
K9517 L86_87 L149_150 0.0317
K9518 L86_87 L2_3 0.0176
K9519 L86_87 L98_99 0.0362
K9520 L86_87 L55_56 0.0391
K9521 L86_87 L84_98 0.0389
K9522 L86_87 L48_49 0.0335
K9523 L86_87 L110_175 0.018
K9524 L86_87 L124_125 0.0376
K9525 L86_87 L113_114 0.0363
K9526 L86_87 L52_53 0.0364
K9527 L86_87 L80_81 0.1877
K9528 L86_87 L17_18 0.0229
K9529 L86_87 L141_202 0.0878
K9530 L86_87 L62_63 0.0403
K9531 L86_87 L146_147 0.0386
K9532 L86_87 L94_95 0.0358
K9533 L86_87 L136_137 0.0375
K9534 L86_87 L127_128 0.0412
K9535 L86_87 L138_139 0.0329
K9536 L86_87 L42_43 0.0406
K9537 L86_87 L28_29 0.0322
K9538 L86_87 L157_158 0.0275
K9539 L86_87 L122_123 0.0411
K9540 L86_87 L96_97 0.0316
K9541 L86_87 L66_67 0.123
K9542 L86_87 L129_130 0.0372
K9543 L86_87 L64_65 0.0403
K9544 L86_87 L117_118 0.039
K9545 L86_87 L51_52 0.0371
K9546 L86_87 L56_57 0.0383
K9547 L86_87 L116_117 0.0381
K9548 L86_87 L173_174 0.037
K9549 L86_87 L32_33 0.0368
K9550 L86_87 L95_96 0.0336
K9551 L86_87 L21_22 0.0291
K9552 L86_87 L7_8 0.0215
K9553 L86_87 L82_83 0.1877
K9554 L86_87 L14_15 0.0211
K9555 L86_87 L184_185 0.0216
K9556 L86_87 L141_142 0.0381
K9557 L86_87 L199_200 0.1479
K9558 L86_87 L125_187 0.0235
K9559 L86_87 L58_59 0.0403
K9560 L86_87 L70_71 0.1369
K9561 L86_87 L68_69 0.123
K9562 L86_87 L26_27 0.0343
K9563 L86_87 L50_51 0.0364
K9564 L86_87 L168_169 0.034
K9565 L86_87 L83_84 0.0934
K9566 L86_87 L90_91 0.0353
K9567 L86_87 L139_140 0.031
K9568 L86_87 L161_162 0.0331
K9569 L86_87 L111_112 0.0363
K9570 L86_87 L162_163 0.0321
K9571 L86_87 L137_138 0.0351
K9572 L86_87 L179_180 0.0214
K9573 L86_87 L12_13 0.0222
K9574 L86_87 L142_143 0.0356
K9575 L86_87 L123_124 0.0401
K9576 L86_87 L191_192 0.1173
K9577 L86_87 L39_40 0.0371
K9578 L86_87 L18_19 0.0223
K9579 L86_87 L130_156 0.0291
K9580 L86_87 L156_157 0.0282
K9581 L86_87 L189_190 0.0216
K9582 L86_87 L11_12 0.0228
K9583 L86_87 L54_55 0.0383
K9584 L86_87 L201_202 0.1479
K9585 L151_152 L167_168 0.0351
K9586 L151_152 L74_90 0.0811
K9587 L151_152 L115_179 0.0169
K9588 L151_152 L196_197 0.0423
K9589 L151_152 L1_2 0.0138
K9590 L151_152 L23_24 0.0232
K9591 L151_152 L158_159 0.0231
K9592 L151_152 L136_198 0.1034
K9593 L151_152 L163_164 0.0282
K9594 L151_152 L144_145 0.0823
K9595 L151_152 L91_92 0.073
K9596 L151_152 L160_161 0.0287
K9597 L151_152 L126_127 0.0198
K9598 L151_152 L22_23 0.0233
K9599 L151_152 L204_205 0.0444
K9600 L151_152 L4_5 0.0136
K9601 L151_152 L34_35 0.0343
K9602 L151_152 L41_42 0.0629
K9603 L151_152 L197_198 0.0632
K9604 L151_152 L143_144 0.0985
K9605 L151_152 L200_201 0.0435
K9606 L151_152 L205_206 0.0713
K9607 L151_152 L36_37 0.0459
K9608 L151_152 L131_132 0.0652
K9609 L151_152 L100_101 0.0867
K9610 L151_152 L203_204 0.0322
K9611 L151_152 L92_93 0.0657
K9612 L151_152 L81_82 0.0438
K9613 L151_152 L13_14 0.0176
K9614 L151_152 L148_149 0.1268
K9615 L151_152 L19_20 0.0185
K9616 L151_152 L187_188 0.0188
K9617 L151_152 L165_166 0.0355
K9618 L151_152 L128_129 0.0245
K9619 L151_152 L106_107 0.0176
K9620 L151_152 L8_9 0.0167
K9621 L151_152 L170_171 0.0466
K9622 L151_152 L193_194 0.0579
K9623 L151_152 L21_65 0.0259
K9624 L151_152 L121_122 0.0204
K9625 L151_152 L9_10 0.0166
K9626 L151_152 L195_196 0.0314
K9627 L151_152 L134_135 0.0587
K9628 L151_152 L41_69 0.0863
K9629 L151_152 L171_172 0.0463
K9630 L151_152 L180_181 0.0168
K9631 L151_152 L79_94 0.1033
K9632 L151_152 L37_38 0.0456
K9633 L151_152 L112_113 0.0209
K9634 L151_152 L183_184 0.0178
K9635 L151_152 L59_60 0.0226
K9636 L151_152 L11_57 0.0246
K9637 L151_152 L38_39 0.0449
K9638 L151_152 L27_28 0.0285
K9639 L151_152 L78_79 0.1147
K9640 L151_152 L44_45 0.057
K9641 L151_152 L47_48 0.0192
K9642 L151_152 L29_30 0.028
K9643 L151_152 L76_77 0.0429
K9644 L151_152 L114_115 0.0234
K9645 L151_152 L166_167 0.0354
K9646 L151_152 L185_186 0.0176
K9647 L151_152 L16_17 0.0187
K9648 L151_152 L188_189 0.0187
K9649 L151_152 L181_182 0.0167
K9650 L151_152 L118_119 0.0235
K9651 L151_152 L176_177 0.0137
K9652 L151_152 L3_4 0.0137
K9653 L151_152 L6_53 0.0233
K9654 L151_152 L149_150 0.0968
K9655 L151_152 L2_3 0.0138
K9656 L151_152 L98_99 0.1266
K9657 L151_152 L55_56 0.0217
K9658 L151_152 L84_98 0.1363
K9659 L151_152 L48_49 0.0206
K9660 L151_152 L110_175 0.0138
K9661 L151_152 L124_125 0.026
K9662 L151_152 L113_114 0.0224
K9663 L151_152 L52_53 0.0224
K9664 L151_152 L80_81 0.032
K9665 L151_152 L17_18 0.0187
K9666 L151_152 L141_202 0.1275
K9667 L151_152 L62_63 0.0198
K9668 L151_152 L146_147 0.1916
K9669 L151_152 L94_95 0.0988
K9670 L151_152 L136_137 0.0891
K9671 L151_152 L127_128 0.0223
K9672 L151_152 L138_139 0.0787
K9673 L151_152 L42_43 0.0622
K9674 L151_152 L28_29 0.0283
K9675 L151_152 L157_158 0.0233
K9676 L151_152 L122_123 0.0226
K9677 L151_152 L96_97 0.0759
K9678 L151_152 L66_67 0.0289
K9679 L151_152 L129_130 0.026
K9680 L151_152 L64_65 0.0244
K9681 L151_152 L117_118 0.0217
K9682 L151_152 L51_52 0.0208
K9683 L151_152 L56_57 0.0234
K9684 L151_152 L116_117 0.0197
K9685 L151_152 L173_174 0.0445
K9686 L151_152 L32_33 0.0351
K9687 L151_152 L95_96 0.088
K9688 L151_152 L21_22 0.0234
K9689 L151_152 L7_8 0.0168
K9690 L151_152 L82_83 0.0689
K9691 L151_152 L14_15 0.0175
K9692 L151_152 L184_185 0.0177
K9693 L151_152 L141_142 0.1216
K9694 L151_152 L199_200 0.0318
K9695 L151_152 L125_187 0.0188
K9696 L151_152 L58_59 0.0203
K9697 L151_152 L70_71 0.0312
K9698 L151_152 L68_69 0.0564
K9699 L151_152 L26_27 0.0285
K9700 L151_152 L50_51 0.019
K9701 L151_152 L168_169 0.0345
K9702 L151_152 L83_84 0.1369
K9703 L151_152 L90_91 0.0789
K9704 L151_152 L139_140 0.0696
K9705 L151_152 L161_162 0.0286
K9706 L151_152 L111_112 0.0191
K9707 L151_152 L162_163 0.0285
K9708 L151_152 L137_138 0.0861
K9709 L151_152 L179_180 0.0169
K9710 L151_152 L12_13 0.0177
K9711 L151_152 L142_143 0.1144
K9712 L151_152 L123_124 0.0247
K9713 L151_152 L191_192 0.0291
K9714 L151_152 L39_40 0.0438
K9715 L151_152 L18_19 0.0186
K9716 L151_152 L130_156 0.0235
K9717 L151_152 L156_157 0.0235
K9718 L151_152 L189_190 0.0185
K9719 L151_152 L11_12 0.0177
K9720 L151_152 L54_55 0.0197
K9721 L151_152 L201_202 0.0676
K9722 L55_56 L167_168 0.0493
K9723 L55_56 L74_90 0.0295
K9724 L55_56 L199_200 0.0448
K9725 L55_56 L115_179 0.0413
K9726 L55_56 L128_129 0.1479
K9727 L55_56 L196_197 0.0488
K9728 L55_56 L1_2 0.0344
K9729 L55_56 L23_24 0.0531
K9730 L55_56 L158_159 0.049
K9731 L55_56 L136_198 0.0439
K9732 L55_56 L163_164 0.0514
K9733 L55_56 L144_145 0.0259
K9734 L55_56 L91_92 0.0278
K9735 L55_56 L160_161 0.0627
K9736 L55_56 L126_127 0.1479
K9737 L55_56 L22_23 0.0574
K9738 L55_56 L204_205 0.0435
K9739 L55_56 L153_154 0.0207
K9740 L55_56 L4_5 0.0282
K9741 L55_56 L34_35 0.0471
K9742 L55_56 L41_42 0.0382
K9743 L55_56 L197_198 0.0474
K9744 L55_56 L143_144 0.0266
K9745 L55_56 L200_201 0.046
K9746 L55_56 L205_206 0.0425
K9747 L55_56 L36_37 0.0479
K9748 L55_56 L131_132 0.0381
K9749 L55_56 L100_101 0.0251
K9750 L55_56 L203_204 0.0425
K9751 L55_56 L92_93 0.0269
K9752 L55_56 L81_82 0.0437
K9753 L55_56 L148_149 0.0257
K9754 L55_56 L19_20 0.0416
K9755 L55_56 L187_188 0.0482
K9756 L55_56 L165_166 0.0549
K9757 L55_56 L102_103 0.0212
K9758 L55_56 L106_107 0.1576
K9759 L55_56 L64_65 0.1593
K9760 L55_56 L26_27 0.0633
K9761 L55_56 L170_171 0.0476
K9762 L55_56 L193_194 0.0462
K9763 L55_56 L21_65 0.0898
K9764 L55_56 L121_122 0.1743
K9765 L55_56 L9_10 0.0341
K9766 L55_56 L195_196 0.0474
K9767 L55_56 L134_135 0.0344
K9768 L55_56 L41_69 0.0427
K9769 L55_56 L171_172 0.0457
K9770 L55_56 L104_105 0.0202
K9771 L55_56 L151_210 0.0359
K9772 L55_56 L138_139 0.0277
K9773 L55_56 L37_38 0.0459
K9774 L55_56 L112_113 0.2659
K9775 L55_56 L59_60 0.3334
K9776 L55_56 L129_130 0.0878
K9777 L55_56 L38_39 0.0441
K9778 L55_56 L27_28 0.059
K9779 L55_56 L96_97 0.026
K9780 L55_56 L78_79 0.0419
K9781 L55_56 L44_45 0.0346
K9782 L55_56 L47_48 0.2809
K9783 L55_56 L29_30 0.0518
K9784 L55_56 L76_77 0.0462
K9785 L55_56 L114_115 0.0969
K9786 L55_56 L166_167 0.052
K9787 L55_56 L16_17 0.0533
K9788 L55_56 L188_189 0.0445
K9789 L55_56 L176_177 0.0298
K9790 L55_56 L3_4 0.03
K9791 L55_56 L149_150 0.025
K9792 L55_56 L2_3 0.032
K9793 L55_56 L98_99 0.0264
K9794 L55_56 L6_53 0.0993
K9795 L55_56 L84_98 0.027
K9796 L55_56 L48_49 0.1727
K9797 L55_56 L110_175 0.0341
K9798 L55_56 L124_125 0.0969
K9799 L55_56 L113_114 0.1743
K9800 L55_56 L52_53 0.1933
K9801 L55_56 L80_81 0.0427
K9802 L55_56 L17_18 0.0488
K9803 L55_56 L141_202 0.0418
K9804 L55_56 L87_88 0.0383
K9805 L55_56 L146_147 0.027
K9806 L55_56 L209_210 0.0381
K9807 L55_56 L94_95 0.0275
K9808 L55_56 L136_137 0.0293
K9809 L55_56 L127_128 0.2081
K9810 L55_56 L42_43 0.037
K9811 L55_56 L181_182 0.0339
K9812 L55_56 L28_29 0.0552
K9813 L55_56 L157_158 0.0526
K9814 L55_56 L122_123 0.2659
K9815 L55_56 L103_104 0.0207
K9816 L55_56 L66_67 0.0465
K9817 L55_56 L21_22 0.0624
K9818 L55_56 L51_52 0.3334
K9819 L55_56 L79_94 0.0282
K9820 L55_56 L173_174 0.0421
K9821 L55_56 L154_155 0.0202
K9822 L55_56 L32_33 0.0523
K9823 L55_56 L95_96 0.0267
K9824 L55_56 L85_86 0.0383
K9825 L55_56 L7_8 0.0387
K9826 L55_56 L82_83 0.0427
K9827 L55_56 L58_59 0.1933
K9828 L55_56 L141_142 0.0281
K9829 L55_56 L62_63 0.1593
K9830 L55_56 L125_187 0.0527
K9831 L55_56 L70_71 0.0477
K9832 L55_56 L68_69 0.0465
K9833 L55_56 L180_181 0.0361
K9834 L55_56 L89_102 0.0217
K9835 L55_56 L8_9 0.0363
K9836 L55_56 L50_51 0.1933
K9837 L55_56 L168_169 0.0468
K9838 L55_56 L83_84 0.04
K9839 L55_56 L90_91 0.0286
K9840 L55_56 L139_140 0.0269
K9841 L55_56 L161_162 0.0585
K9842 L55_56 L111_112 0.1743
K9843 L55_56 L162_163 0.0548
K9844 L55_56 L137_138 0.0285
K9845 L55_56 L179_180 0.0385
K9846 L55_56 L207_208 0.0381
K9847 L55_56 L142_143 0.0274
K9848 L55_56 L123_124 0.1743
K9849 L55_56 L152_153 0.0212
K9850 L55_56 L191_192 0.0462
K9851 L55_56 L39_40 0.0423
K9852 L55_56 L130_156 0.0616
K9853 L55_56 L156_157 0.0568
K9854 L55_56 L189_190 0.0413
K9855 L55_56 L18_19 0.0449
K9856 L55_56 L201_202 0.0448
K9857 L114_119 L140_145 0.0248
K9858 L114_119 L1_6 0.1053
K9859 L114_119 L13_18 0.059
K9860 L114_119 L35_40 0.0454
K9861 L114_119 L23_28 0.0704
K9862 L114_119 L184_188 0.0599
K9863 L114_119 L6_11 0.1064
K9864 L114_119 L163_168 0.0587
K9865 L114_119 L91_95 0.0314
K9866 L114_119 L144_149 0.0293
K9867 L114_119 L130_160 0.0775
K9868 L114_119 L4_9 0.0537
K9869 L114_119 L156_161 0.0781
K9870 L114_119 L181_185 0.0546
K9871 L114_119 L164_169 0.0516
K9872 L114_119 L106_111 0.0558
K9873 L114_119 L34_39 0.0511
K9874 L114_119 L148_153 0.0288
K9875 L114_119 L201_205 0.0466
K9876 L114_119 L9_14 0.054
K9877 L114_119 L200_204 0.0421
K9878 L114_119 L150_155 0.0229
K9879 L114_119 L145_150 0.0238
K9880 L114_119 L30_35 0.0512
K9881 L114_119 L131_136 0.046
K9882 L114_119 L101_105 0.0228
K9883 L114_119 L46_50 0.0554
K9884 L114_119 L196_200 0.0439
K9885 L114_119 L92_96 0.0305
K9886 L114_119 L81_86 0.0404
K9887 L114_119 L19_24 0.0531
K9888 L114_119 L120_125 0.1086
K9889 L114_119 L8_13 0.0593
K9890 L114_119 L60_64 0.1076
K9891 L114_119 L193_197 0.0515
K9892 L114_119 L7_12 0.0659
K9893 L114_119 L137_142 0.0324
K9894 L114_119 L167_172 0.054
K9895 L114_119 L121_126 0.0553
K9896 L114_119 L195_199 0.035
K9897 L114_119 L97_101 0.0237
K9898 L114_119 L110_115 0.1086
K9899 L114_119 L113_118 0.1145
K9900 L114_119 L134_139 0.032
K9901 L114_119 L141_146 0.0415
K9902 L114_119 L100_104 0.0281
K9903 L114_119 L24_29 0.0648
K9904 L114_119 L138_143 0.0315
K9905 L114_119 L33_38 0.0536
K9906 L114_119 L18_23 0.0581
K9907 L114_119 L107_112 0.0741
K9908 L114_119 L112_117 0.0744
K9909 L114_119 L40_45 0.04
K9910 L114_119 L183_187 0.0667
K9911 L114_119 L136_141 0.0437
K9912 L114_119 L59_63 0.0726
K9913 L114_119 L5_10 0.0417
K9914 L114_119 L15_20 0.0417
K9915 L114_119 L51_55 0.0736
K9916 L114_119 L58_62 0.0549
K9917 L114_119 L67_71 0.0455
K9918 L114_119 L29_34 0.0582
K9919 L114_119 L179_183 0.0671
K9920 L114_119 L41_74 0.0458
K9921 L114_119 L131_170 0.0458
K9922 L114_119 L205_209 0.0444
K9923 L114_119 L191_195 0.0364
K9924 L114_119 L66_70 0.0362
K9925 L114_119 L98_102 0.0294
K9926 L114_119 L27_32 0.0664
K9927 L114_119 L142_147 0.0309
K9928 L114_119 L147_152 0.0295
K9929 L114_119 L178_182 0.0421
K9930 L114_119 L180_184 0.0602
K9931 L114_119 L3_8 0.059
K9932 L114_119 L157_162 0.0713
K9933 L114_119 L149_154 0.0282
K9934 L114_119 L203_207 0.0325
K9935 L114_119 L2_7 0.0655
K9936 L114_119 L117_122 0.0741
K9937 L114_119 L22_27 0.0769
K9938 L114_119 L158_189 0.0537
K9939 L114_119 L38_43 0.0463
K9940 L114_119 L47_51 0.0734
K9941 L114_119 L55_59 0.0734
K9942 L114_119 L135_174 0.0402
K9943 L114_119 L94_98 0.0308
K9944 L114_119 L160_165 0.0654
K9945 L114_119 L52_56 0.1114
K9946 L114_119 L115_120 0.1098
K9947 L114_119 L80_85 0.0324
K9948 L114_119 L10_15 0.0418
K9949 L114_119 L16_21 0.1022
K9950 L114_119 L158_163 0.0655
K9951 L114_119 L185_189 0.0544
K9952 L114_119 L96_100 0.0292
K9953 L114_119 L165_170 0.0544
K9954 L114_119 L186_190 0.0421
K9955 L114_119 L82_87 0.0443
K9956 L114_119 L125_130 0.1051
K9957 L114_119 L108_113 0.1134
K9958 L114_119 L159_164 0.057
K9959 L114_119 L84_89 0.0394
K9960 L114_119 L68_72 0.0513
K9961 L114_119 L169_174 0.0457
K9962 L114_119 L204_208 0.0405
K9963 L114_119 L25_30 0.0565
K9964 L114_119 L32_37 0.0564
K9965 L114_119 L133_172 0.0465
K9966 L114_119 L14_19 0.0537
K9967 L114_119 L44_92 0.0318
K9968 L114_119 L161_166 0.0672
K9969 L114_119 L21_26 0.0761
K9970 L114_119 L95_99 0.03
K9971 L114_119 L116_121 0.0558
K9972 L114_119 L74_79 0.0435
K9973 L114_119 L199_203 0.0337
K9974 L114_119 L75_80 0.0336
K9975 L114_119 L70_75 0.0349
K9976 L114_119 L50_54 0.0555
K9977 L114_119 L79_84 0.0413
K9978 L114_119 L56_60 0.1104
K9979 L114_119 L159_190 0.0417
K9980 L114_119 L93_97 0.0247
K9981 L114_119 L90_94 0.0322
K9982 L114_119 L134_173 0.0448
K9983 L114_119 L139_144 0.0306
K9984 L114_119 L177_181 0.0544
K9985 L114_119 L111_116 0.056
K9986 L114_119 L162_167 0.0627
K9987 L114_119 L43_91 0.0328
K9988 L114_119 L122_127 0.0733
K9989 L114_119 L135_140 0.0258
K9990 L114_119 L39_44 0.0446
K9991 L114_119 L123_128 0.1103
K9992 L114_119 L12_17 0.0655
K9993 L114_119 L54_58 0.0554
K9994 L114_119 L146_151 0.0395
K9995 L114_119 L143_148 0.0301
K9996 L114_119 L11_16 0.1053
K9997 L114_119 L77_82 0.0464
K9998 L47_51 L181_185 0.0312
K9999 L47_51 L140_145 0.0189
K10000 L47_51 L1_6 0.0507
K10001 L47_51 L13_18 0.0329
K10002 L47_51 L35_40 0.0312
K10003 L47_51 L23_28 0.0409
K10004 L47_51 L73_78 0.0421
K10005 L47_51 L6_11 0.0506
K10006 L47_51 L163_168 0.0369
K10007 L47_51 L91_95 0.024
K10008 L47_51 L144_149 0.0227
K10009 L47_51 L130_160 0.0413
K10010 L47_51 L4_9 0.0314
K10011 L47_51 L202_206 0.0404
K10012 L47_51 L109_114 0.0736
K10013 L47_51 L57_61 0.0733
K10014 L47_51 L164_169 0.033
K10015 L47_51 L195_199 0.0405
K10016 L47_51 L106_111 0.1437
K10017 L47_51 L34_39 0.0348
K10018 L47_51 L148_153 0.0227
K10019 L47_51 L201_205 0.0443
K10020 L47_51 L9_14 0.0313
K10021 L47_51 L53_57 0.0741
K10022 L47_51 L69_73 0.0439
K10023 L47_51 L205_209 0.0423
K10024 L47_51 L150_155 0.0179
K10025 L47_51 L145_150 0.0184
K10026 L47_51 L30_35 0.0331
K10027 L47_51 L131_136 0.0347
K10028 L47_51 L101_105 0.018
K10029 L47_51 L46_50 0.1548
K10030 L47_51 L92_96 0.0233
K10031 L47_51 L19_24 0.031
K10032 L47_51 L120_125 0.05
K10033 L47_51 L8_13 0.0331
K10034 L47_51 L60_64 0.1057
K10035 L47_51 L198_202 0.042
K10036 L47_51 L193_197 0.0487
K10037 L47_51 L7_12 0.0351
K10038 L47_51 L137_142 0.0247
K10039 L47_51 L167_172 0.0361
K10040 L47_51 L121_126 0.1215
K10041 L47_51 L97_101 0.0184
K10042 L47_51 L110_115 0.0504
K10043 L47_51 L141_146 0.0325
K10044 L47_51 L100_104 0.0221
K10045 L47_51 L24_29 0.0389
K10046 L47_51 L138_143 0.024
K10047 L47_51 L33_38 0.0362
K10048 L47_51 L18_23 0.0327
K10049 L47_51 L124_129 0.0713
K10050 L47_51 L78_83 0.0405
K10051 L47_51 L134_139 0.0239
K10052 L47_51 L40_45 0.0291
K10053 L47_51 L183_187 0.0347
K10054 L47_51 L136_141 0.0336
K10055 L47_51 L5_10 0.025
K10056 L47_51 L15_20 0.0249
K10057 L47_51 L58_62 0.1273
K10058 L47_51 L29_34 0.037
K10059 L47_51 L179_183 0.0349
K10060 L47_51 L158_189 0.0309
K10061 L47_51 L206_210 0.0389
K10062 L47_51 L41_74 0.0348
K10063 L47_51 L131_170 0.0327
K10064 L47_51 L191_195 0.0427
K10065 L47_51 L66_70 0.043
K10066 L47_51 L98_102 0.0233
K10067 L47_51 L27_32 0.0407
K10068 L47_51 L147_152 0.0233
K10069 L47_51 L178_182 0.0249
K10070 L47_51 L180_184 0.0329
K10071 L47_51 L3_8 0.0331
K10072 L47_51 L157_162 0.0407
K10073 L47_51 L149_154 0.0221
K10074 L47_51 L203_207 0.0365
K10075 L47_51 L2_7 0.0351
K10076 L47_51 L22_27 0.0431
K10077 L47_51 L38_43 0.0335
K10078 L47_51 L113_118 0.1104
K10079 L47_51 L108_113 0.1114
K10080 L47_51 L135_174 0.029
K10081 L47_51 L94_98 0.024
K10082 L47_51 L160_165 0.0388
K10083 L47_51 L52_56 0.1134
K10084 L47_51 L115_120 0.0503
K10085 L47_51 L80_85 0.0367
K10086 L47_51 L10_15 0.025
K10087 L47_51 L16_21 0.0498
K10088 L47_51 L158_163 0.0387
K10089 L47_51 L185_189 0.0311
K10090 L47_51 L96_100 0.0227
K10091 L47_51 L49_53 0.0744
K10092 L47_51 L186_190 0.0248
K10093 L47_51 L156_161 0.0429
K10094 L47_51 L82_87 0.0425
K10095 L47_51 L125_130 0.0495
K10096 L47_51 L184_188 0.0328
K10097 L47_51 L159_164 0.0345
K10098 L47_51 L84_89 0.0315
K10099 L47_51 L68_72 0.0489
K10100 L47_51 L169_174 0.0311
K10101 L47_51 L25_30 0.0346
K10102 L47_51 L32_37 0.0377
K10103 L47_51 L133_172 0.0334
K10104 L47_51 L14_19 0.0312
K10105 L47_51 L44_92 0.0239
K10106 L47_51 L161_166 0.0405
K10107 L47_51 L21_26 0.0415
K10108 L47_51 L95_99 0.0234
K10109 L47_51 L116_121 0.1322
K10110 L47_51 L74_79 0.0336
K10111 L47_51 L165_170 0.0358
K10112 L47_51 L199_203 0.0384
K10113 L47_51 L75_80 0.0385
K10114 L47_51 L143_148 0.0233
K10115 L47_51 L70_75 0.0406
K10116 L47_51 L50_54 0.1506
K10117 L47_51 L79_84 0.0326
K10118 L47_51 L56_60 0.1103
K10119 L47_51 L159_190 0.0246
K10120 L47_51 L93_97 0.0189
K10121 L47_51 L90_94 0.0247
K10122 L47_51 L134_173 0.0322
K10123 L47_51 L139_144 0.0233
K10124 L47_51 L83_88 0.039
K10125 L47_51 L177_181 0.0313
K10126 L47_51 L111_116 0.1405
K10127 L47_51 L162_167 0.0386
K10128 L47_51 L43_91 0.0247
K10129 L47_51 L142_147 0.024
K10130 L47_51 L135_140 0.0193
K10131 L47_51 L39_44 0.0323
K10132 L47_51 L123_128 0.1034
K10133 L47_51 L12_17 0.0349
K10134 L47_51 L54_58 0.1402
K10135 L47_51 L146_151 0.0315
K10136 L47_51 L61_65 0.072
K10137 L47_51 L11_16 0.0503
K10138 L47_51 L77_82 0.0444
K10139 L168_169 L74_90 0.0518
K10140 L168_169 L199_200 0.0328
K10141 L168_169 L115_179 0.0524
K10142 L168_169 L128_129 0.0613
K10143 L168_169 L196_197 0.0396
K10144 L168_169 L1_2 0.0419
K10145 L168_169 L23_24 0.0865
K10146 L168_169 L158_159 0.0897
K10147 L168_169 L136_198 0.0582
K10148 L168_169 L163_164 0.1279
K10149 L168_169 L144_145 0.0498
K10150 L168_169 L91_92 0.0538
K10151 L168_169 L160_161 0.1122
K10152 L168_169 L126_127 0.038
K10153 L168_169 L22_23 0.0843
K10154 L168_169 L204_205 0.0374
K10155 L168_169 L153_154 0.0354
K10156 L168_169 L4_5 0.0437
K10157 L168_169 L41_42 0.0727
K10158 L168_169 L197_198 0.0477
K10159 L168_169 L143_144 0.0496
K10160 L168_169 L200_201 0.0385
K10161 L168_169 L205_206 0.0441
K10162 L168_169 L36_37 0.1084
K10163 L168_169 L131_132 0.0741
K10164 L168_169 L100_101 0.0451
K10165 L168_169 L203_204 0.0321
K10166 L168_169 L92_93 0.054
K10167 L168_169 L81_82 0.0373
K10168 L168_169 L13_14 0.0596
K10169 L168_169 L148_149 0.0454
K10170 L168_169 L19_20 0.0673
K10171 L168_169 L102_103 0.0348
K10172 L168_169 L106_107 0.0351
K10173 L168_169 L64_65 0.0606
K10174 L168_169 L8_9 0.0538
K10175 L168_169 L170_171 0.1122
K10176 L168_169 L193_194 0.0458
K10177 L168_169 L21_65 0.0805
K10178 L168_169 L121_122 0.0397
K10179 L168_169 L9_10 0.054
K10180 L168_169 L195_196 0.0335
K10181 L168_169 L187_188 0.0667
K10182 L168_169 L134_135 0.0788
K10183 L168_169 L41_69 0.0562
K10184 L168_169 L171_172 0.12
K10185 L168_169 L104_105 0.0352
K10186 L168_169 L151_210 0.0464
K10187 L168_169 L79_94 0.0475
K10188 L168_169 L37_38 0.1153
K10189 L168_169 L112_113 0.0455
K10190 L168_169 L183_184 0.0595
K10191 L168_169 L59_60 0.0484
K10192 L168_169 L11_57 0.0715
K10193 L168_169 L38_39 0.1203
K10194 L168_169 L27_28 0.1153
K10195 L168_169 L78_79 0.0545
K10196 L168_169 L44_45 0.0772
K10197 L168_169 L47_48 0.0418
K10198 L168_169 L29_30 0.1221
K10199 L168_169 L76_77 0.0384
K10200 L168_169 L114_115 0.0669
K10201 L168_169 L185_186 0.061
K10202 L168_169 L16_17 0.063
K10203 L168_169 L188_189 0.0683
K10204 L168_169 L118_119 0.0584
K10205 L168_169 L176_177 0.0441
K10206 L168_169 L3_4 0.0435
K10207 L168_169 L6_53 0.0662
K10208 L168_169 L149_150 0.0456
K10209 L168_169 L2_3 0.0429
K10210 L168_169 L98_99 0.0445
K10211 L168_169 L84_98 0.0438
K10212 L168_169 L48_49 0.0506
K10213 L168_169 L110_175 0.0424
K10214 L168_169 L124_125 0.0788
K10215 L168_169 L113_114 0.0554
K10216 L168_169 L52_53 0.055
K10217 L168_169 L80_81 0.032
K10218 L168_169 L17_18 0.0653
K10219 L168_169 L141_202 0.0549
K10220 L168_169 L87_88 0.0397
K10221 L168_169 L146_147 0.0442
K10222 L168_169 L209_210 0.0398
K10223 L168_169 L94_95 0.0484
K10224 L168_169 L136_137 0.0524
K10225 L168_169 L127_128 0.0472
K10226 L168_169 L138_139 0.0545
K10227 L168_169 L42_43 0.0751
K10228 L168_169 L181_182 0.0548
K10229 L168_169 L28_29 0.1203
K10230 L168_169 L157_158 0.0888
K10231 L168_169 L122_123 0.0487
K10232 L168_169 L96_97 0.0492
K10233 L168_169 L66_67 0.0315
K10234 L168_169 L129_130 0.0821
K10235 L168_169 L21_22 0.081
K10236 L168_169 L117_118 0.0471
K10237 L168_169 L51_52 0.0452
K10238 L168_169 L56_57 0.0579
K10239 L168_169 L116_117 0.0388
K10240 L168_169 L173_174 0.1279
K10241 L168_169 L154_155 0.0355
K10242 L168_169 L95_96 0.049
K10243 L168_169 L85_86 0.0294
K10244 L168_169 L7_8 0.053
K10245 L168_169 L82_83 0.0438
K10246 L168_169 L14_15 0.0599
K10247 L168_169 L184_185 0.0606
K10248 L168_169 L141_142 0.048
K10249 L168_169 L62_63 0.0378
K10250 L168_169 L125_187 0.0642
K10251 L168_169 L58_59 0.0395
K10252 L168_169 L103_104 0.0351
K10253 L168_169 L70_71 0.0334
K10254 L168_169 L68_69 0.0455
K10255 L168_169 L180_181 0.0545
K10256 L168_169 L89_102 0.0343
K10257 L168_169 L26_27 0.1084
K10258 L168_169 L50_51 0.0377
K10259 L168_169 L83_84 0.0516
K10260 L168_169 L90_91 0.053
K10261 L168_169 L139_140 0.0548
K10262 L168_169 L161_162 0.12
K10263 L168_169 L111_112 0.0379
K10264 L168_169 L162_163 0.1258
K10265 L168_169 L137_138 0.0537
K10266 L168_169 L179_180 0.0537
K10267 L168_169 L12_13 0.0585
K10268 L168_169 L207_208 0.0295
K10269 L168_169 L142_143 0.049
K10270 L168_169 L123_124 0.0616
K10271 L168_169 L152_153 0.0351
K10272 L168_169 L191_192 0.0316
K10273 L168_169 L39_40 0.1221
K10274 L168_169 L18_19 0.0668
K10275 L168_169 L130_156 0.0828
K10276 L168_169 L156_157 0.0864
K10277 L168_169 L189_190 0.0688
K10278 L168_169 L11_12 0.0569
K10279 L168_169 L54_55 0.0387
K10280 L168_169 L201_202 0.0459
K10281 L110_175 L167_168 0.0434
K10282 L110_175 L74_90 0.0192
K10283 L110_175 L199_200 0.0185
K10284 L110_175 L115_179 0.2697
K10285 L110_175 L128_129 0.0427
K10286 L110_175 L196_197 0.0213
K10287 L110_175 L13_14 0.0969
K10288 L110_175 L23_24 0.0752
K10289 L110_175 L158_159 0.0725
K10290 L110_175 L136_198 0.0258
K10291 L110_175 L163_164 0.058
K10292 L110_175 L144_145 0.018
K10293 L110_175 L91_92 0.0191
K10294 L110_175 L126_127 0.0244
K10295 L110_175 L22_23 0.0794
K10296 L110_175 L204_205 0.0199
K10297 L110_175 L153_154 0.0137
K10298 L110_175 L34_35 0.0419
K10299 L110_175 L41_42 0.0256
K10300 L110_175 L197_198 0.0237
K10301 L110_175 L143_144 0.0182
K10302 L110_175 L200_201 0.0206
K10303 L110_175 L205_206 0.0217
K10304 L110_175 L36_37 0.0339
K10305 L110_175 L131_132 0.0257
K10306 L110_175 L100_101 0.0171
K10307 L110_175 L203_204 0.018
K10308 L110_175 L92_93 0.019
K10309 L110_175 L81_82 0.0198
K10310 L110_175 L148_149 0.0172
K10311 L110_175 L19_20 0.0706
K10312 L110_175 L187_188 0.0983
K10313 L110_175 L102_103 0.0138
K10314 L110_175 L160_161 0.063
K10315 L110_175 L64_65 0.0421
K10316 L110_175 L26_27 0.0613
K10317 L110_175 L165_166 0.0443
K10318 L110_175 L170_171 0.0342
K10319 L110_175 L193_194 0.0229
K10320 L110_175 L21_65 0.0629
K10321 L110_175 L121_122 0.0263
K10322 L110_175 L9_10 0.0915
K10323 L110_175 L195_196 0.019
K10324 L110_175 L134_135 0.0253
K10325 L110_175 L41_69 0.0249
K10326 L110_175 L171_172 0.0341
K10327 L110_175 L104_105 0.0136
K10328 L110_175 L151_210 0.021
K10329 L110_175 L79_94 0.0182
K10330 L110_175 L37_38 0.0338
K10331 L110_175 L112_113 0.0347
K10332 L110_175 L183_184 0.1362
K10333 L110_175 L59_60 0.0336
K10334 L110_175 L11_57 0.0775
K10335 L110_175 L38_39 0.0335
K10336 L110_175 L27_28 0.0607
K10337 L110_175 L96_97 0.018
K10338 L110_175 L78_79 0.0244
K10339 L110_175 L44_45 0.0251
K10340 L110_175 L29_30 0.0566
K10341 L110_175 L76_77 0.0205
K10342 L110_175 L114_115 0.0863
K10343 L110_175 L166_167 0.0441
K10344 L110_175 L185_186 0.0895
K10345 L110_175 L16_17 0.0911
K10346 L110_175 L188_189 0.0877
K10347 L110_175 L118_119 0.0485
K10348 L110_175 L180_181 0.1437
K10349 L110_175 L6_53 0.082
K10350 L110_175 L149_150 0.0171
K10351 L110_175 L98_99 0.0172
K10352 L110_175 L84_98 0.0173
K10353 L110_175 L124_125 0.0746
K10354 L110_175 L113_114 0.0495
K10355 L110_175 L52_53 0.0487
K10356 L110_175 L80_81 0.0179
K10357 L110_175 L17_18 0.0879
K10358 L110_175 L141_202 0.0245
K10359 L110_175 L87_88 0.0196
K10360 L110_175 L146_147 0.0173
K10361 L110_175 L209_210 0.0197
K10362 L110_175 L94_95 0.0182
K10363 L110_175 L136_137 0.0193
K10364 L110_175 L127_128 0.0311
K10365 L110_175 L138_139 0.0192
K10366 L110_175 L42_43 0.0255
K10367 L110_175 L181_182 0.1036
K10368 L110_175 L28_29 0.0591
K10369 L110_175 L157_158 0.0792
K10370 L110_175 L122_123 0.0339
K10371 L110_175 L103_104 0.0137
K10372 L110_175 L66_67 0.0181
K10373 L110_175 L129_130 0.0649
K10374 L110_175 L21_22 0.081
K10375 L110_175 L117_118 0.0344
K10376 L110_175 L51_52 0.0344
K10377 L110_175 L56_57 0.0477
K10378 L110_175 L116_117 0.0266
K10379 L110_175 L173_174 0.0333
K10380 L110_175 L154_155 0.0137
K10381 L110_175 L32_33 0.0435
K10382 L110_175 L95_96 0.0181
K10383 L110_175 L85_86 0.0164
K10384 L110_175 L7_8 0.1426
K10385 L110_175 L82_83 0.0217
K10386 L110_175 L14_15 0.0814
K10387 L110_175 L184_185 0.1116
K10388 L110_175 L141_142 0.0183
K10389 L110_175 L62_63 0.0242
K10390 L110_175 L125_187 0.1028
K10391 L110_175 L58_59 0.0262
K10392 L110_175 L70_71 0.019
K10393 L110_175 L68_69 0.0228
K10394 L110_175 L89_102 0.0138
K10395 L110_175 L8_9 0.1153
K10396 L110_175 L50_51 0.0266
K10397 L110_175 L83_84 0.0232
K10398 L110_175 L90_91 0.0192
K10399 L110_175 L139_140 0.0191
K10400 L110_175 L161_162 0.0624
K10401 L110_175 L111_112 0.0267
K10402 L110_175 L162_163 0.0606
K10403 L110_175 L137_138 0.0193
K10404 L110_175 L179_180 0.2134
K10405 L110_175 L12_13 0.1117
K10406 L110_175 L207_208 0.0164
K10407 L110_175 L142_143 0.0183
K10408 L110_175 L123_124 0.0471
K10409 L110_175 L152_153 0.0138
K10410 L110_175 L191_192 0.0181
K10411 L110_175 L39_40 0.033
K10412 L110_175 L18_19 0.0801
K10413 L110_175 L130_156 0.0863
K10414 L110_175 L156_157 0.0843
K10415 L110_175 L189_190 0.0757
K10416 L110_175 L11_12 0.1183
K10417 L110_175 L54_55 0.0265
K10418 L110_175 L201_202 0.0227
K10419 L55_59 L181_185 0.0312
K10420 L55_59 L140_145 0.0198
K10421 L55_59 L1_6 0.0503
K10422 L55_59 L13_18 0.0331
K10423 L55_59 L35_40 0.0325
K10424 L55_59 L23_28 0.0419
K10425 L55_59 L73_78 0.0457
K10426 L55_59 L6_11 0.0506
K10427 L55_59 L163_168 0.0382
K10428 L55_59 L91_95 0.0254
K10429 L55_59 L144_149 0.0239
K10430 L55_59 L130_160 0.0425
K10431 L55_59 L4_9 0.0312
K10432 L55_59 L202_206 0.0437
K10433 L55_59 L109_114 0.0726
K10434 L55_59 L57_61 0.0744
K10435 L55_59 L164_169 0.034
K10436 L55_59 L195_199 0.0453
K10437 L55_59 L106_111 0.1322
K10438 L55_59 L34_39 0.0363
K10439 L55_59 L148_153 0.024
K10440 L55_59 L201_205 0.0487
K10441 L55_59 L9_14 0.0313
K10442 L55_59 L53_57 0.0741
K10443 L55_59 L69_73 0.0476
K10444 L55_59 L205_209 0.0464
K10445 L55_59 L150_155 0.0189
K10446 L55_59 L145_150 0.0193
K10447 L55_59 L30_35 0.0342
K10448 L55_59 L131_136 0.037
K10449 L55_59 L101_105 0.0189
K10450 L55_59 L46_50 0.1402
K10451 L55_59 L92_96 0.0246
K10452 L55_59 L19_24 0.0313
K10453 L55_59 L120_125 0.0504
K10454 L55_59 L8_13 0.0331
K10455 L55_59 L60_64 0.1134
K10456 L55_59 L198_202 0.0455
K10457 L55_59 L193_197 0.054
K10458 L55_59 L7_12 0.0351
K10459 L55_59 L137_142 0.0262
K10460 L55_59 L167_172 0.0378
K10461 L55_59 L121_126 0.1405
K10462 L55_59 L97_101 0.0194
K10463 L55_59 L110_115 0.05
K10464 L55_59 L141_146 0.0347
K10465 L55_59 L100_104 0.0233
K10466 L55_59 L24_29 0.0397
K10467 L55_59 L138_143 0.0253
K10468 L55_59 L33_38 0.0379
K10469 L55_59 L18_23 0.0331
K10470 L55_59 L124_129 0.0734
K10471 L55_59 L78_83 0.0439
K10472 L55_59 L134_139 0.0251
K10473 L55_59 L40_45 0.0305
K10474 L55_59 L183_187 0.0349
K10475 L55_59 L136_141 0.0358
K10476 L55_59 L5_10 0.0249
K10477 L55_59 L15_20 0.025
K10478 L55_59 L58_62 0.1506
K10479 L55_59 L29_34 0.0383
K10480 L55_59 L179_183 0.0349
K10481 L55_59 L158_189 0.0312
K10482 L55_59 L206_210 0.042
K10483 L55_59 L41_74 0.0371
K10484 L55_59 L131_170 0.0348
K10485 L55_59 L191_195 0.0481
K10486 L55_59 L66_70 0.0484
K10487 L55_59 L98_102 0.0247
K10488 L55_59 L27_32 0.0424
K10489 L55_59 L147_152 0.0247
K10490 L55_59 L178_182 0.0248
K10491 L55_59 L180_184 0.0329
K10492 L55_59 L3_8 0.0329
K10493 L55_59 L157_162 0.0417
K10494 L55_59 L149_154 0.0233
K10495 L55_59 L203_207 0.0405
K10496 L55_59 L2_7 0.0349
K10497 L55_59 L22_27 0.0443
K10498 L55_59 L38_43 0.0353
K10499 L55_59 L113_118 0.1104
K10500 L55_59 L108_113 0.1076
K10501 L55_59 L135_174 0.0304
K10502 L55_59 L94_98 0.0255
K10503 L55_59 L160_165 0.0405
K10504 L55_59 L52_56 0.1134
K10505 L55_59 L115_120 0.0503
K10506 L55_59 L80_85 0.0406
K10507 L55_59 L10_15 0.025
K10508 L55_59 L16_21 0.0506
K10509 L55_59 L158_163 0.0396
K10510 L55_59 L185_189 0.0313
K10511 L55_59 L96_100 0.0239
K10512 L55_59 L49_53 0.0733
K10513 L55_59 L186_190 0.0249
K10514 L55_59 L156_161 0.0441
K10515 L55_59 L82_87 0.0466
K10516 L55_59 L125_130 0.0503
K10517 L55_59 L184_188 0.033
K10518 L55_59 L159_164 0.0352
K10519 L55_59 L84_89 0.0336
K10520 L55_59 L68_72 0.0543
K10521 L55_59 L169_174 0.0324
K10522 L55_59 L25_30 0.0353
K10523 L55_59 L32_37 0.0397
K10524 L55_59 L133_172 0.0352
K10525 L55_59 L14_19 0.0314
K10526 L55_59 L44_92 0.0252
K10527 L55_59 L161_166 0.0422
K10528 L55_59 L21_26 0.0427
K10529 L55_59 L95_99 0.0247
K10530 L55_59 L116_121 0.1437
K10531 L55_59 L74_79 0.0359
K10532 L55_59 L165_170 0.0378
K10533 L55_59 L199_203 0.0427
K10534 L55_59 L75_80 0.043
K10535 L55_59 L143_148 0.0246
K10536 L55_59 L70_75 0.0455
K10537 L55_59 L50_54 0.1506
K10538 L55_59 L79_84 0.0348
K10539 L55_59 L56_60 0.1145
K10540 L55_59 L159_190 0.0249
K10541 L55_59 L93_97 0.0199
K10542 L55_59 L90_94 0.0262
K10543 L55_59 L134_173 0.0339
K10544 L55_59 L139_144 0.0245
K10545 L55_59 L83_88 0.0421
K10546 L55_59 L177_181 0.0311
K10547 L55_59 L111_116 0.1405
K10548 L55_59 L162_167 0.0401
K10549 L55_59 L43_91 0.0261
K10550 L55_59 L142_147 0.0254
K10551 L55_59 L135_140 0.0203
K10552 L55_59 L39_44 0.034
K10553 L55_59 L123_128 0.1104
K10554 L55_59 L12_17 0.0351
K10555 L55_59 L54_58 0.1548
K10556 L55_59 L146_151 0.0336
K10557 L55_59 L61_65 0.0741
K10558 L55_59 L11_16 0.0507
K10559 L55_59 L77_82 0.0489
K10560 L114_115 L167_168 0.0696
K10561 L114_115 L74_90 0.0326
K10562 L114_115 L199_200 0.0365
K10563 L114_115 L128_129 0.1369
K10564 L114_115 L196_197 0.0419
K10565 L114_115 L13_14 0.1117
K10566 L114_115 L23_24 0.1048
K10567 L114_115 L158_159 0.0975
K10568 L114_115 L136_198 0.0462
K10569 L114_115 L163_164 0.0861
K10570 L114_115 L144_145 0.0299
K10571 L114_115 L91_92 0.0319
K10572 L114_115 L160_161 0.1029
K10573 L114_115 L126_127 0.0594
K10574 L114_115 L22_23 0.1157
K10575 L114_115 L204_205 0.0382
K10576 L114_115 L153_154 0.023
K10577 L114_115 L4_5 0.0542
K10578 L114_115 L34_35 0.0662
K10579 L114_115 L41_42 0.0433
K10580 L114_115 L197_198 0.045
K10581 L114_115 L143_144 0.0303
K10582 L114_115 L200_201 0.04
K10583 L114_115 L205_206 0.0405
K10584 L114_115 L131_132 0.0435
K10585 L114_115 L100_101 0.0284
K10586 L114_115 L203_204 0.0351
K10587 L114_115 L92_93 0.0314
K10588 L114_115 L81_82 0.0381
K10589 L114_115 L1_2 0.082
K10590 L114_115 L148_149 0.0288
K10591 L114_115 L19_20 0.0885
K10592 L114_115 L187_188 0.1252
K10593 L114_115 L165_166 0.074
K10594 L114_115 L102_103 0.0232
K10595 L114_115 L106_107 0.0621
K10596 L114_115 L64_65 0.13
K10597 L114_115 L26_27 0.1002
K10598 L114_115 L170_171 0.0576
K10599 L114_115 L193_194 0.0438
K10600 L114_115 L21_65 0.1684
K10601 L114_115 L121_122 0.0648
K10602 L114_115 L195_196 0.0379
K10603 L114_115 L134_135 0.0416
K10604 L114_115 L41_69 0.0448
K10605 L114_115 L171_172 0.0566
K10606 L114_115 L104_105 0.0227
K10607 L114_115 L151_210 0.0371
K10608 L114_115 L79_94 0.0308
K10609 L114_115 L37_38 0.0562
K10610 L114_115 L124_125 0.2392
K10611 L114_115 L183_184 0.1476
K10612 L114_115 L59_60 0.0931
K10613 L114_115 L11_57 0.2659
K10614 L114_115 L38_39 0.055
K10615 L114_115 L27_28 0.0955
K10616 L114_115 L96_97 0.0298
K10617 L114_115 L78_79 0.0435
K10618 L114_115 L44_45 0.0414
K10619 L114_115 L47_48 0.0923
K10620 L114_115 L29_30 0.0845
K10621 L114_115 L76_77 0.0399
K10622 L114_115 L166_167 0.0721
K10623 L114_115 L185_186 0.0996
K10624 L114_115 L16_17 0.1327
K10625 L114_115 L118_119 0.1933
K10626 L114_115 L176_177 0.0629
K10627 L114_115 L3_4 0.0612
K10628 L114_115 L149_150 0.0285
K10629 L114_115 L2_3 0.0702
K10630 L114_115 L98_99 0.029
K10631 L114_115 L84_98 0.0293
K10632 L114_115 L48_49 0.1765
K10633 L114_115 L80_81 0.035
K10634 L114_115 L17_18 0.1165
K10635 L114_115 L141_202 0.0437
K10636 L114_115 L87_88 0.0363
K10637 L114_115 L146_147 0.0294
K10638 L114_115 L209_210 0.0364
K10639 L114_115 L94_95 0.0306
K10640 L114_115 L136_137 0.0328
K10641 L114_115 L127_128 0.0854
K10642 L114_115 L138_139 0.032
K10643 L114_115 L42_43 0.0428
K10644 L114_115 L28_29 0.0902
K10645 L114_115 L157_158 0.1088
K10646 L114_115 L122_123 0.0952
K10647 L114_115 L103_104 0.0229
K10648 L114_115 L66_67 0.0363
K10649 L114_115 L129_130 0.1829
K10650 L114_115 L21_22 0.1262
K10651 L114_115 L117_118 0.0993
K10652 L114_115 L56_57 0.1743
K10653 L114_115 L116_117 0.066
K10654 L114_115 L188_189 0.1069
K10655 L114_115 L173_174 0.054
K10656 L114_115 L154_155 0.0228
K10657 L114_115 L32_33 0.0711
K10658 L114_115 L95_96 0.0302
K10659 L114_115 L85_86 0.0317
K10660 L114_115 L82_83 0.0404
K10661 L114_115 L14_15 0.095
K10662 L114_115 L184_185 0.1196
K10663 L114_115 L141_142 0.031
K10664 L114_115 L62_63 0.0588
K10665 L114_115 L125_187 0.1459
K10666 L114_115 L58_59 0.0642
K10667 L114_115 L70_71 0.0378
K10668 L114_115 L68_69 0.0436
K10669 L114_115 L89_102 0.0233
K10670 L114_115 L36_37 0.0571
K10671 L114_115 L83_84 0.0412
K10672 L114_115 L90_91 0.0323
K10673 L114_115 L139_140 0.0315
K10674 L114_115 L161_162 0.0978
K10675 L114_115 L162_163 0.0921
K10676 L114_115 L137_138 0.0324
K10677 L114_115 L12_13 0.133
K10678 L114_115 L207_208 0.0318
K10679 L114_115 L142_143 0.0307
K10680 L114_115 L123_124 0.1646
K10681 L114_115 L152_153 0.0233
K10682 L114_115 L191_192 0.0364
K10683 L114_115 L39_40 0.0537
K10684 L114_115 L18_19 0.1014
K10685 L114_115 L130_156 0.1332
K10686 L114_115 L156_157 0.121
K10687 L114_115 L189_190 0.0921
K10688 L114_115 L11_12 0.1583
K10689 L114_115 L54_55 0.0653
K10690 L114_115 L201_202 0.0427
K10691 L94_98 L24_29 0.0339
K10692 L94_98 L181_185 0.0232
K10693 L94_98 L140_145 0.0789
K10694 L94_98 L1_6 0.0281
K10695 L94_98 L13_18 0.025
K10696 L94_98 L35_40 0.0492
K10697 L94_98 L23_28 0.0342
K10698 L94_98 L73_78 0.0667
K10699 L94_98 L184_188 0.0248
K10700 L94_98 L6_11 0.0297
K10701 L94_98 L163_168 0.0415
K10702 L94_98 L91_95 0.1832
K10703 L94_98 L144_149 0.1173
K10704 L94_98 L130_160 0.0364
K10705 L94_98 L4_9 0.0221
K10706 L94_98 L202_206 0.0659
K10707 L94_98 L109_114 0.0294
K10708 L94_98 L57_61 0.0324
K10709 L94_98 L164_169 0.0377
K10710 L94_98 L195_199 0.027
K10711 L94_98 L106_111 0.0192
K10712 L94_98 L34_39 0.0548
K10713 L94_98 L148_153 0.1438
K10714 L94_98 L201_205 0.0457
K10715 L94_98 L53_57 0.0309
K10716 L94_98 L69_73 0.0654
K10717 L94_98 L200_204 0.0349
K10718 L94_98 L150_155 0.0789
K10719 L94_98 L145_150 0.0811
K10720 L94_98 L30_35 0.0381
K10721 L94_98 L131_136 0.1056
K10722 L94_98 L101_105 0.0861
K10723 L94_98 L46_50 0.0192
K10724 L94_98 L196_200 0.0349
K10725 L94_98 L92_96 0.1284
K10726 L94_98 L81_86 0.0351
K10727 L94_98 L19_24 0.0263
K10728 L94_98 L120_125 0.0313
K10729 L94_98 L8_13 0.0235
K10730 L94_98 L60_64 0.03
K10731 L94_98 L198_202 0.0655
K10732 L94_98 L193_197 0.0451
K10733 L94_98 L167_172 0.0555
K10734 L94_98 L121_126 0.0208
K10735 L94_98 L97_101 0.0891
K10736 L94_98 L110_115 0.028
K10737 L94_98 L113_118 0.0277
K10738 L94_98 L141_146 0.1161
K10739 L94_98 L100_104 0.1284
K10740 L94_98 L9_14 0.0233
K10741 L94_98 L138_143 0.1438
K10742 L94_98 L33_38 0.0565
K10743 L94_98 L18_23 0.0266
K10744 L94_98 L134_139 0.1015
K10745 L94_98 L124_129 0.0338
K10746 L94_98 L107_112 0.024
K10747 L94_98 L78_83 0.0671
K10748 L94_98 L112_117 0.0247
K10749 L94_98 L40_45 0.068
K10750 L94_98 L136_141 0.1131
K10751 L94_98 L59_63 0.0262
K10752 L94_98 L5_10 0.0181
K10753 L94_98 L15_20 0.0203
K10754 L94_98 L51_55 0.0247
K10755 L94_98 L58_62 0.0209
K10756 L94_98 L67_71 0.0349
K10757 L94_98 L29_34 0.0419
K10758 L94_98 L206_210 0.0655
K10759 L94_98 L41_74 0.1129
K10760 L94_98 L131_170 0.1083
K10761 L94_98 L205_209 0.0455
K10762 L94_98 L191_195 0.0269
K10763 L94_98 L178_182 0.0181
K10764 L94_98 L180_184 0.0234
K10765 L94_98 L3_8 0.0222
K10766 L94_98 L157_162 0.034
K10767 L94_98 L149_154 0.1127
K10768 L94_98 L203_207 0.027
K10769 L94_98 L66_70 0.027
K10770 L94_98 L117_122 0.0254
K10771 L94_98 L158_189 0.0262
K10772 L94_98 L38_43 0.083
K10773 L94_98 L135_174 0.0661
K10774 L94_98 L160_165 0.047
K10775 L94_98 L52_56 0.0278
K10776 L94_98 L115_120 0.0296
K10777 L94_98 L80_85 0.0271
K10778 L94_98 L10_15 0.0192
K10779 L94_98 L16_21 0.0334
K10780 L94_98 L158_163 0.0337
K10781 L94_98 L185_189 0.0246
K10782 L94_98 L96_100 0.1354
K10783 L94_98 L49_53 0.0295
K10784 L94_98 L186_190 0.0202
K10785 L94_98 L82_87 0.0459
K10786 L94_98 L125_130 0.0332
K10787 L94_98 L108_113 0.0267
K10788 L94_98 L159_164 0.0307
K10789 L94_98 L84_89 0.1224
K10790 L94_98 L68_72 0.0455
K10791 L94_98 L169_174 0.0485
K10792 L94_98 L204_208 0.0349
K10793 L94_98 L25_30 0.0309
K10794 L94_98 L133_172 0.08
K10795 L94_98 L14_19 0.0247
K10796 L94_98 L44_92 0.1124
K10797 L94_98 L21_26 0.0367
K10798 L94_98 L95_99 0.2054
K10799 L94_98 L116_121 0.0203
K10800 L94_98 L74_79 0.1224
K10801 L94_98 L165_170 0.0661
K10802 L94_98 L199_203 0.0271
K10803 L94_98 L75_80 0.0272
K10804 L94_98 L143_148 0.1536
K10805 L94_98 L70_75 0.0271
K10806 L94_98 L50_54 0.0197
K10807 L94_98 L79_84 0.1262
K10808 L94_98 L56_60 0.0288
K10809 L94_98 L159_190 0.0215
K10810 L94_98 L93_97 0.0861
K10811 L94_98 L134_173 0.0754
K10812 L94_98 L139_144 0.1127
K10813 L94_98 L83_88 0.0667
K10814 L94_98 L177_181 0.022
K10815 L94_98 L111_116 0.0197
K10816 L94_98 L162_167 0.0422
K10817 L94_98 L43_91 0.1439
K10818 L94_98 L122_127 0.0262
K10819 L94_98 L135_140 0.073
K10820 L94_98 L39_44 0.0779
K10821 L94_98 L123_128 0.0298
K10822 L94_98 L54_58 0.0203
K10823 L94_98 L146_151 0.1131
K10824 L94_98 L61_65 0.034
K10825 L94_98 L11_16 0.0314
K10826 L94_98 L77_82 0.0461
K10827 L17_18 L167_168 0.0668
K10828 L17_18 L74_90 0.0268
K10829 L17_18 L199_200 0.023
K10830 L17_18 L115_179 0.1127
K10831 L17_18 L128_129 0.0493
K10832 L17_18 L196_197 0.027
K10833 L17_18 L95_96 0.0251
K10834 L17_18 L1_2 0.0983
K10835 L17_18 L23_24 0.1891
K10836 L17_18 L158_159 0.136
K10837 L17_18 L136_198 0.0343
K10838 L17_18 L163_164 0.098
K10839 L17_18 L144_145 0.0248
K10840 L17_18 L91_92 0.0268
K10841 L17_18 L160_161 0.1035
K10842 L17_18 L126_127 0.0283
K10843 L17_18 L22_23 0.2069
K10844 L17_18 L204_205 0.0252
K10845 L17_18 L153_154 0.0187
K10846 L17_18 L4_5 0.0877
K10847 L17_18 L34_35 0.0667
K10848 L17_18 L41_42 0.0362
K10849 L17_18 L197_198 0.0307
K10850 L17_18 L143_144 0.025
K10851 L17_18 L200_201 0.026
K10852 L17_18 L205_206 0.0281
K10853 L17_18 L36_37 0.0496
K10854 L17_18 L131_132 0.0359
K10855 L17_18 L100_101 0.0235
K10856 L17_18 L203_204 0.0224
K10857 L17_18 L92_93 0.0266
K10858 L17_18 L81_82 0.0252
K10859 L17_18 L13_14 0.1832
K10860 L17_18 L148_149 0.0235
K10861 L17_18 L165_166 0.0668
K10862 L17_18 L102_103 0.0188
K10863 L17_18 L106_107 0.0332
K10864 L17_18 L64_65 0.05
K10865 L17_18 L26_27 0.1098
K10866 L17_18 L170_171 0.049
K10867 L17_18 L193_194 0.0296
K10868 L17_18 L21_65 0.0803
K10869 L17_18 L9_10 0.1124
K10870 L17_18 L195_196 0.0236
K10871 L17_18 L134_135 0.0356
K10872 L17_18 L41_69 0.0335
K10873 L17_18 L171_172 0.0492
K10874 L17_18 L104_105 0.0187
K10875 L17_18 L151_210 0.0277
K10876 L17_18 L79_94 0.0251
K10877 L17_18 L37_38 0.0498
K10878 L17_18 L112_113 0.0474
K10879 L17_18 L183_184 0.1536
K10880 L17_18 L11_57 0.1476
K10881 L17_18 L38_39 0.0496
K10882 L17_18 L27_28 0.1123
K10883 L17_18 L78_79 0.0326
K10884 L17_18 L44_45 0.0359
K10885 L17_18 L47_48 0.0444
K10886 L17_18 L29_30 0.1032
K10887 L17_18 L76_77 0.0261
K10888 L17_18 L166_167 0.0673
K10889 L17_18 L185_186 0.1226
K10890 L17_18 L191_192 0.0225
K10891 L17_18 L118_119 0.0723
K10892 L17_18 L176_177 0.0879
K10893 L17_18 L3_4 0.0983
K10894 L17_18 L6_53 0.1252
K10895 L17_18 L149_150 0.0234
K10896 L17_18 L2_3 0.1028
K10897 L17_18 L98_99 0.0237
K10898 L17_18 L84_98 0.0237
K10899 L17_18 L48_49 0.0653
K10900 L17_18 L113_114 0.0693
K10901 L17_18 L52_53 0.071
K10902 L17_18 L80_81 0.0225
K10903 L17_18 L141_202 0.0325
K10904 L17_18 L87_88 0.0255
K10905 L17_18 L146_147 0.0235
K10906 L17_18 L209_210 0.0254
K10907 L17_18 L94_95 0.0252
K10908 L17_18 L136_137 0.0266
K10909 L17_18 L127_128 0.036
K10910 L17_18 L138_139 0.0266
K10911 L17_18 L42_43 0.0363
K10912 L17_18 L181_182 0.1015
K10913 L17_18 L28_29 0.1098
K10914 L17_18 L157_158 0.1556
K10915 L17_18 L96_97 0.025
K10916 L17_18 L66_67 0.0225
K10917 L17_18 L129_130 0.0776
K10918 L17_18 L21_22 0.1891
K10919 L17_18 L117_118 0.0482
K10920 L17_18 L51_52 0.0478
K10921 L17_18 L56_57 0.0741
K10922 L17_18 L116_117 0.0361
K10923 L17_18 L173_174 0.0484
K10924 L17_18 L154_155 0.0186
K10925 L17_18 L32_33 0.0688
K10926 L17_18 L103_104 0.0188
K10927 L17_18 L85_86 0.0205
K10928 L17_18 L7_8 0.1354
K10929 L17_18 L82_83 0.0282
K10930 L17_18 L14_15 0.1439
K10931 L17_18 L184_185 0.1438
K10932 L17_18 L141_142 0.025
K10933 L17_18 L62_63 0.0284
K10934 L17_18 L70_71 0.0237
K10935 L17_18 L68_69 0.0297
K10936 L17_18 L180_181 0.1127
K10937 L17_18 L89_102 0.0188
K10938 L17_18 L8_9 0.1284
K10939 L17_18 L50_51 0.0359
K10940 L17_18 L83_84 0.0309
K10941 L17_18 L90_91 0.0269
K10942 L17_18 L139_140 0.0265
K10943 L17_18 L161_162 0.1055
K10944 L17_18 L111_112 0.0357
K10945 L17_18 L162_163 0.1035
K10946 L17_18 L137_138 0.0267
K10947 L17_18 L179_180 0.1173
K10948 L17_18 L12_13 0.2054
K10949 L17_18 L207_208 0.0205
K10950 L17_18 L142_143 0.025
K10951 L17_18 L152_153 0.0187
K10952 L17_18 L39_40 0.049
K10953 L17_18 L130_156 0.1556
K10954 L17_18 L156_157 0.1644
K10955 L17_18 L11_12 0.1832
K10956 L17_18 L54_55 0.0363
K10957 L17_18 L201_202 0.0293
K10958 L62_63 L167_168 0.0398
K10959 L62_63 L74_90 0.0263
K10960 L62_63 L115_179 0.0294
K10961 L62_63 L196_197 0.0508
K10962 L62_63 L1_2 0.0244
K10963 L62_63 L102_103 0.0192
K10964 L62_63 L136_198 0.0402
K10965 L62_63 L163_164 0.0396
K10966 L62_63 L144_145 0.0229
K10967 L62_63 L91_92 0.0245
K10968 L62_63 L160_161 0.0473
K10969 L62_63 L146_147 0.0245
K10970 L62_63 L204_205 0.0449
K10971 L62_63 L153_154 0.0186
K10972 L62_63 L4_5 0.0209
K10973 L62_63 L34_35 0.038
K10974 L62_63 L41_42 0.0337
K10975 L62_63 L197_198 0.0459
K10976 L62_63 L143_144 0.0237
K10977 L62_63 L200_201 0.0477
K10978 L62_63 L205_206 0.0414
K10979 L62_63 L36_37 0.0407
K10980 L62_63 L131_132 0.0335
K10981 L62_63 L100_101 0.0223
K10982 L62_63 L203_204 0.0462
K10983 L62_63 L92_93 0.0236
K10984 L62_63 L81_82 0.0451
K10985 L62_63 L13_14 0.0268
K10986 L62_63 L148_149 0.023
K10987 L62_63 L19_20 0.0256
K10988 L62_63 L187_188 0.0283
K10989 L62_63 L165_166 0.0443
K10990 L62_63 L106_107 0.1492
K10991 L62_63 L8_9 0.0266
K10992 L62_63 L170_171 0.0406
K10993 L62_63 L193_194 0.0446
K10994 L62_63 L141_142 0.0253
K10995 L62_63 L121_122 0.2623
K10996 L62_63 L195_196 0.0528
K10997 L62_63 L134_135 0.0298
K10998 L62_63 L41_69 0.0388
K10999 L62_63 L171_172 0.0387
K11000 L62_63 L104_105 0.0181
K11001 L62_63 L151_210 0.0335
K11002 L62_63 L79_94 0.0254
K11003 L62_63 L37_38 0.0389
K11004 L62_63 L112_113 0.13
K11005 L62_63 L183_184 0.0281
K11006 L62_63 L59_60 0.1877
K11007 L62_63 L11_57 0.0608
K11008 L62_63 L38_39 0.0371
K11009 L62_63 L27_28 0.0447
K11010 L62_63 L96_97 0.023
K11011 L62_63 L78_79 0.0387
K11012 L62_63 L44_45 0.0299
K11013 L62_63 L47_48 0.123
K11014 L62_63 L29_30 0.0398
K11015 L62_63 L76_77 0.0479
K11016 L62_63 L166_167 0.0419
K11017 L62_63 L185_186 0.0254
K11018 L62_63 L16_17 0.03
K11019 L62_63 L188_189 0.0268
K11020 L62_63 L118_119 0.0878
K11021 L62_63 L176_177 0.0219
K11022 L62_63 L3_4 0.0219
K11023 L62_63 L6_53 0.0594
K11024 L62_63 L149_150 0.0223
K11025 L62_63 L2_3 0.0231
K11026 L62_63 L98_99 0.0238
K11027 L62_63 L184_185 0.0267
K11028 L62_63 L84_98 0.0246
K11029 L62_63 L48_49 0.0785
K11030 L62_63 L124_125 0.0611
K11031 L62_63 L113_114 0.0837
K11032 L62_63 L52_53 0.0854
K11033 L62_63 L80_81 0.0465
K11034 L62_63 L141_202 0.0386
K11035 L62_63 L87_88 0.0373
K11036 L62_63 L209_210 0.0372
K11037 L62_63 L94_95 0.0246
K11038 L62_63 L136_137 0.0262
K11039 L62_63 L138_139 0.0244
K11040 L62_63 L42_43 0.0323
K11041 L62_63 L181_182 0.0252
K11042 L62_63 L28_29 0.0421
K11043 L62_63 L122_123 0.1674
K11044 L62_63 L103_104 0.0187
K11045 L62_63 L66_67 0.0524
K11046 L62_63 L9_10 0.0253
K11047 L62_63 L117_118 0.1479
K11048 L62_63 L51_52 0.1369
K11049 L62_63 L56_57 0.0898
K11050 L62_63 L116_117 0.2081
K11051 L62_63 L173_174 0.0354
K11052 L62_63 L154_155 0.0181
K11053 L62_63 L32_33 0.0421
K11054 L62_63 L95_96 0.0238
K11055 L62_63 L85_86 0.0414
K11056 L62_63 L7_8 0.0279
K11057 L62_63 L82_83 0.0416
K11058 L62_63 L14_15 0.0255
K11059 L62_63 L199_200 0.0493
K11060 L62_63 L125_187 0.0299
K11061 L62_63 L58_59 0.3407
K11062 L62_63 L70_71 0.0532
K11063 L62_63 L68_69 0.0449
K11064 L62_63 L180_181 0.0265
K11065 L62_63 L89_102 0.0198
K11066 L62_63 L26_27 0.0476
K11067 L62_63 L50_51 0.1829
K11068 L62_63 L83_84 0.0372
K11069 L62_63 L90_91 0.0254
K11070 L62_63 L139_140 0.0236
K11071 L62_63 L161_162 0.0445
K11072 L62_63 L111_112 0.1684
K11073 L62_63 L162_163 0.0419
K11074 L62_63 L137_138 0.0253
K11075 L62_63 L179_180 0.0278
K11076 L62_63 L12_13 0.0282
K11077 L62_63 L207_208 0.0412
K11078 L62_63 L142_143 0.0245
K11079 L62_63 L123_124 0.0911
K11080 L62_63 L152_153 0.0192
K11081 L62_63 L191_192 0.052
K11082 L62_63 L39_40 0.0355
K11083 L62_63 L18_19 0.0269
K11084 L62_63 L189_190 0.0255
K11085 L62_63 L11_12 0.0298
K11086 L62_63 L54_55 0.2387
K11087 L62_63 L201_202 0.0436
K11088 L209_210 L167_168 0.0414
K11089 L209_210 L74_90 0.0513
K11090 L209_210 L115_179 0.024
K11091 L209_210 L196_197 0.1369
K11092 L209_210 L1_2 0.0196
K11093 L209_210 L23_24 0.0307
K11094 L209_210 L158_159 0.03
K11095 L209_210 L136_198 0.1369
K11096 L209_210 L163_164 0.0354
K11097 L209_210 L144_145 0.0414
K11098 L209_210 L91_92 0.0434
K11099 L209_210 L160_161 0.0387
K11100 L209_210 L126_127 0.0373
K11101 L209_210 L22_23 0.0315
K11102 L209_210 L204_205 0.1877
K11103 L209_210 L4_5 0.0184
K11104 L209_210 L34_35 0.0397
K11105 L209_210 L41_42 0.0558
K11106 L209_210 L197_198 0.1829
K11107 L209_210 L143_144 0.0449
K11108 L209_210 L200_201 0.1593
K11109 L209_210 L205_206 0.3407
K11110 L209_210 L36_37 0.0519
K11111 L209_210 L131_132 0.0564
K11112 L209_210 L100_101 0.0416
K11113 L209_210 L203_204 0.0934
K11114 L209_210 L92_93 0.0402
K11115 L209_210 L81_82 0.1674
K11116 L209_210 L13_14 0.0238
K11117 L209_210 L148_149 0.0456
K11118 L209_210 L19_20 0.0241
K11119 L209_210 L187_188 0.0255
K11120 L209_210 L165_166 0.0447
K11121 L209_210 L128_129 0.0414
K11122 L209_210 L106_107 0.0318
K11123 L209_210 L8_9 0.0229
K11124 L209_210 L170_171 0.0523
K11125 L209_210 L193_194 0.1605
K11126 L209_210 L21_65 0.0401
K11127 L209_210 L121_122 0.0377
K11128 L209_210 L9_10 0.0224
K11129 L209_210 L195_196 0.0854
K11130 L209_210 L134_135 0.0459
K11131 L209_210 L41_69 0.1173
K11132 L209_210 L171_172 0.0497
K11133 L209_210 L180_181 0.023
K11134 L209_210 L79_94 0.053
K11135 L209_210 L37_38 0.0494
K11136 L209_210 L112_113 0.0364
K11137 L209_210 L183_184 0.0244
K11138 L209_210 L59_60 0.0401
K11139 L209_210 L11_57 0.0381
K11140 L209_210 L38_39 0.0469
K11141 L209_210 L27_28 0.0374
K11142 L209_210 L78_79 0.1479
K11143 L209_210 L44_45 0.0455
K11144 L209_210 L47_48 0.0334
K11145 L209_210 L29_30 0.0352
K11146 L209_210 L76_77 0.1479
K11147 L209_210 L166_167 0.0431
K11148 L209_210 L185_186 0.0233
K11149 L209_210 L16_17 0.026
K11150 L209_210 L188_189 0.0248
K11151 L209_210 L181_182 0.0225
K11152 L209_210 L118_119 0.0391
K11153 L209_210 L176_177 0.0189
K11154 L209_210 L3_4 0.0188
K11155 L209_210 L6_53 0.0363
K11156 L209_210 L149_150 0.042
K11157 L209_210 L2_3 0.0192
K11158 L209_210 L98_99 0.0493
K11159 L209_210 L84_98 0.0543
K11160 L209_210 L48_49 0.0341
K11161 L209_210 L124_125 0.0403
K11162 L209_210 L113_114 0.0371
K11163 L209_210 L52_53 0.037
K11164 L209_210 L80_81 0.0911
K11165 L209_210 L141_202 0.1593
K11166 L209_210 L146_147 0.0552
K11167 L209_210 L94_95 0.0483
K11168 L209_210 L136_137 0.052
K11169 L209_210 L127_128 0.0403
K11170 L209_210 L138_139 0.0438
K11171 L209_210 L42_43 0.052
K11172 L209_210 L28_29 0.0363
K11173 L209_210 L157_158 0.0308
K11174 L209_210 L122_123 0.0403
K11175 L209_210 L96_97 0.041
K11176 L209_210 L66_67 0.077
K11177 L209_210 L129_130 0.0403
K11178 L209_210 L64_65 0.0412
K11179 L209_210 L117_118 0.0383
K11180 L209_210 L51_52 0.0363
K11181 L209_210 L56_57 0.039
K11182 L209_210 L116_117 0.036
K11183 L209_210 L173_174 0.0449
K11184 L209_210 L32_33 0.0429
K11185 L209_210 L95_96 0.0444
K11186 L209_210 L21_22 0.0323
K11187 L209_210 L7_8 0.0234
K11188 L209_210 L82_83 0.2623
K11189 L209_210 L14_15 0.0233
K11190 L209_210 L184_185 0.0239
K11191 L209_210 L141_142 0.0538
K11192 L209_210 L199_200 0.0898
K11193 L209_210 L125_187 0.0261
K11194 L209_210 L58_59 0.0376
K11195 L209_210 L70_71 0.0837
K11196 L209_210 L68_69 0.1492
K11197 L209_210 L26_27 0.0385
K11198 L209_210 L50_51 0.0344
K11199 L209_210 L83_84 0.1674
K11200 L209_210 L90_91 0.047
K11201 L209_210 L139_140 0.0406
K11202 L209_210 L161_162 0.0376
K11203 L209_210 L111_112 0.0345
K11204 L209_210 L162_163 0.0365
K11205 L209_210 L137_138 0.0476
K11206 L209_210 L179_180 0.0235
K11207 L209_210 L12_13 0.0244
K11208 L209_210 L142_143 0.0489
K11209 L209_210 L123_124 0.0413
K11210 L209_210 L191_192 0.0785
K11211 L209_210 L39_40 0.0447
K11212 L209_210 L18_19 0.0248
K11213 L209_210 L130_156 0.0324
K11214 L209_210 L156_157 0.0316
K11215 L209_210 L189_190 0.0242
K11216 L209_210 L11_12 0.0249
K11217 L209_210 L54_55 0.0359
K11218 L209_210 L201_202 0.2387
K11219 L94_95 L167_168 0.049
K11220 L94_95 L74_90 0.1832
K11221 L94_95 L115_179 0.0222
K11222 L94_95 L128_129 0.0316
K11223 L94_95 L196_197 0.0482
K11224 L94_95 L1_2 0.0183
K11225 L94_95 L23_24 0.0315
K11226 L94_95 L158_159 0.0311
K11227 L94_95 L136_198 0.133
K11228 L94_95 L163_164 0.0383
K11229 L94_95 L91_92 0.1832
K11230 L94_95 L160_161 0.0386
K11231 L94_95 L126_127 0.0245
K11232 L94_95 L22_23 0.0316
K11233 L94_95 L204_205 0.0385
K11234 L94_95 L153_154 0.0988
K11235 L94_95 L4_5 0.0182
K11236 L94_95 L34_35 0.049
K11237 L94_95 L41_42 0.1076
K11238 L94_95 L197_198 0.0723
K11239 L94_95 L191_192 0.0335
K11240 L94_95 L205_206 0.0527
K11241 L94_95 L36_37 0.0683
K11242 L94_95 L131_132 0.1006
K11243 L94_95 L100_101 0.1439
K11244 L94_95 L203_204 0.0303
K11245 L94_95 L92_93 0.1439
K11246 L94_95 L81_82 0.0387
K11247 L94_95 L13_14 0.0237
K11248 L94_95 L148_149 0.1438
K11249 L94_95 L19_20 0.025
K11250 L94_95 L187_188 0.025
K11251 L94_95 L165_166 0.049
K11252 L94_95 L102_103 0.1216
K11253 L94_95 L106_107 0.0219
K11254 L94_95 L64_65 0.0317
K11255 L94_95 L8_9 0.0223
K11256 L94_95 L170_171 0.0668
K11257 L94_95 L193_194 0.0668
K11258 L94_95 L21_65 0.0346
K11259 L94_95 L121_122 0.0253
K11260 L94_95 L9_10 0.0222
K11261 L94_95 L195_196 0.0361
K11262 L94_95 L134_135 0.0947
K11263 L94_95 L41_69 0.132
K11264 L94_95 L171_172 0.0673
K11265 L94_95 L104_105 0.0985
K11266 L94_95 L151_210 0.0738
K11267 L94_95 L138_139 0.1438
K11268 L94_95 L37_38 0.0688
K11269 L94_95 L98_99 0.2054
K11270 L94_95 L112_113 0.0263
K11271 L94_95 L183_184 0.0236
K11272 L94_95 L59_60 0.0286
K11273 L94_95 L11_57 0.0324
K11274 L94_95 L38_39 0.0683
K11275 L94_95 L27_28 0.039
K11276 L94_95 L44_45 0.1004
K11277 L94_95 L47_48 0.0244
K11278 L94_95 L29_30 0.0386
K11279 L94_95 L166_167 0.0492
K11280 L94_95 L185_186 0.0234
K11281 L94_95 L16_17 0.0251
K11282 L94_95 L188_189 0.025
K11283 L94_95 L118_119 0.0302
K11284 L94_95 L176_177 0.0182
K11285 L94_95 L3_4 0.0183
K11286 L94_95 L6_53 0.0307
K11287 L94_95 L149_150 0.1226
K11288 L94_95 L2_3 0.0183
K11289 L94_95 L84_98 0.1832
K11290 L94_95 L48_49 0.0266
K11291 L94_95 L124_125 0.0342
K11292 L94_95 L113_114 0.0288
K11293 L94_95 L52_53 0.0289
K11294 L94_95 L80_81 0.0304
K11295 L94_95 L87_88 0.0489
K11296 L94_95 L146_147 0.1438
K11297 L94_95 L136_137 0.1438
K11298 L94_95 L127_128 0.028
K11299 L94_95 L42_43 0.1104
K11300 L94_95 L181_182 0.0221
K11301 L94_95 L28_29 0.0389
K11302 L94_95 L157_158 0.0313
K11303 L94_95 L122_123 0.0285
K11304 L94_95 L161_162 0.0387
K11305 L94_95 L66_67 0.0337
K11306 L94_95 L129_130 0.0344
K11307 L94_95 L21_22 0.0315
K11308 L94_95 L117_118 0.0274
K11309 L94_95 L51_52 0.0264
K11310 L94_95 L56_57 0.0303
K11311 L94_95 L116_117 0.0245
K11312 L94_95 L173_174 0.0653
K11313 L94_95 L154_155 0.088
K11314 L94_95 L32_33 0.0498
K11315 L94_95 L103_104 0.1144
K11316 L94_95 L85_86 0.0282
K11317 L94_95 L7_8 0.0224
K11318 L94_95 L82_83 0.0533
K11319 L94_95 L14_15 0.0235
K11320 L94_95 L184_185 0.0235
K11321 L94_95 L125_187 0.025
K11322 L94_95 L58_59 0.0253
K11323 L94_95 L70_71 0.0363
K11324 L94_95 L68_69 0.0685
K11325 L94_95 L180_181 0.0222
K11326 L94_95 L89_102 0.1144
K11327 L94_95 L26_27 0.0389
K11328 L94_95 L50_51 0.0237
K11329 L94_95 L83_84 0.0851
K11330 L94_95 L90_91 0.2054
K11331 L94_95 L139_140 0.1226
K11332 L94_95 L111_112 0.0237
K11333 L94_95 L162_163 0.0386
K11334 L94_95 L137_138 0.1536
K11335 L94_95 L179_180 0.0223
K11336 L94_95 L12_13 0.0237
K11337 L94_95 L207_208 0.0281
K11338 L94_95 L123_124 0.0317
K11339 L94_95 L152_153 0.1033
K11340 L94_95 L39_40 0.0667
K11341 L94_95 L18_19 0.0251
K11342 L94_95 L130_156 0.0313
K11343 L94_95 L156_157 0.0314
K11344 L94_95 L189_190 0.0248
K11345 L94_95 L11_12 0.0237
K11346 L94_95 L54_55 0.0245
K11347 L136_141 L181_185 0.0303
K11348 L136_141 L140_145 0.0622
K11349 L136_141 L13_18 0.0326
K11350 L136_141 L35_40 0.0574
K11351 L136_141 L23_28 0.0445
K11352 L136_141 L73_78 0.1064
K11353 L136_141 L184_188 0.0327
K11354 L136_141 L163_168 0.0529
K11355 L136_141 L91_95 0.0958
K11356 L136_141 L144_149 0.0833
K11357 L136_141 L4_9 0.0286
K11358 L136_141 L202_206 0.1086
K11359 L136_141 L109_114 0.0415
K11360 L136_141 L57_61 0.0458
K11361 L136_141 L164_169 0.0474
K11362 L136_141 L195_199 0.039
K11363 L136_141 L158_189 0.0339
K11364 L136_141 L106_111 0.0269
K11365 L136_141 L34_39 0.0651
K11366 L136_141 L148_153 0.0939
K11367 L136_141 L201_205 0.069
K11368 L136_141 L53_57 0.0435
K11369 L136_141 L69_73 0.1053
K11370 L136_141 L200_204 0.0506
K11371 L136_141 L150_155 0.0597
K11372 L136_141 L145_150 0.0615
K11373 L136_141 L30_35 0.047
K11374 L136_141 L101_105 0.0581
K11375 L136_141 L46_50 0.0268
K11376 L136_141 L196_200 0.0507
K11377 L136_141 L92_96 0.0813
K11378 L136_141 L81_86 0.05
K11379 L136_141 L19_24 0.0337
K11380 L136_141 L8_13 0.0307
K11381 L136_141 L60_64 0.0426
K11382 L136_141 L198_202 0.1098
K11383 L136_141 L193_197 0.069
K11384 L136_141 L7_12 0.0313
K11385 L136_141 L137_142 0.1262
K11386 L136_141 L167_172 0.0701
K11387 L136_141 L121_126 0.0295
K11388 L136_141 L97_101 0.0598
K11389 L136_141 L113_118 0.0393
K11390 L136_141 L134_139 0.0833
K11391 L136_141 L100_104 0.0775
K11392 L136_141 L24_29 0.0434
K11393 L136_141 L138_143 0.1011
K11394 L136_141 L33_38 0.069
K11395 L136_141 L18_23 0.0346
K11396 L136_141 L124_129 0.0487
K11397 L136_141 L107_112 0.0336
K11398 L136_141 L78_83 0.1053
K11399 L136_141 L112_117 0.0348
K11400 L136_141 L40_45 0.0705
K11401 L136_141 L183_187 0.0334
K11402 L136_141 L59_63 0.037
K11403 L136_141 L5_10 0.0234
K11404 L136_141 L15_20 0.0259
K11405 L136_141 L51_55 0.0347
K11406 L136_141 L58_62 0.0294
K11407 L136_141 L67_71 0.0503
K11408 L136_141 L29_34 0.0524
K11409 L136_141 L179_183 0.0314
K11410 L136_141 L206_210 0.1051
K11411 L136_141 L205_209 0.0681
K11412 L136_141 L191_195 0.0389
K11413 L136_141 L66_70 0.0387
K11414 L136_141 L98_102 0.1056
K11415 L136_141 L27_32 0.0562
K11416 L136_141 L142_147 0.1224
K11417 L136_141 L147_152 0.1129
K11418 L136_141 L178_182 0.0234
K11419 L136_141 L180_184 0.0309
K11420 L136_141 L3_8 0.0291
K11421 L136_141 L157_162 0.0447
K11422 L136_141 L149_154 0.0802
K11423 L136_141 L203_207 0.0387
K11424 L136_141 L2_7 0.0296
K11425 L136_141 L117_122 0.0359
K11426 L136_141 L22_27 0.0454
K11427 L136_141 L38_43 0.0902
K11428 L136_141 L108_113 0.0377
K11429 L136_141 L135_174 0.0719
K11430 L136_141 L52_56 0.0391
K11431 L136_141 L80_85 0.0385
K11432 L136_141 L10_15 0.0246
K11433 L136_141 L158_163 0.0436
K11434 L136_141 L185_189 0.032
K11435 L136_141 L96_100 0.0803
K11436 L136_141 L49_53 0.0413
K11437 L136_141 L186_190 0.026
K11438 L136_141 L156_161 0.0457
K11439 L136_141 L82_87 0.0673
K11440 L136_141 L159_164 0.0394
K11441 L136_141 L9_14 0.0301
K11442 L136_141 L68_72 0.0681
K11443 L136_141 L169_174 0.0582
K11444 L136_141 L204_208 0.0503
K11445 L136_141 L25_30 0.0392
K11446 L136_141 L32_37 0.0728
K11447 L136_141 L133_172 0.0927
K11448 L136_141 L14_19 0.0319
K11449 L136_141 L44_92 0.0803
K11450 L136_141 L161_166 0.0568
K11451 L136_141 L95_99 0.0941
K11452 L136_141 L116_121 0.0286
K11453 L136_141 L199_203 0.0389
K11454 L136_141 L75_80 0.0387
K11455 L136_141 L143_148 0.0991
K11456 L136_141 L70_75 0.0388
K11457 L136_141 L50_54 0.0276
K11458 L136_141 L56_60 0.0408
K11459 L136_141 L159_190 0.0275
K11460 L136_141 L93_97 0.0604
K11461 L136_141 L90_94 0.1161
K11462 L136_141 L134_173 0.0838
K11463 L136_141 L139_144 0.0844
K11464 L136_141 L83_88 0.1022
K11465 L136_141 L177_181 0.0287
K11466 L136_141 L111_116 0.0277
K11467 L136_141 L162_167 0.0549
K11468 L136_141 L43_91 0.0941
K11469 L136_141 L122_127 0.0371
K11470 L136_141 L135_140 0.0615
K11471 L136_141 L39_44 0.082
K11472 L136_141 L123_128 0.0428
K11473 L136_141 L54_58 0.0285
K11474 L136_141 L61_65 0.0484
K11475 L136_141 L12_17 0.0332
K11476 L136_141 L77_82 0.0681
K11477 L103_104 L167_168 0.0352
K11478 L103_104 L74_90 0.0787
K11479 L103_104 L115_179 0.0167
K11480 L103_104 L196_197 0.0357
K11481 L103_104 L1_2 0.0137
K11482 L103_104 L23_24 0.0235
K11483 L103_104 L158_159 0.0233
K11484 L103_104 L136_198 0.0775
K11485 L103_104 L163_164 0.0285
K11486 L103_104 L144_145 0.0988
K11487 L103_104 L91_92 0.0891
K11488 L103_104 L160_161 0.0283
K11489 L103_104 L126_127 0.0186
K11490 L103_104 L22_23 0.0235
K11491 L103_104 L204_205 0.037
K11492 L103_104 L4_5 0.0138
K11493 L103_104 L34_35 0.0354
K11494 L103_104 L41_42 0.0621
K11495 L103_104 L197_198 0.05
K11496 L103_104 L143_144 0.1033
K11497 L103_104 L200_201 0.0365
K11498 L103_104 L205_206 0.0537
K11499 L103_104 L36_37 0.0456
K11500 L103_104 L131_132 0.06
K11501 L103_104 L100_101 0.1673
K11502 L103_104 L203_204 0.0281
K11503 L103_104 L92_93 0.0861
K11504 L103_104 L81_82 0.0373
K11505 L103_104 L13_14 0.0178
K11506 L103_104 L148_149 0.1363
K11507 L103_104 L19_20 0.0188
K11508 L103_104 L187_188 0.0187
K11509 L103_104 L165_166 0.0348
K11510 L103_104 L128_129 0.0233
K11511 L103_104 L106_107 0.0168
K11512 L103_104 L8_9 0.0169
K11513 L103_104 L170_171 0.0449
K11514 L103_104 L193_194 0.0461
K11515 L103_104 L21_65 0.0254
K11516 L103_104 L121_122 0.0192
K11517 L103_104 L9_10 0.0169
K11518 L103_104 L195_196 0.0276
K11519 L103_104 L134_135 0.0622
K11520 L103_104 L41_69 0.0732
K11521 L103_104 L171_172 0.0456
K11522 L103_104 L180_181 0.0168
K11523 L103_104 L79_94 0.0985
K11524 L103_104 L37_38 0.0463
K11525 L103_104 L112_113 0.0199
K11526 L103_104 L183_184 0.0177
K11527 L103_104 L59_60 0.0215
K11528 L103_104 L11_57 0.0242
K11529 L103_104 L38_39 0.0466
K11530 L103_104 L27_28 0.0286
K11531 L103_104 L78_79 0.0912
K11532 L103_104 L44_45 0.0644
K11533 L103_104 L47_48 0.0185
K11534 L103_104 L29_30 0.0286
K11535 L103_104 L76_77 0.0368
K11536 L103_104 L166_167 0.0351
K11537 L103_104 L185_186 0.0177
K11538 L103_104 L16_17 0.0187
K11539 L103_104 L188_189 0.0187
K11540 L103_104 L181_182 0.0168
K11541 L103_104 L118_119 0.0226
K11542 L103_104 L176_177 0.0138
K11543 L103_104 L3_4 0.0138
K11544 L103_104 L6_53 0.023
K11545 L103_104 L149_150 0.1266
K11546 L103_104 L2_3 0.0138
K11547 L103_104 L98_99 0.1673
K11548 L103_104 L84_98 0.1268
K11549 L103_104 L48_49 0.02
K11550 L103_104 L124_125 0.0254
K11551 L103_104 L113_114 0.0216
K11552 L103_104 L52_53 0.0217
K11553 L103_104 L80_81 0.0283
K11554 L103_104 L141_202 0.0862
K11555 L103_104 L146_147 0.1062
K11556 L103_104 L136_137 0.073
K11557 L103_104 L127_128 0.021
K11558 L103_104 L138_139 0.0811
K11559 L103_104 L42_43 0.0644
K11560 L103_104 L28_29 0.0287
K11561 L103_104 L157_158 0.0234
K11562 L103_104 L122_123 0.0214
K11563 L103_104 L96_97 0.1144
K11564 L103_104 L66_67 0.0258
K11565 L103_104 L129_130 0.0253
K11566 L103_104 L64_65 0.0234
K11567 L103_104 L117_118 0.0207
K11568 L103_104 L51_52 0.02
K11569 L103_104 L56_57 0.0227
K11570 L103_104 L116_117 0.0187
K11571 L103_104 L173_174 0.0456
K11572 L103_104 L32_33 0.0354
K11573 L103_104 L95_96 0.1216
K11574 L103_104 L21_22 0.0233
K11575 L103_104 L7_8 0.0169
K11576 L103_104 L82_83 0.0548
K11577 L103_104 L14_15 0.0178
K11578 L103_104 L184_185 0.0177
K11579 L103_104 L141_142 0.088
K11580 L103_104 L199_200 0.0279
K11581 L103_104 L125_187 0.0186
K11582 L103_104 L58_59 0.0193
K11583 L103_104 L70_71 0.0277
K11584 L103_104 L68_69 0.0469
K11585 L103_104 L26_27 0.0285
K11586 L103_104 L50_51 0.0182
K11587 L103_104 L83_84 0.1016
K11588 L103_104 L90_91 0.0861
K11589 L103_104 L139_140 0.0789
K11590 L103_104 L161_162 0.0285
K11591 L103_104 L111_112 0.0181
K11592 L103_104 L162_163 0.0285
K11593 L103_104 L137_138 0.0789
K11594 L103_104 L179_180 0.0168
K11595 L103_104 L12_13 0.0178
K11596 L103_104 L142_143 0.0988
K11597 L103_104 L123_124 0.0236
K11598 L103_104 L191_192 0.0256
K11599 L103_104 L39_40 0.0463
K11600 L103_104 L18_19 0.0188
K11601 L103_104 L130_156 0.0232
K11602 L103_104 L156_157 0.0233
K11603 L103_104 L189_190 0.0187
K11604 L103_104 L11_12 0.0177
K11605 L103_104 L54_55 0.0187
K11606 L103_104 L201_202 0.0521
K11607 L156_161 L24_29 0.1838
K11608 L156_161 L181_185 0.1437
K11609 L156_161 L140_145 0.0342
K11610 L156_161 L1_6 0.0992
K11611 L156_161 L13_18 0.1795
K11612 L156_161 L35_40 0.0853
K11613 L156_161 L23_28 0.2341
K11614 L156_161 L73_78 0.0456
K11615 L156_161 L184_188 0.2276
K11616 L156_161 L6_11 0.1107
K11617 L156_161 L163_168 0.159
K11618 L156_161 L91_95 0.0422
K11619 L156_161 L144_149 0.0389
K11620 L156_161 L130_160 0.3972
K11621 L156_161 L4_9 0.1139
K11622 L156_161 L202_206 0.0436
K11623 L156_161 L109_114 0.0746
K11624 L156_161 L57_61 0.0798
K11625 L156_161 L164_169 0.1278
K11626 L156_161 L195_199 0.0275
K11627 L156_161 L106_111 0.0336
K11628 L156_161 L34_39 0.0976
K11629 L156_161 L148_153 0.0366
K11630 L156_161 L201_205 0.0384
K11631 L156_161 L53_57 0.0769
K11632 L156_161 L69_73 0.048
K11633 L156_161 L200_204 0.0336
K11634 L156_161 L150_155 0.0296
K11635 L156_161 L145_150 0.0317
K11636 L156_161 L30_35 0.1202
K11637 L156_161 L131_136 0.0489
K11638 L156_161 L101_105 0.0294
K11639 L156_161 L46_50 0.0334
K11640 L156_161 L196_200 0.0346
K11641 L156_161 L92_96 0.0415
K11642 L156_161 L81_86 0.0326
K11643 L156_161 L19_24 0.1465
K11644 L156_161 L120_125 0.1298
K11645 L156_161 L8_13 0.1572
K11646 L156_161 L60_64 0.0578
K11647 L156_161 L198_202 0.0458
K11648 L156_161 L193_197 0.0415
K11649 L156_161 L167_172 0.1081
K11650 L156_161 L121_126 0.0346
K11651 L156_161 L97_101 0.0315
K11652 L156_161 L110_115 0.1027
K11653 L156_161 L113_118 0.0563
K11654 L156_161 L141_146 0.0429
K11655 L156_161 L100_104 0.0359
K11656 L156_161 L9_14 0.1293
K11657 L156_161 L138_143 0.0427
K11658 L156_161 L33_38 0.1038
K11659 L156_161 L18_23 0.1886
K11660 L156_161 L134_139 0.0455
K11661 L156_161 L124_129 0.0836
K11662 L156_161 L107_112 0.0431
K11663 L156_161 L78_83 0.0434
K11664 L156_161 L112_117 0.0438
K11665 L156_161 L40_45 0.0625
K11666 L156_161 L59_63 0.0444
K11667 L156_161 L5_10 0.0842
K11668 L156_161 L15_20 0.0996
K11669 L156_161 L51_55 0.0436
K11670 L156_161 L58_62 0.0345
K11671 L156_161 L67_71 0.0355
K11672 L156_161 L29_34 0.1463
K11673 L156_161 L206_210 0.0415
K11674 L156_161 L41_74 0.0486
K11675 L156_161 L131_170 0.0685
K11676 L156_161 L205_209 0.037
K11677 L156_161 L191_195 0.0282
K11678 L156_161 L178_182 0.0895
K11679 L156_161 L180_184 0.1879
K11680 L156_161 L3_8 0.1319
K11681 L156_161 L157_162 0.2991
K11682 L156_161 L149_154 0.0362
K11683 L156_161 L203_207 0.026
K11684 L156_161 L66_70 0.0282
K11685 L156_161 L117_122 0.0443
K11686 L156_161 L158_189 0.1676
K11687 L156_161 L38_43 0.0717
K11688 L156_161 L135_174 0.0635
K11689 L156_161 L160_165 0.2112
K11690 L156_161 L52_56 0.0559
K11691 L156_161 L115_120 0.1156
K11692 L156_161 L80_85 0.026
K11693 L156_161 L10_15 0.093
K11694 L156_161 L16_21 0.1345
K11695 L156_161 L158_163 0.2092
K11696 L156_161 L185_189 0.1608
K11697 L156_161 L96_100 0.0385
K11698 L156_161 L49_53 0.0736
K11699 L156_161 L186_190 0.1085
K11700 L156_161 L82_87 0.0369
K11701 L156_161 L125_130 0.1438
K11702 L156_161 L108_113 0.055
K11703 L156_161 L159_164 0.1566
K11704 L156_161 L84_89 0.0402
K11705 L156_161 L68_72 0.0413
K11706 L156_161 L169_174 0.0879
K11707 L156_161 L204_208 0.0327
K11708 L156_161 L25_30 0.1436
K11709 L156_161 L133_172 0.073
K11710 L156_161 L14_19 0.1417
K11711 L156_161 L44_92 0.045
K11712 L156_161 L21_26 0.2588
K11713 L156_161 L95_99 0.0391
K11714 L156_161 L116_121 0.0343
K11715 L156_161 L74_79 0.0454
K11716 L156_161 L165_170 0.1037
K11717 L156_161 L199_203 0.0268
K11718 L156_161 L75_80 0.0267
K11719 L156_161 L143_148 0.0394
K11720 L156_161 L70_75 0.0274
K11721 L156_161 L50_54 0.0339
K11722 L156_161 L79_84 0.0426
K11723 L156_161 L56_60 0.057
K11724 L156_161 L159_190 0.1117
K11725 L156_161 L93_97 0.0339
K11726 L156_161 L134_173 0.0708
K11727 L156_161 L139_144 0.0419
K11728 L156_161 L83_88 0.0414
K11729 L156_161 L177_181 0.1233
K11730 L156_161 L111_116 0.034
K11731 L156_161 L162_167 0.1944
K11732 L156_161 L43_91 0.0459
K11733 L156_161 L122_127 0.0447
K11734 L156_161 L135_140 0.037
K11735 L156_161 L39_44 0.0696
K11736 L156_161 L123_128 0.0583
K11737 L156_161 L54_58 0.0342
K11738 L156_161 L146_151 0.0404
K11739 L156_161 L61_65 0.0821
K11740 L156_161 L11_16 0.123
K11741 L156_161 L77_82 0.0383
K11742 L66_67 L167_168 0.0329
K11743 L66_67 L74_90 0.0363
K11744 L66_67 L199_200 0.2334
K11745 L66_67 L115_179 0.022
K11746 L66_67 L128_129 0.0446
K11747 L66_67 L196_197 0.1765
K11748 L66_67 L1_2 0.0181
K11749 L66_67 L23_24 0.0268
K11750 L66_67 L158_159 0.0258
K11751 L66_67 L136_198 0.0615
K11752 L66_67 L163_164 0.0297
K11753 L66_67 L144_145 0.0298
K11754 L66_67 L91_92 0.0319
K11755 L66_67 L160_161 0.0332
K11756 L66_67 L126_127 0.052
K11757 L66_67 L22_23 0.0277
K11758 L66_67 L153_154 0.0256
K11759 L66_67 L4_5 0.0166
K11760 L66_67 L34_35 0.0316
K11761 L66_67 L197_198 0.0923
K11762 L66_67 L204_205 0.1387
K11763 L66_67 L143_144 0.0315
K11764 L66_67 L200_201 0.1576
K11765 L66_67 L205_206 0.0858
K11766 L66_67 L36_37 0.0383
K11767 L66_67 L141_142 0.0358
K11768 L66_67 L100_101 0.0296
K11769 L66_67 L203_204 0.1866
K11770 L66_67 L92_93 0.0301
K11771 L66_67 L81_82 0.1475
K11772 L66_67 L13_14 0.0213
K11773 L66_67 L185_186 0.0205
K11774 L66_67 L148_149 0.0312
K11775 L66_67 L19_20 0.0211
K11776 L66_67 L187_188 0.0225
K11777 L66_67 L165_166 0.0358
K11778 L66_67 L102_103 0.0273
K11779 L66_67 L106_107 0.0412
K11780 L66_67 L64_65 0.0449
K11781 L66_67 L8_9 0.0207
K11782 L66_67 L170_171 0.0382
K11783 L66_67 L21_65 0.0388
K11784 L66_67 L121_122 0.051
K11785 L66_67 L9_10 0.0201
K11786 L66_67 L195_196 0.2931
K11787 L66_67 L171_172 0.0363
K11788 L66_67 L104_105 0.0244
K11789 L66_67 L151_210 0.0545
K11790 L66_67 L79_94 0.036
K11791 L66_67 L37_38 0.0365
K11792 L66_67 L112_113 0.0436
K11793 L66_67 L183_184 0.0219
K11794 L66_67 L59_60 0.0495
K11795 L66_67 L11_57 0.0379
K11796 L66_67 L38_39 0.0348
K11797 L66_67 L27_28 0.0321
K11798 L66_67 L96_97 0.0299
K11799 L66_67 L78_79 0.0613
K11800 L66_67 L138_139 0.0318
K11801 L66_67 L47_48 0.0403
K11802 L66_67 L29_30 0.0298
K11803 L66_67 L76_77 0.1727
K11804 L66_67 L166_167 0.0343
K11805 L66_67 L16_17 0.0233
K11806 L66_67 L188_189 0.0217
K11807 L66_67 L118_119 0.0425
K11808 L66_67 L176_177 0.017
K11809 L66_67 L3_4 0.0171
K11810 L66_67 L6_53 0.0364
K11811 L66_67 L149_150 0.0295
K11812 L66_67 L2_3 0.0176
K11813 L66_67 L98_99 0.0334
K11814 L66_67 L184_185 0.0212
K11815 L66_67 L84_98 0.0356
K11816 L66_67 L48_49 0.0373
K11817 L66_67 L124_125 0.0394
K11818 L66_67 L113_114 0.0404
K11819 L66_67 L52_53 0.0406
K11820 L66_67 L80_81 0.2072
K11821 L66_67 L141_202 0.0607
K11822 L66_67 L87_88 0.0785
K11823 L66_67 L146_147 0.0353
K11824 L66_67 L127_128 0.0498
K11825 L66_67 L181_182 0.0201
K11826 L66_67 L28_29 0.0309
K11827 L66_67 L157_158 0.0267
K11828 L66_67 L122_123 0.0492
K11829 L66_67 L129_130 0.0387
K11830 L66_67 L21_22 0.0287
K11831 L66_67 L117_118 0.0462
K11832 L66_67 L51_52 0.0438
K11833 L66_67 L56_57 0.0427
K11834 L66_67 L116_117 0.0477
K11835 L66_67 L173_174 0.0331
K11836 L66_67 L154_155 0.0242
K11837 L66_67 L32_33 0.0344
K11838 L66_67 L95_96 0.0317
K11839 L66_67 L85_86 0.1605
K11840 L66_67 L7_8 0.0214
K11841 L66_67 L82_83 0.0877
K11842 L66_67 L14_15 0.0206
K11843 L66_67 L125_187 0.0232
K11844 L66_67 L58_59 0.0513
K11845 L66_67 L70_71 0.4331
K11846 L66_67 L136_137 0.0361
K11847 L66_67 L180_181 0.0207
K11848 L66_67 L89_102 0.0291
K11849 L66_67 L26_27 0.0333
K11850 L66_67 L50_51 0.0451
K11851 L66_67 L83_84 0.0601
K11852 L66_67 L90_91 0.034
K11853 L66_67 L139_140 0.0299
K11854 L66_67 L161_162 0.032
K11855 L66_67 L111_112 0.0448
K11856 L66_67 L162_163 0.0308
K11857 L66_67 L137_138 0.0338
K11858 L66_67 L179_180 0.0213
K11859 L66_67 L12_13 0.0219
K11860 L66_67 L207_208 0.1492
K11861 L66_67 L142_143 0.0335
K11862 L66_67 L123_124 0.0447
K11863 L66_67 L152_153 0.0272
K11864 L66_67 L39_40 0.0332
K11865 L66_67 L18_19 0.0218
K11866 L66_67 L130_156 0.0286
K11867 L66_67 L156_157 0.0276
K11868 L66_67 L189_190 0.021
K11869 L66_67 L11_12 0.0227
K11870 L66_67 L54_55 0.048
K11871 L66_67 L201_202 0.0896
K11872 L24_29 L140_145 0.0351
K11873 L24_29 L1_6 0.0838
K11874 L24_29 L13_18 0.1482
K11875 L24_29 L35_40 0.1013
K11876 L24_29 L23_28 0.2991
K11877 L24_29 L73_78 0.0429
K11878 L24_29 L184_188 0.1319
K11879 L24_29 L6_11 0.0904
K11880 L24_29 L91_95 0.0366
K11881 L24_29 L130_160 0.1599
K11882 L24_29 L22_27 0.2092
K11883 L24_29 L202_206 0.0408
K11884 L24_29 L109_114 0.0628
K11885 L24_29 L57_61 0.0673
K11886 L24_29 L164_169 0.1634
K11887 L24_29 L195_199 0.0256
K11888 L24_29 L106_111 0.0303
K11889 L24_29 L148_153 0.0319
K11890 L24_29 L201_205 0.0359
K11891 L24_29 L53_57 0.0655
K11892 L24_29 L69_73 0.0448
K11893 L24_29 L200_204 0.0314
K11894 L24_29 L150_155 0.0302
K11895 L24_29 L145_150 0.0325
K11896 L24_29 L30_35 0.189
K11897 L24_29 L131_136 0.0461
K11898 L24_29 L101_105 0.0304
K11899 L24_29 L46_50 0.0304
K11900 L24_29 L196_200 0.0322
K11901 L24_29 L81_86 0.0307
K11902 L24_29 L120_125 0.0939
K11903 L24_29 L8_13 0.1187
K11904 L24_29 L60_64 0.0506
K11905 L24_29 L198_202 0.0427
K11906 L24_29 L193_197 0.0383
K11907 L24_29 L7_12 0.1049
K11908 L24_29 L137_142 0.0359
K11909 L24_29 L167_172 0.1038
K11910 L24_29 L121_126 0.0311
K11911 L24_29 L97_101 0.0328
K11912 L24_29 L110_115 0.082
K11913 L24_29 L141_146 0.0409
K11914 L24_29 L122_127 0.0398
K11915 L24_29 L138_143 0.0364
K11916 L24_29 L33_38 0.1081
K11917 L24_29 L18_23 0.1879
K11918 L24_29 L124_129 0.0679
K11919 L24_29 L107_112 0.0387
K11920 L24_29 L78_83 0.041
K11921 L24_29 L112_117 0.0392
K11922 L24_29 L40_45 0.0678
K11923 L24_29 L183_187 0.1139
K11924 L24_29 L59_63 0.04
K11925 L24_29 L5_10 0.1284
K11926 L24_29 L15_20 0.2077
K11927 L24_29 L51_55 0.0393
K11928 L24_29 L58_62 0.0312
K11929 L24_29 L67_71 0.0331
K11930 L24_29 L179_183 0.0989
K11931 L24_29 L206_210 0.0391
K11932 L24_29 L41_74 0.0464
K11933 L24_29 L131_170 0.0637
K11934 L24_29 L205_209 0.0347
K11935 L24_29 L191_195 0.0262
K11936 L24_29 L2_7 0.0898
K11937 L24_29 L98_102 0.0318
K11938 L24_29 L27_32 0.159
K11939 L24_29 L147_152 0.0316
K11940 L24_29 L178_182 0.1131
K11941 L24_29 L180_184 0.1101
K11942 L24_29 L3_8 0.098
K11943 L24_29 L157_162 0.2341
K11944 L24_29 L203_207 0.0244
K11945 L24_29 L66_70 0.0263
K11946 L24_29 L117_122 0.0396
K11947 L24_29 L38_43 0.073
K11948 L24_29 L135_174 0.0666
K11949 L24_29 L160_165 0.1298
K11950 L24_29 L52_56 0.0493
K11951 L24_29 L115_120 0.0881
K11952 L24_29 L80_85 0.0245
K11953 L24_29 L10_15 0.1671
K11954 L24_29 L16_21 0.1022
K11955 L24_29 L113_118 0.049
K11956 L24_29 L49_53 0.0634
K11957 L24_29 L186_190 0.1578
K11958 L24_29 L125_130 0.0989
K11959 L24_29 L108_113 0.0481
K11960 L24_29 L159_164 0.2296
K11961 L24_29 L84_89 0.0389
K11962 L24_29 L68_72 0.0384
K11963 L24_29 L169_174 0.0972
K11964 L24_29 L204_208 0.0306
K11965 L24_29 L25_30 0.305
K11966 L24_29 L32_37 0.101
K11967 L24_29 L133_172 0.0717
K11968 L24_29 L82_87 0.0348
K11969 L24_29 L161_166 0.1463
K11970 L24_29 L21_26 0.1786
K11971 L24_29 L95_99 0.0342
K11972 L24_29 L116_121 0.0309
K11973 L24_29 L74_79 0.0436
K11974 L24_29 L165_170 0.0885
K11975 L24_29 L199_203 0.025
K11976 L24_29 L75_80 0.0251
K11977 L24_29 L143_148 0.034
K11978 L24_29 L70_75 0.0257
K11979 L24_29 L50_54 0.0307
K11980 L24_29 L79_84 0.0411
K11981 L24_29 L56_60 0.05
K11982 L24_29 L159_190 0.1665
K11983 L24_29 L93_97 0.0355
K11984 L24_29 L90_94 0.0362
K11985 L24_29 L83_88 0.0393
K11986 L24_29 L111_116 0.0306
K11987 L24_29 L162_167 0.1706
K11988 L24_29 L43_91 0.0394
K11989 L24_29 L142_147 0.0337
K11990 L24_29 L135_140 0.0382
K11991 L24_29 L123_128 0.0503
K11992 L24_29 L12_17 0.1233
K11993 L24_29 L54_58 0.031
K11994 L24_29 L146_151 0.0387
K11995 L24_29 L61_65 0.0687
K11996 L24_29 L11_16 0.0968
K11997 L24_29 L77_82 0.036
K11998 L79_94 L167_168 0.0484
K11999 L79_94 L74_90 0.2054
K12000 L79_94 L115_179 0.0223
K12001 L79_94 L128_129 0.0324
K12002 L79_94 L196_197 0.0527
K12003 L79_94 L1_2 0.0183
K12004 L79_94 L23_24 0.0313
K12005 L79_94 L158_159 0.0308
K12006 L79_94 L136_198 0.1583
K12007 L79_94 L163_164 0.0379
K12008 L79_94 L91_92 0.1439
K12009 L79_94 L160_161 0.0387
K12010 L79_94 L126_127 0.0253
K12011 L79_94 L22_23 0.0315
K12012 L79_94 L204_205 0.0413
K12013 L79_94 L153_154 0.088
K12014 L79_94 L4_5 0.018
K12015 L79_94 L34_35 0.048
K12016 L79_94 L41_42 0.1104
K12017 L79_94 L197_198 0.0822
K12018 L79_94 L191_192 0.0358
K12019 L79_94 L205_206 0.0579
K12020 L79_94 L36_37 0.0688
K12021 L79_94 L131_132 0.1029
K12022 L79_94 L100_101 0.1124
K12023 L79_94 L203_204 0.032
K12024 L79_94 L92_93 0.1124
K12025 L79_94 L81_82 0.0416
K12026 L79_94 L13_14 0.0235
K12027 L79_94 L148_149 0.1226
K12028 L79_94 L19_20 0.0247
K12029 L79_94 L187_188 0.025
K12030 L79_94 L165_166 0.0492
K12031 L79_94 L102_103 0.1144
K12032 L79_94 L106_107 0.0225
K12033 L79_94 L64_65 0.0326
K12034 L79_94 L8_9 0.0222
K12035 L79_94 L170_171 0.0673
K12036 L79_94 L193_194 0.0758
K12037 L79_94 L21_65 0.035
K12038 L79_94 L121_122 0.026
K12039 L79_94 L9_10 0.0221
K12040 L79_94 L195_196 0.0385
K12041 L79_94 L134_135 0.0868
K12042 L79_94 L41_69 0.1616
K12043 L79_94 L171_172 0.0668
K12044 L79_94 L104_105 0.0823
K12045 L79_94 L151_210 0.0842
K12046 L79_94 L138_139 0.1226
K12047 L79_94 L37_38 0.0683
K12048 L79_94 L98_99 0.1832
K12049 L79_94 L112_113 0.027
K12050 L79_94 L183_184 0.0235
K12051 L79_94 L59_60 0.0295
K12052 L79_94 L11_57 0.0328
K12053 L79_94 L38_39 0.0667
K12054 L79_94 L27_28 0.0389
K12055 L79_94 L44_45 0.091
K12056 L79_94 L47_48 0.025
K12057 L79_94 L29_30 0.0381
K12058 L79_94 L166_167 0.049
K12059 L79_94 L185_186 0.0232
K12060 L79_94 L16_17 0.0252
K12061 L79_94 L188_189 0.0248
K12062 L79_94 L118_119 0.0308
K12063 L79_94 L176_177 0.0181
K12064 L79_94 L3_4 0.0182
K12065 L79_94 L6_53 0.031
K12066 L79_94 L149_150 0.1015
K12067 L79_94 L2_3 0.0183
K12068 L79_94 L84_98 0.2054
K12069 L79_94 L48_49 0.0271
K12070 L79_94 L124_125 0.0346
K12071 L79_94 L113_114 0.0293
K12072 L79_94 L52_53 0.0294
K12073 L79_94 L80_81 0.0321
K12074 L79_94 L87_88 0.0538
K12075 L79_94 L146_147 0.1536
K12076 L79_94 L136_137 0.1536
K12077 L79_94 L127_128 0.0289
K12078 L79_94 L42_43 0.1076
K12079 L79_94 L181_182 0.022
K12080 L79_94 L28_29 0.0386
K12081 L79_94 L157_158 0.0311
K12082 L79_94 L122_123 0.0293
K12083 L79_94 L161_162 0.0386
K12084 L79_94 L129_130 0.0348
K12085 L79_94 L21_22 0.0316
K12086 L79_94 L117_118 0.0281
K12087 L79_94 L51_52 0.027
K12088 L79_94 L56_57 0.0309
K12089 L79_94 L116_117 0.0252
K12090 L79_94 L173_174 0.063
K12091 L79_94 L154_155 0.0759
K12092 L79_94 L32_33 0.0496
K12093 L79_94 L85_86 0.0298
K12094 L79_94 L7_8 0.0223
K12095 L79_94 L82_83 0.0589
K12096 L79_94 L14_15 0.0233
K12097 L79_94 L184_185 0.0234
K12098 L79_94 L125_187 0.025
K12099 L79_94 L58_59 0.0261
K12100 L79_94 L70_71 0.0387
K12101 L79_94 L68_69 0.0783
K12102 L79_94 L180_181 0.0221
K12103 L79_94 L89_102 0.1216
K12104 L79_94 L26_27 0.039
K12105 L79_94 L50_51 0.0244
K12106 L79_94 L83_84 0.0996
K12107 L79_94 L90_91 0.1832
K12108 L79_94 L139_140 0.1015
K12109 L79_94 L111_112 0.0243
K12110 L79_94 L162_163 0.0383
K12111 L79_94 L137_138 0.1438
K12112 L79_94 L179_180 0.0222
K12113 L79_94 L12_13 0.0237
K12114 L79_94 L207_208 0.0297
K12115 L79_94 L123_124 0.0325
K12116 L79_94 L152_153 0.0988
K12117 L79_94 L39_40 0.0642
K12118 L79_94 L18_19 0.025
K12119 L79_94 L130_156 0.0314
K12120 L79_94 L156_157 0.0313
K12121 L79_94 L189_190 0.0246
K12122 L79_94 L11_12 0.0237
K12123 L79_94 L54_55 0.0252
K12124 L68_72 L181_185 0.0279
K12125 L68_72 L140_145 0.0312
K12126 L68_72 L1_6 0.0393
K12127 L68_72 L13_18 0.03
K12128 L68_72 L35_40 0.0409
K12129 L68_72 L23_28 0.0399
K12130 L68_72 L73_78 0.1134
K12131 L68_72 L6_11 0.041
K12132 L68_72 L163_168 0.0422
K12133 L68_72 L91_95 0.0426
K12134 L68_72 L144_149 0.0392
K12135 L68_72 L130_160 0.0393
K12136 L68_72 L4_9 0.0271
K12137 L68_72 L202_206 0.1076
K12138 L68_72 L109_114 0.0487
K12139 L68_72 L57_61 0.0543
K12140 L68_72 L164_169 0.0376
K12141 L68_72 L195_199 0.0797
K12142 L68_72 L106_111 0.0391
K12143 L68_72 L34_39 0.0462
K12144 L68_72 L148_153 0.0415
K12145 L68_72 L204_208 0.1034
K12146 L68_72 L53_57 0.0515
K12147 L68_72 L69_73 0.1145
K12148 L68_72 L200_204 0.1076
K12149 L68_72 L150_155 0.0307
K12150 L68_72 L145_150 0.031
K12151 L68_72 L30_35 0.0378
K12152 L68_72 L131_136 0.0684
K12153 L68_72 L101_105 0.0308
K12154 L68_72 L46_50 0.0393
K12155 L68_72 L196_200 0.1104
K12156 L68_72 L92_96 0.0398
K12157 L68_72 L81_86 0.1057
K12158 L68_72 L19_24 0.03
K12159 L68_72 L120_125 0.0426
K12160 L68_72 L8_13 0.029
K12161 L68_72 L198_202 0.1104
K12162 L68_72 L7_12 0.03
K12163 L68_72 L137_142 0.0455
K12164 L68_72 L167_172 0.0486
K12165 L68_72 L121_126 0.0454
K12166 L68_72 L97_101 0.0312
K12167 L68_72 L110_115 0.0391
K12168 L68_72 L134_139 0.0396
K12169 L68_72 L141_146 0.0673
K12170 L68_72 L100_104 0.0391
K12171 L68_72 L9_14 0.028
K12172 L68_72 L138_143 0.0423
K12173 L68_72 L33_38 0.0488
K12174 L68_72 L18_23 0.0311
K12175 L68_72 L124_129 0.057
K12176 L68_72 L107_112 0.0487
K12177 L68_72 L78_83 0.1103
K12178 L68_72 L112_117 0.0513
K12179 L68_72 L40_45 0.0434
K12180 L68_72 L183_187 0.031
K12181 L68_72 L59_63 0.0574
K12182 L68_72 L5_10 0.0219
K12183 L68_72 L15_20 0.0234
K12184 L68_72 L51_55 0.0515
K12185 L68_72 L58_62 0.0456
K12186 L68_72 L67_71 0.1145
K12187 L68_72 L29_34 0.0424
K12188 L68_72 L179_183 0.0298
K12189 L68_72 L158_189 0.0299
K12190 L68_72 L206_210 0.1034
K12191 L68_72 L41_74 0.0692
K12192 L68_72 L131_170 0.0544
K12193 L68_72 L191_195 0.0802
K12194 L68_72 L66_70 0.0818
K12195 L68_72 L98_102 0.0448
K12196 L68_72 L27_32 0.0466
K12197 L68_72 L142_147 0.0451
K12198 L68_72 L147_152 0.0445
K12199 L68_72 L178_182 0.0219
K12200 L68_72 L180_184 0.0289
K12201 L68_72 L3_8 0.028
K12202 L68_72 L157_162 0.0398
K12203 L68_72 L149_154 0.0388
K12204 L68_72 L203_207 0.0759
K12205 L68_72 L2_7 0.0288
K12206 L68_72 L117_122 0.054
K12207 L68_72 L22_27 0.0415
K12208 L68_72 L38_43 0.0526
K12209 L68_72 L135_174 0.0432
K12210 L68_72 L160_165 0.0443
K12211 L68_72 L115_120 0.0408
K12212 L68_72 L80_85 0.0772
K12213 L68_72 L10_15 0.0227
K12214 L68_72 L16_21 0.0447
K12215 L68_72 L158_163 0.0383
K12216 L68_72 L185_189 0.0289
K12217 L68_72 L96_100 0.0395
K12218 L68_72 L49_53 0.0489
K12219 L68_72 L186_190 0.0233
K12220 L68_72 L125_130 0.0445
K12221 L68_72 L184_188 0.0299
K12222 L68_72 L159_164 0.0344
K12223 L68_72 L169_174 0.0407
K12224 L68_72 L25_30 0.0345
K12225 L68_72 L32_37 0.0518
K12226 L68_72 L133_172 0.0522
K12227 L68_72 L14_19 0.029
K12228 L68_72 L44_92 0.0398
K12229 L68_72 L161_166 0.0463
K12230 L68_72 L21_26 0.0395
K12231 L68_72 L95_99 0.0423
K12232 L68_72 L84_89 0.0668
K12233 L68_72 L116_121 0.0431
K12234 L68_72 L74_79 0.069
K12235 L68_72 L165_170 0.0497
K12236 L68_72 L199_203 0.0782
K12237 L68_72 L75_80 0.0796
K12238 L68_72 L143_148 0.042
K12239 L68_72 L70_75 0.0812
K12240 L68_72 L50_54 0.0412
K12241 L68_72 L79_84 0.0681
K12242 L68_72 L159_190 0.0241
K12243 L68_72 L93_97 0.0313
K12244 L68_72 L90_94 0.0459
K12245 L68_72 L134_173 0.049
K12246 L68_72 L139_144 0.0395
K12247 L68_72 L83_88 0.1057
K12248 L68_72 L177_181 0.027
K12249 L68_72 L111_116 0.041
K12250 L68_72 L162_167 0.0442
K12251 L68_72 L43_91 0.0427
K12252 L68_72 L122_127 0.057
K12253 L68_72 L135_140 0.0312
K12254 L68_72 L39_44 0.0493
K12255 L68_72 L12_17 0.0311
K12256 L68_72 L54_58 0.0433
K12257 L68_72 L146_151 0.066
K12258 L68_72 L61_65 0.0574
K12259 L68_72 L11_16 0.0428
K12260 L169_174 L181_185 0.0473
K12261 L169_174 L1_6 0.047
K12262 L169_174 L13_18 0.0502
K12263 L169_174 L23_28 0.0917
K12264 L169_174 L73_78 0.0493
K12265 L169_174 L184_188 0.0511
K12266 L169_174 L6_11 0.0501
K12267 L169_174 L163_168 0.189
K12268 L169_174 L91_95 0.0557
K12269 L169_174 L144_149 0.0525
K12270 L169_174 L130_160 0.0795
K12271 L169_174 L4_9 0.0426
K12272 L169_174 L109_114 0.0438
K12273 L169_174 L57_61 0.0474
K12274 L169_174 L195_199 0.026
K12275 L169_174 L106_111 0.0246
K12276 L169_174 L34_39 0.2296
K12277 L169_174 L148_153 0.0463
K12278 L169_174 L201_205 0.0389
K12279 L169_174 L53_57 0.0454
K12280 L169_174 L69_73 0.0512
K12281 L169_174 L200_204 0.0325
K12282 L169_174 L131_136 0.0625
K12283 L169_174 L100_104 0.0466
K12284 L169_174 L46_50 0.0246
K12285 L169_174 L196_200 0.0331
K12286 L169_174 L92_96 0.0576
K12287 L169_174 L81_86 0.0317
K12288 L169_174 L19_24 0.0576
K12289 L169_174 L120_125 0.0542
K12290 L169_174 L8_13 0.0457
K12291 L169_174 L60_64 0.0397
K12292 L169_174 L198_202 0.0497
K12293 L169_174 L193_197 0.0409
K12294 L169_174 L7_12 0.0443
K12295 L169_174 L137_142 0.0544
K12296 L169_174 L143_148 0.0511
K12297 L169_174 L167_172 0.2076
K12298 L169_174 L121_126 0.026
K12299 L169_174 L110_115 0.0474
K12300 L169_174 L113_118 0.0378
K12301 L169_174 L134_139 0.067
K12302 L169_174 L141_146 0.0542
K12303 L169_174 L9_14 0.0466
K12304 L169_174 L138_143 0.0569
K12305 L169_174 L33_38 0.1794
K12306 L169_174 L18_23 0.0557
K12307 L169_174 L124_129 0.0497
K12308 L169_174 L107_112 0.0312
K12309 L169_174 L78_83 0.0474
K12310 L169_174 L112_117 0.0318
K12311 L169_174 L183_187 0.0492
K12312 L169_174 L59_63 0.033
K12313 L169_174 L51_55 0.0317
K12314 L169_174 L58_62 0.026
K12315 L169_174 L67_71 0.0335
K12316 L169_174 L29_34 0.1634
K12317 L169_174 L179_183 0.0449
K12318 L169_174 L206_210 0.0457
K12319 L169_174 L41_74 0.0616
K12320 L169_174 L131_170 0.1129
K12321 L169_174 L205_209 0.0378
K12322 L169_174 L191_195 0.0264
K12323 L169_174 L66_70 0.0263
K12324 L169_174 L98_102 0.0443
K12325 L169_174 L27_32 0.1202
K12326 L169_174 L142_147 0.0492
K12327 L169_174 L147_152 0.0449
K12328 L169_174 L180_184 0.0463
K12329 L169_174 L3_8 0.0418
K12330 L169_174 L157_162 0.095
K12331 L169_174 L149_154 0.0473
K12332 L169_174 L203_207 0.0251
K12333 L169_174 L2_7 0.0408
K12334 L169_174 L117_122 0.0325
K12335 L169_174 L22_27 0.0853
K12336 L169_174 L158_189 0.0589
K12337 L169_174 L38_43 0.1403
K12338 L169_174 L108_113 0.0367
K12339 L169_174 L160_165 0.1129
K12340 L169_174 L52_56 0.0376
K12341 L169_174 L115_120 0.0506
K12342 L169_174 L80_85 0.0251
K12343 L169_174 L16_21 0.0574
K12344 L169_174 L158_163 0.1013
K12345 L169_174 L185_189 0.0525
K12346 L169_174 L96_100 0.0516
K12347 L169_174 L49_53 0.0436
K12348 L169_174 L82_87 0.0376
K12349 L169_174 L125_130 0.0582
K12350 L169_174 L84_89 0.0501
K12351 L169_174 L204_208 0.0318
K12352 L169_174 L202_206 0.0477
K12353 L169_174 L32_37 0.1436
K12354 L169_174 L133_172 0.1538
K12355 L169_174 L14_19 0.0516
K12356 L169_174 L44_92 0.0651
K12357 L169_174 L161_166 0.1278
K12358 L169_174 L21_26 0.0772
K12359 L169_174 L95_99 0.0502
K12360 L169_174 L116_121 0.0256
K12361 L169_174 L74_79 0.0574
K12362 L169_174 L165_170 0.1357
K12363 L169_174 L199_203 0.0256
K12364 L169_174 L75_80 0.0255
K12365 L169_174 L70_75 0.026
K12366 L169_174 L50_54 0.0251
K12367 L169_174 L79_84 0.0536
K12368 L169_174 L56_60 0.0387
K12369 L169_174 L90_94 0.0534
K12370 L169_174 L134_173 0.189
K12371 L169_174 L139_144 0.0589
K12372 L169_174 L83_88 0.0454
K12373 L169_174 L177_181 0.0431
K12374 L169_174 L111_116 0.0251
K12375 L169_174 L162_167 0.1538
K12376 L169_174 L43_91 0.0625
K12377 L169_174 L122_127 0.0331
K12378 L169_174 L39_44 0.1634
K12379 L169_174 L123_128 0.0399
K12380 L169_174 L12_17 0.0485
K12381 L169_174 L54_58 0.0255
K12382 L169_174 L146_151 0.0506
K12383 L169_174 L61_65 0.0493
K12384 L169_174 L11_16 0.0536
K12385 L169_174 L77_82 0.0387
K12386 L188_189 L167_168 0.0688
K12387 L188_189 L74_90 0.0265
K12388 L188_189 L199_200 0.0224
K12389 L188_189 L115_179 0.1124
K12390 L188_189 L128_129 0.0456
K12391 L188_189 L196_197 0.0262
K12392 L188_189 L95_96 0.025
K12393 L188_189 L1_2 0.0801
K12394 L188_189 L23_24 0.1644
K12395 L188_189 L158_159 0.1891
K12396 L188_189 L136_198 0.0336
K12397 L188_189 L163_164 0.1098
K12398 L188_189 L144_145 0.0251
K12399 L188_189 L91_92 0.0267
K12400 L188_189 L160_161 0.1032
K12401 L188_189 L126_127 0.0269
K12402 L188_189 L22_23 0.1556
K12403 L188_189 L204_205 0.0245
K12404 L188_189 L153_154 0.0188
K12405 L188_189 L4_5 0.0879
K12406 L188_189 L34_35 0.0668
K12407 L188_189 L41_42 0.0356
K12408 L188_189 L197_198 0.0298
K12409 L188_189 L143_144 0.0252
K12410 L188_189 L200_201 0.0253
K12411 L188_189 L205_206 0.0275
K12412 L188_189 L36_37 0.0484
K12413 L188_189 L131_132 0.0359
K12414 L188_189 L100_101 0.0235
K12415 L188_189 L203_204 0.0218
K12416 L188_189 L92_93 0.0266
K12417 L188_189 L81_82 0.0245
K12418 L188_189 L13_14 0.1536
K12419 L188_189 L148_149 0.0237
K12420 L188_189 L165_166 0.0667
K12421 L188_189 L102_103 0.0187
K12422 L188_189 L106_107 0.0314
K12423 L188_189 L64_65 0.0451
K12424 L188_189 L26_27 0.098
K12425 L188_189 L170_171 0.049
K12426 L188_189 L193_194 0.0287
K12427 L188_189 L21_65 0.068
K12428 L188_189 L9_10 0.1127
K12429 L188_189 L195_196 0.0229
K12430 L188_189 L134_135 0.0362
K12431 L188_189 L41_69 0.0324
K12432 L188_189 L171_172 0.0496
K12433 L188_189 L104_105 0.0187
K12434 L188_189 L151_210 0.0273
K12435 L188_189 L37_38 0.049
K12436 L188_189 L112_113 0.0442
K12437 L188_189 L183_184 0.1832
K12438 L188_189 L11_57 0.1117
K12439 L188_189 L38_39 0.0492
K12440 L188_189 L27_28 0.1035
K12441 L188_189 L78_79 0.0317
K12442 L188_189 L44_45 0.0359
K12443 L188_189 L47_48 0.0406
K12444 L188_189 L29_30 0.1035
K12445 L188_189 L76_77 0.0253
K12446 L188_189 L166_167 0.0683
K12447 L188_189 L185_186 0.1832
K12448 L188_189 L191_192 0.0218
K12449 L188_189 L118_119 0.0656
K12450 L188_189 L176_177 0.1028
K12451 L188_189 L3_4 0.0911
K12452 L188_189 L6_53 0.1014
K12453 L188_189 L149_150 0.0237
K12454 L188_189 L2_3 0.0879
K12455 L188_189 L98_99 0.0235
K12456 L188_189 L84_98 0.0234
K12457 L188_189 L48_49 0.0575
K12458 L188_189 L113_114 0.0634
K12459 L188_189 L52_53 0.0623
K12460 L188_189 L80_81 0.0218
K12461 L188_189 L141_202 0.0319
K12462 L188_189 L87_88 0.0248
K12463 L188_189 L146_147 0.0235
K12464 L188_189 L136_137 0.0266
K12465 L188_189 L127_128 0.0339
K12466 L188_189 L138_139 0.0269
K12467 L188_189 L42_43 0.0359
K12468 L188_189 L181_182 0.1284
K12469 L188_189 L28_29 0.1055
K12470 L188_189 L157_158 0.2069
K12471 L188_189 L96_97 0.025
K12472 L188_189 L129_130 0.0697
K12473 L188_189 L21_22 0.136
K12474 L188_189 L117_118 0.0449
K12475 L188_189 L51_52 0.0438
K12476 L188_189 L56_57 0.0643
K12477 L188_189 L116_117 0.0341
K12478 L188_189 L173_174 0.0496
K12479 L188_189 L154_155 0.0188
K12480 L188_189 L32_33 0.0668
K12481 L188_189 L85_86 0.0199
K12482 L188_189 L7_8 0.1127
K12483 L188_189 L82_83 0.0274
K12484 L188_189 L14_15 0.1438
K12485 L188_189 L184_185 0.2054
K12486 L188_189 L141_142 0.025
K12487 L188_189 L70_71 0.0229
K12488 L188_189 L68_69 0.0286
K12489 L188_189 L180_181 0.1354
K12490 L188_189 L89_102 0.0186
K12491 L188_189 L8_9 0.1173
K12492 L188_189 L50_51 0.0336
K12493 L188_189 L83_84 0.0302
K12494 L188_189 L90_91 0.0266
K12495 L188_189 L139_140 0.0268
K12496 L188_189 L161_162 0.1098
K12497 L188_189 L111_112 0.0338
K12498 L188_189 L162_163 0.1123
K12499 L188_189 L137_138 0.0268
K12500 L188_189 L179_180 0.1284
K12501 L188_189 L12_13 0.1438
K12502 L188_189 L207_208 0.0199
K12503 L188_189 L142_143 0.0251
K12504 L188_189 L152_153 0.0188
K12505 L188_189 L39_40 0.049
K12506 L188_189 L130_156 0.1555
K12507 L188_189 L156_157 0.1891
K12508 L188_189 L11_12 0.1226
K12509 L188_189 L54_55 0.0339
K12510 L188_189 L201_202 0.0286
K12511 L173_174 L167_168 0.1258
K12512 L173_174 L74_90 0.0704
K12513 L173_174 L199_200 0.0347
K12514 L173_174 L115_179 0.0409
K12515 L173_174 L128_129 0.0523
K12516 L173_174 L196_197 0.0426
K12517 L173_174 L1_2 0.033
K12518 L173_174 L23_24 0.0624
K12519 L173_174 L158_159 0.0635
K12520 L173_174 L136_198 0.0696
K12521 L173_174 L163_164 0.0832
K12522 L173_174 L144_145 0.0688
K12523 L173_174 L91_92 0.0758
K12524 L173_174 L160_161 0.0786
K12525 L173_174 L126_127 0.0355
K12526 L173_174 L22_23 0.0615
K12527 L173_174 L204_205 0.0406
K12528 L173_174 L153_154 0.0463
K12529 L173_174 L4_5 0.0339
K12530 L173_174 L34_35 0.1221
K12531 L173_174 L41_42 0.1033
K12532 L173_174 L197_198 0.0534
K12533 L173_174 L143_144 0.0683
K12534 L173_174 L200_201 0.0417
K12535 L173_174 L205_206 0.0496
K12536 L173_174 L131_132 0.1073
K12537 L173_174 L100_101 0.0599
K12538 L173_174 L203_204 0.0341
K12539 L173_174 L92_93 0.0766
K12540 L173_174 L81_82 0.0405
K12541 L173_174 L13_14 0.045
K12542 L173_174 L148_149 0.0606
K12543 L173_174 L19_20 0.0492
K12544 L173_174 L187_188 0.049
K12545 L173_174 L165_166 0.1122
K12546 L173_174 L102_103 0.0449
K12547 L173_174 L106_107 0.0324
K12548 L173_174 L64_65 0.0519
K12549 L173_174 L8_9 0.0416
K12550 L173_174 L193_194 0.051
K12551 L173_174 L21_65 0.0629
K12552 L173_174 L121_122 0.0369
K12553 L173_174 L9_10 0.0417
K12554 L173_174 L195_196 0.0352
K12555 L173_174 L134_135 0.1244
K12556 L173_174 L41_69 0.0669
K12557 L173_174 L104_105 0.0459
K12558 L173_174 L151_210 0.0551
K12559 L173_174 L184_185 0.0454
K12560 L173_174 L112_113 0.0407
K12561 L173_174 L183_184 0.045
K12562 L173_174 L59_60 0.0436
K12563 L173_174 L11_57 0.0573
K12564 L173_174 L51_52 0.0406
K12565 L173_174 L27_28 0.0796
K12566 L173_174 L78_79 0.0649
K12567 L173_174 L44_45 0.118
K12568 L173_174 L47_48 0.0375
K12569 L173_174 L29_30 0.0817
K12570 L173_174 L76_77 0.0415
K12571 L173_174 L166_167 0.12
K12572 L173_174 L185_186 0.0456
K12573 L173_174 L16_17 0.0475
K12574 L173_174 L118_119 0.0499
K12575 L173_174 L176_177 0.0341
K12576 L173_174 L3_4 0.0338
K12577 L173_174 L6_53 0.0537
K12578 L173_174 L149_150 0.061
K12579 L173_174 L2_3 0.0335
K12580 L173_174 L98_99 0.0585
K12581 L173_174 L84_98 0.0569
K12582 L173_174 L48_49 0.0434
K12583 L173_174 L124_125 0.0621
K12584 L173_174 L113_114 0.0474
K12585 L173_174 L52_53 0.0471
K12586 L173_174 L80_81 0.034
K12587 L173_174 L141_202 0.0656
K12588 L173_174 L87_88 0.0447
K12589 L173_174 L146_147 0.0578
K12590 L173_174 L136_137 0.0722
K12591 L173_174 L127_128 0.0428
K12592 L173_174 L138_139 0.0781
K12593 L173_174 L42_43 0.1106
K12594 L173_174 L181_182 0.042
K12595 L173_174 L28_29 0.0811
K12596 L173_174 L157_158 0.0632
K12597 L173_174 L122_123 0.0438
K12598 L173_174 L96_97 0.0673
K12599 L173_174 L129_130 0.0636
K12600 L173_174 L21_22 0.0602
K12601 L173_174 L117_118 0.0423
K12602 L173_174 L56_57 0.0496
K12603 L173_174 L116_117 0.036
K12604 L173_174 L154_155 0.0466
K12605 L173_174 L32_33 0.1153
K12606 L173_174 L95_96 0.0668
K12607 L173_174 L85_86 0.0313
K12608 L173_174 L7_8 0.0412
K12609 L173_174 L82_83 0.0493
K12610 L173_174 L14_15 0.0451
K12611 L173_174 L141_142 0.0642
K12612 L173_174 L125_187 0.048
K12613 L173_174 L58_59 0.0368
K12614 L173_174 L70_71 0.0351
K12615 L173_174 L68_69 0.0507
K12616 L173_174 L180_181 0.0419
K12617 L173_174 L89_102 0.0438
K12618 L173_174 L26_27 0.0773
K12619 L173_174 L50_51 0.0349
K12620 L173_174 L83_84 0.0612
K12621 L173_174 L90_91 0.0736
K12622 L173_174 L139_140 0.079
K12623 L173_174 L161_162 0.0811
K12624 L173_174 L111_112 0.035
K12625 L173_174 L162_163 0.0827
K12626 L173_174 L137_138 0.0757
K12627 L173_174 L179_180 0.0415
K12628 L173_174 L12_13 0.0445
K12629 L173_174 L207_208 0.0313
K12630 L173_174 L142_143 0.0667
K12631 L173_174 L123_124 0.0525
K12632 L173_174 L152_153 0.0456
K12633 L173_174 L191_192 0.0332
K12634 L173_174 L18_19 0.049
K12635 L173_174 L130_156 0.0609
K12636 L173_174 L156_157 0.0623
K12637 L173_174 L189_190 0.0498
K12638 L173_174 L11_12 0.0438
K12639 L173_174 L54_55 0.0359
K12640 L173_174 L201_202 0.0515
K12641 L32_37 L181_185 0.0598
K12642 L32_37 L140_145 0.0593
K12643 L32_37 L1_6 0.0568
K12644 L32_37 L13_18 0.0718
K12645 L32_37 L35_40 0.1566
K12646 L32_37 L23_28 0.1081
K12647 L32_37 L73_78 0.0636
K12648 L32_37 L184_188 0.0699
K12649 L32_37 L6_11 0.0617
K12650 L32_37 L163_168 0.1463
K12651 L32_37 L91_95 0.083
K12652 L32_37 L144_149 0.0668
K12653 L32_37 L130_160 0.0992
K12654 L32_37 L4_9 0.0548
K12655 L32_37 L202_206 0.0595
K12656 L32_37 L109_114 0.0534
K12657 L32_37 L57_61 0.0601
K12658 L32_37 L164_169 0.1202
K12659 L32_37 L195_199 0.0317
K12660 L32_37 L106_111 0.0296
K12661 L32_37 L34_39 0.2092
K12662 L32_37 L148_153 0.0619
K12663 L32_37 L201_205 0.0481
K12664 L32_37 L53_57 0.0568
K12665 L32_37 L69_73 0.0672
K12666 L32_37 L200_204 0.0395
K12667 L32_37 L150_155 0.0479
K12668 L32_37 L145_150 0.0531
K12669 L32_37 L30_35 0.1278
K12670 L32_37 L131_136 0.0803
K12671 L32_37 L101_105 0.0488
K12672 L32_37 L46_50 0.0297
K12673 L32_37 L196_200 0.0405
K12674 L32_37 L92_96 0.0779
K12675 L32_37 L81_86 0.0387
K12676 L32_37 L19_24 0.0779
K12677 L32_37 L120_125 0.0664
K12678 L32_37 L8_13 0.0633
K12679 L32_37 L60_64 0.0501
K12680 L32_37 L198_202 0.0629
K12681 L32_37 L193_197 0.0515
K12682 L32_37 L167_172 0.2341
K12683 L32_37 L121_126 0.0317
K12684 L32_37 L97_101 0.0543
K12685 L32_37 L110_115 0.0562
K12686 L32_37 L113_118 0.0463
K12687 L32_37 L141_146 0.0664
K12688 L32_37 L100_104 0.061
K12689 L32_37 L9_14 0.061
K12690 L32_37 L138_143 0.08
K12691 L32_37 L33_38 0.2991
K12692 L32_37 L18_23 0.083
K12693 L32_37 L134_139 0.086
K12694 L32_37 L124_129 0.0629
K12695 L32_37 L107_112 0.0376
K12696 L32_37 L78_83 0.0601
K12697 L32_37 L112_117 0.0386
K12698 L32_37 L40_45 0.1278
K12699 L32_37 L59_63 0.0407
K12700 L32_37 L5_10 0.0442
K12701 L32_37 L15_20 0.0543
K12702 L32_37 L51_55 0.0387
K12703 L32_37 L58_62 0.0318
K12704 L32_37 L67_71 0.0416
K12705 L32_37 L29_34 0.159
K12706 L32_37 L206_210 0.0564
K12707 L32_37 L41_74 0.082
K12708 L32_37 L131_170 0.1747
K12709 L32_37 L205_209 0.0463
K12710 L32_37 L191_195 0.0323
K12711 L32_37 L178_182 0.0435
K12712 L32_37 L180_184 0.0619
K12713 L32_37 L3_8 0.0565
K12714 L32_37 L157_162 0.1038
K12715 L32_37 L149_154 0.0598
K12716 L32_37 L203_207 0.0303
K12717 L32_37 L66_70 0.0325
K12718 L32_37 L117_122 0.0395
K12719 L32_37 L158_189 0.0754
K12720 L32_37 L38_43 0.1944
K12721 L32_37 L135_174 0.1202
K12722 L32_37 L160_165 0.1747
K12723 L32_37 L52_56 0.0466
K12724 L32_37 L115_120 0.0609
K12725 L32_37 L80_85 0.0305
K12726 L32_37 L10_15 0.0488
K12727 L32_37 L16_21 0.0741
K12728 L32_37 L158_163 0.0976
K12729 L32_37 L185_189 0.0668
K12730 L32_37 L96_100 0.0685
K12731 L32_37 L49_53 0.0537
K12732 L32_37 L186_190 0.0531
K12733 L32_37 L82_87 0.0466
K12734 L32_37 L125_130 0.0728
K12735 L32_37 L108_113 0.0446
K12736 L32_37 L159_164 0.0853
K12737 L32_37 L84_89 0.0617
K12738 L32_37 L204_208 0.0386
K12739 L32_37 L25_30 0.0879
K12740 L32_37 L133_172 0.1706
K12741 L32_37 L14_19 0.0685
K12742 L32_37 L44_92 0.0898
K12743 L32_37 L21_26 0.1037
K12744 L32_37 L95_99 0.0718
K12745 L32_37 L116_121 0.031
K12746 L32_37 L74_79 0.0741
K12747 L32_37 L165_170 0.2588
K12748 L32_37 L199_203 0.031
K12749 L32_37 L75_80 0.0312
K12750 L32_37 L143_148 0.0699
K12751 L32_37 L70_75 0.0318
K12752 L32_37 L50_54 0.0305
K12753 L32_37 L79_84 0.0674
K12754 L32_37 L56_60 0.0483
K12755 L32_37 L159_190 0.0593
K12756 L32_37 L93_97 0.061
K12757 L32_37 L134_173 0.1463
K12758 L32_37 L139_144 0.0754
K12759 L32_37 L83_88 0.0568
K12760 L32_37 L177_181 0.054
K12761 L32_37 L111_116 0.0303
K12762 L32_37 L162_167 0.1706
K12763 L32_37 L43_91 0.098
K12764 L32_37 L122_127 0.0405
K12765 L32_37 L135_140 0.0666
K12766 L32_37 L39_44 0.159
K12767 L32_37 L123_128 0.0498
K12768 L32_37 L54_58 0.0312
K12769 L32_37 L146_151 0.0609
K12770 L32_37 L61_65 0.0636
K12771 L32_37 L11_16 0.0674
K12772 L32_37 L77_82 0.0483
K12773 L32_33 L74_90 0.0545
K12774 L32_33 L199_200 0.0353
K12775 L32_33 L115_179 0.0538
K12776 L32_33 L128_129 0.0698
K12777 L32_33 L196_197 0.0432
K12778 L32_33 L1_2 0.0441
K12779 L32_33 L23_24 0.0888
K12780 L32_33 L158_159 0.0843
K12781 L32_33 L136_198 0.0634
K12782 L32_33 L163_164 0.1153
K12783 L32_33 L144_145 0.0484
K12784 L32_33 L91_92 0.0545
K12785 L32_33 L160_161 0.1203
K12786 L32_33 L126_127 0.0419
K12787 L32_33 L22_23 0.0897
K12788 L32_33 L204_205 0.0404
K12789 L32_33 L153_154 0.0351
K12790 L32_33 L4_5 0.0434
K12791 L32_33 L41_42 0.0782
K12792 L32_33 L197_198 0.0523
K12793 L32_33 L143_144 0.049
K12794 L32_33 L200_201 0.0418
K12795 L32_33 L205_206 0.0476
K12796 L32_33 L36_37 0.1258
K12797 L32_33 L131_132 0.0767
K12798 L32_33 L100_101 0.045
K12799 L32_33 L203_204 0.0345
K12800 L32_33 L92_93 0.0537
K12801 L32_33 L81_82 0.0406
K12802 L32_33 L13_14 0.0606
K12803 L32_33 L148_149 0.045
K12804 L32_33 L19_20 0.0667
K12805 L32_33 L102_103 0.0355
K12806 L32_33 L106_107 0.0381
K12807 L32_33 L64_65 0.0708
K12808 L32_33 L8_9 0.0545
K12809 L32_33 L170_171 0.1203
K12810 L32_33 L193_194 0.0505
K12811 L32_33 L21_65 0.0939
K12812 L32_33 L121_122 0.0436
K12813 L32_33 L9_10 0.0537
K12814 L32_33 L195_196 0.0362
K12815 L32_33 L187_188 0.0673
K12816 L32_33 L134_135 0.0751
K12817 L32_33 L41_69 0.063
K12818 L32_33 L171_172 0.1221
K12819 L32_33 L104_105 0.0351
K12820 L32_33 L151_210 0.0494
K12821 L32_33 L37_38 0.1279
K12822 L32_33 L112_113 0.0498
K12823 L32_33 L183_184 0.0599
K12824 L32_33 L59_60 0.0546
K12825 L32_33 L11_57 0.0791
K12826 L32_33 L38_39 0.1258
K12827 L32_33 L27_28 0.1279
K12828 L32_33 L78_79 0.0598
K12829 L32_33 L44_45 0.0766
K12830 L32_33 L47_48 0.0462
K12831 L32_33 L29_30 0.12
K12832 L32_33 L76_77 0.0419
K12833 L32_33 L185_186 0.0585
K12834 L32_33 L16_17 0.0683
K12835 L32_33 L118_119 0.0646
K12836 L32_33 L176_177 0.0435
K12837 L32_33 L3_4 0.0441
K12838 L32_33 L6_53 0.0721
K12839 L32_33 L149_150 0.0445
K12840 L32_33 L2_3 0.0443
K12841 L32_33 L98_99 0.0456
K12842 L32_33 L84_98 0.0454
K12843 L32_33 L48_49 0.0561
K12844 L32_33 L124_125 0.0859
K12845 L32_33 L113_114 0.0606
K12846 L32_33 L52_53 0.0611
K12847 L32_33 L80_81 0.0346
K12848 L32_33 L141_202 0.0592
K12849 L32_33 L87_88 0.0431
K12850 L32_33 L146_147 0.045
K12851 L32_33 L136_137 0.0538
K12852 L32_33 L127_128 0.0531
K12853 L32_33 L138_139 0.0538
K12854 L32_33 L42_43 0.0788
K12855 L32_33 L181_182 0.053
K12856 L32_33 L28_29 0.1258
K12857 L32_33 L157_158 0.0865
K12858 L32_33 L122_123 0.0542
K12859 L32_33 L96_97 0.049
K12860 L32_33 L129_130 0.0915
K12861 L32_33 L21_22 0.0888
K12862 L32_33 L117_118 0.052
K12863 L32_33 L51_52 0.0501
K12864 L32_33 L56_57 0.0653
K12865 L32_33 L116_117 0.0424
K12866 L32_33 L154_155 0.0348
K12867 L32_33 L95_96 0.0496
K12868 L32_33 L85_86 0.0317
K12869 L32_33 L7_8 0.0548
K12870 L32_33 L82_83 0.0479
K12871 L32_33 L14_15 0.0595
K12872 L32_33 L184_185 0.0596
K12873 L32_33 L141_142 0.049
K12874 L32_33 L125_187 0.0668
K12875 L32_33 L58_59 0.0438
K12876 L32_33 L70_71 0.0363
K12877 L32_33 L68_69 0.0509
K12878 L32_33 L180_181 0.0538
K12879 L32_33 L89_102 0.0354
K12880 L32_33 L26_27 0.1258
K12881 L32_33 L50_51 0.0414
K12882 L32_33 L83_84 0.0559
K12883 L32_33 L90_91 0.0548
K12884 L32_33 L139_140 0.053
K12885 L32_33 L161_162 0.1221
K12886 L32_33 L111_112 0.0412
K12887 L32_33 L162_163 0.1203
K12888 L32_33 L137_138 0.054
K12889 L32_33 L179_180 0.054
K12890 L32_33 L12_13 0.061
K12891 L32_33 L207_208 0.0316
K12892 L32_33 L142_143 0.0492
K12893 L32_33 L123_124 0.069
K12894 L32_33 L152_153 0.0352
K12895 L32_33 L191_192 0.0343
K12896 L32_33 L39_40 0.12
K12897 L32_33 L18_19 0.0683
K12898 L32_33 L130_156 0.0865
K12899 L32_33 L156_157 0.0873
K12900 L32_33 L189_190 0.0653
K12901 L32_33 L11_12 0.0606
K12902 L32_33 L54_55 0.0426
K12903 L32_33 L201_202 0.0499
K12904 L133_172 L181_185 0.0465
K12905 L133_172 L140_145 0.1068
K12906 L133_172 L1_6 0.0445
K12907 L133_172 L35_40 0.1403
K12908 L133_172 L73_78 0.0678
K12909 L133_172 L6_11 0.0474
K12910 L133_172 L163_168 0.1081
K12911 L133_172 L144_149 0.1187
K12912 L133_172 L130_160 0.067
K12913 L133_172 L4_9 0.0422
K12914 L133_172 L202_206 0.0657
K12915 L133_172 L109_114 0.0444
K12916 L133_172 L57_61 0.0486
K12917 L133_172 L164_169 0.095
K12918 L133_172 L195_199 0.0319
K12919 L133_172 L106_111 0.0266
K12920 L133_172 L34_39 0.1706
K12921 L133_172 L201_205 0.0502
K12922 L133_172 L53_57 0.0463
K12923 L133_172 L69_73 0.0704
K12924 L133_172 L200_204 0.0403
K12925 L133_172 L150_155 0.0762
K12926 L133_172 L145_150 0.0897
K12927 L133_172 L30_35 0.0917
K12928 L133_172 L131_136 0.1019
K12929 L133_172 L101_105 0.0728
K12930 L133_172 L46_50 0.0265
K12931 L133_172 L196_200 0.0409
K12932 L133_172 L92_96 0.1319
K12933 L133_172 L81_86 0.0394
K12934 L133_172 L19_24 0.0555
K12935 L133_172 L120_125 0.0511
K12936 L133_172 L160_165 0.0983
K12937 L133_172 L185_189 0.051
K12938 L133_172 L60_64 0.0427
K12939 L133_172 L198_202 0.0686
K12940 L133_172 L193_197 0.0526
K12941 L133_172 L7_12 0.0391
K12942 L133_172 L137_142 0.098
K12943 L133_172 L121_126 0.0286
K12944 L133_172 L97_101 0.0843
K12945 L133_172 L110_115 0.0447
K12946 L133_172 L113_118 0.0399
K12947 L133_172 L141_146 0.0842
K12948 L133_172 L100_104 0.093
K12949 L133_172 L9_14 0.0459
K12950 L133_172 L134_139 0.1879
K12951 L133_172 L124_129 0.0514
K12952 L133_172 L107_112 0.0335
K12953 L133_172 L78_83 0.065
K12954 L133_172 L112_117 0.0344
K12955 L133_172 L40_45 0.1794
K12956 L133_172 L183_187 0.0427
K12957 L133_172 L59_63 0.0361
K12958 L133_172 L5_10 0.0346
K12959 L133_172 L15_20 0.041
K12960 L133_172 L51_55 0.0343
K12961 L133_172 L58_62 0.0285
K12962 L133_172 L67_71 0.0413
K12963 L133_172 L29_34 0.1038
K12964 L133_172 L179_183 0.0394
K12965 L133_172 L158_189 0.0565
K12966 L133_172 L206_210 0.0627
K12967 L133_172 L41_74 0.0985
K12968 L133_172 L131_170 0.2473
K12969 L133_172 L205_209 0.0488
K12970 L133_172 L191_195 0.0323
K12971 L133_172 L66_70 0.0322
K12972 L133_172 L98_102 0.0699
K12973 L133_172 L27_32 0.1038
K12974 L133_172 L142_147 0.083
K12975 L133_172 L147_152 0.0718
K12976 L133_172 L178_182 0.0349
K12977 L133_172 L149_154 0.098
K12978 L133_172 L203_207 0.031
K12979 L133_172 L2_7 0.0364
K12980 L133_172 L117_122 0.0353
K12981 L133_172 L22_27 0.0717
K12982 L133_172 L135_174 0.2076
K12983 L133_172 L52_56 0.0398
K12984 L133_172 L115_120 0.0477
K12985 L133_172 L80_85 0.0309
K12986 L133_172 L10_15 0.0375
K12987 L133_172 L16_21 0.0544
K12988 L133_172 L158_163 0.073
K12989 L133_172 L96_100 0.1101
K12990 L133_172 L49_53 0.0441
K12991 L133_172 L186_190 0.0415
K12992 L133_172 L82_87 0.0486
K12993 L133_172 L125_130 0.0549
K12994 L133_172 L108_113 0.0385
K12995 L133_172 L159_164 0.0659
K12996 L133_172 L84_89 0.0753
K12997 L133_172 L204_208 0.0395
K12998 L133_172 L25_30 0.0648
K12999 L133_172 L14_19 0.0503
K13000 L133_172 L44_92 0.1572
K13001 L133_172 L161_166 0.1081
K13002 L133_172 L21_26 0.0658
K13003 L133_172 L116_121 0.0279
K13004 L133_172 L74_79 0.0902
K13005 L133_172 L165_170 0.17
K13006 L133_172 L199_203 0.0315
K13007 L133_172 L75_80 0.0314
K13008 L133_172 L70_75 0.0318
K13009 L133_172 L50_54 0.0272
K13010 L133_172 L79_84 0.0823
K13011 L133_172 L56_60 0.0412
K13012 L133_172 L159_190 0.0458
K13013 L133_172 L93_97 0.0979
K13014 L133_172 L90_94 0.093
K13015 L133_172 L134_173 0.2991
K13016 L133_172 L139_144 0.1482
K13017 L133_172 L83_88 0.0621
K13018 L133_172 L177_181 0.0427
K13019 L133_172 L111_116 0.0272
K13020 L133_172 L122_127 0.0362
K13021 L133_172 L135_140 0.1262
K13022 L133_172 L39_44 0.2341
K13023 L133_172 L123_128 0.0429
K13024 L133_172 L12_17 0.0422
K13025 L133_172 L54_58 0.0278
K13026 L133_172 L146_151 0.0767
K13027 L133_172 L61_65 0.051
K13028 L133_172 L11_16 0.0507
K13029 L133_172 L77_82 0.0499
K13030 L95_96 L167_168 0.0492
K13031 L95_96 L74_90 0.1439
K13032 L95_96 L115_179 0.0221
K13033 L95_96 L128_129 0.0307
K13034 L95_96 L196_197 0.0445
K13035 L95_96 L1_2 0.0182
K13036 L95_96 L23_24 0.0316
K13037 L95_96 L158_159 0.0313
K13038 L95_96 L136_198 0.1117
K13039 L95_96 L163_164 0.0386
K13040 L95_96 L91_92 0.2054
K13041 L95_96 L160_161 0.0383
K13042 L95_96 L126_127 0.0237
K13043 L95_96 L22_23 0.0315
K13044 L95_96 L204_205 0.0361
K13045 L95_96 L153_154 0.1033
K13046 L95_96 L4_5 0.0183
K13047 L95_96 L34_35 0.0496
K13048 L95_96 L41_42 0.1004
K13049 L95_96 L197_198 0.0643
K13050 L95_96 L191_192 0.0315
K13051 L95_96 L205_206 0.0482
K13052 L95_96 L36_37 0.0667
K13053 L95_96 L131_132 0.0947
K13054 L95_96 L100_101 0.1832
K13055 L95_96 L203_204 0.0287
K13056 L95_96 L92_93 0.1832
K13057 L95_96 L81_82 0.0363
K13058 L95_96 L13_14 0.0237
K13059 L95_96 L148_149 0.1536
K13060 L95_96 L19_20 0.0251
K13061 L95_96 L187_188 0.025
K13062 L95_96 L165_166 0.0484
K13063 L95_96 L102_103 0.1144
K13064 L95_96 L106_107 0.0213
K13065 L95_96 L64_65 0.0309
K13066 L95_96 L8_9 0.0224
K13067 L95_96 L170_171 0.0653
K13068 L95_96 L193_194 0.0596
K13069 L95_96 L21_65 0.034
K13070 L95_96 L121_122 0.0245
K13071 L95_96 L9_10 0.0223
K13072 L95_96 L195_196 0.0339
K13073 L95_96 L134_135 0.1006
K13074 L95_96 L41_69 0.1086
K13075 L95_96 L171_172 0.0668
K13076 L95_96 L104_105 0.1144
K13077 L95_96 L151_210 0.0654
K13078 L95_96 L138_139 0.1536
K13079 L95_96 L37_38 0.0683
K13080 L95_96 L98_99 0.1832
K13081 L95_96 L112_113 0.0257
K13082 L95_96 L183_184 0.0235
K13083 L95_96 L59_60 0.0278
K13084 L95_96 L11_57 0.032
K13085 L95_96 L38_39 0.0688
K13086 L95_96 L27_28 0.0389
K13087 L95_96 L44_45 0.1076
K13088 L95_96 L47_48 0.0238
K13089 L95_96 L29_30 0.0389
K13090 L95_96 L166_167 0.049
K13091 L95_96 L185_186 0.0235
K13092 L95_96 L16_17 0.025
K13093 L95_96 L118_119 0.0295
K13094 L95_96 L176_177 0.0182
K13095 L95_96 L3_4 0.0183
K13096 L95_96 L6_53 0.0303
K13097 L95_96 L149_150 0.1438
K13098 L95_96 L2_3 0.0183
K13099 L95_96 L84_98 0.1439
K13100 L95_96 L48_49 0.0261
K13101 L95_96 L124_125 0.0337
K13102 L95_96 L113_114 0.0282
K13103 L95_96 L52_53 0.0283
K13104 L95_96 L80_81 0.0289
K13105 L95_96 L87_88 0.0449
K13106 L95_96 L146_147 0.1226
K13107 L95_96 L136_137 0.1226
K13108 L95_96 L127_128 0.0271
K13109 L95_96 L42_43 0.1076
K13110 L95_96 L181_182 0.0222
K13111 L95_96 L28_29 0.039
K13112 L95_96 L157_158 0.0314
K13113 L95_96 L122_123 0.0277
K13114 L95_96 L161_162 0.0386
K13115 L95_96 L129_130 0.0338
K13116 L95_96 L21_22 0.0313
K13117 L95_96 L117_118 0.0266
K13118 L95_96 L51_52 0.0257
K13119 L95_96 L56_57 0.0296
K13120 L95_96 L116_117 0.0238
K13121 L95_96 L154_155 0.0988
K13122 L95_96 L85_86 0.0268
K13123 L95_96 L7_8 0.0223
K13124 L95_96 L82_83 0.0488
K13125 L95_96 L14_15 0.0237
K13126 L95_96 L184_185 0.0236
K13127 L95_96 L125_187 0.0248
K13128 L95_96 L58_59 0.0245
K13129 L95_96 L70_71 0.0341
K13130 L95_96 L68_69 0.0608
K13131 L95_96 L180_181 0.0223
K13132 L95_96 L89_102 0.0985
K13133 L95_96 L26_27 0.0386
K13134 L95_96 L50_51 0.0231
K13135 L95_96 L83_84 0.0741
K13136 L95_96 L90_91 0.1832
K13137 L95_96 L139_140 0.1438
K13138 L95_96 L111_112 0.023
K13139 L95_96 L162_163 0.0387
K13140 L95_96 L137_138 0.1438
K13141 L95_96 L179_180 0.0222
K13142 L95_96 L12_13 0.0237
K13143 L95_96 L207_208 0.0267
K13144 L95_96 L123_124 0.031
K13145 L95_96 L152_153 0.0988
K13146 L95_96 L39_40 0.0683
K13147 L95_96 L18_19 0.0252
K13148 L95_96 L130_156 0.0311
K13149 L95_96 L156_157 0.0313
K13150 L95_96 L189_190 0.025
K13151 L95_96 L11_12 0.0235
K13152 L95_96 L54_55 0.0238
K13153 L85_86 L167_168 0.0304
K13154 L85_86 L74_90 0.0295
K13155 L85_86 L115_179 0.0199
K13156 L85_86 L196_197 0.13
K13157 L85_86 L1_2 0.0164
K13158 L85_86 L23_24 0.0245
K13159 L85_86 L158_159 0.0238
K13160 L85_86 L136_198 0.0588
K13161 L85_86 L163_164 0.0274
K13162 L85_86 L144_145 0.0254
K13163 L85_86 L91_92 0.0266
K13164 L85_86 L160_161 0.0301
K13165 L85_86 L126_127 0.0412
K13166 L85_86 L22_23 0.0252
K13167 L85_86 L204_205 0.1674
K13168 L85_86 L4_5 0.0152
K13169 L85_86 L34_35 0.0295
K13170 L85_86 L41_42 0.0344
K13171 L85_86 L197_198 0.0837
K13172 L85_86 L143_144 0.0267
K13173 L85_86 L200_201 0.1479
K13174 L85_86 L205_206 0.0911
K13175 L85_86 L36_37 0.0355
K13176 L85_86 L131_132 0.0343
K13177 L85_86 L100_101 0.0256
K13178 L85_86 L203_204 0.2623
K13179 L85_86 L92_93 0.0253
K13180 L85_86 L81_82 0.1877
K13181 L85_86 L13_14 0.0194
K13182 L85_86 L148_149 0.0268
K13183 L85_86 L19_20 0.0194
K13184 L85_86 L187_188 0.0205
K13185 L85_86 L165_166 0.0328
K13186 L85_86 L128_129 0.0372
K13187 L85_86 L106_107 0.0341
K13188 L85_86 L8_9 0.0189
K13189 L85_86 L170_171 0.0354
K13190 L85_86 L193_194 0.077
K13191 L85_86 L21_65 0.0336
K13192 L85_86 L121_122 0.0411
K13193 L85_86 L9_10 0.0185
K13194 L85_86 L195_196 0.1684
K13195 L85_86 L134_135 0.0297
K13196 L85_86 L41_69 0.055
K13197 L85_86 L171_172 0.0339
K13198 L85_86 L180_181 0.0189
K13199 L85_86 L37_38 0.034
K13200 L85_86 L112_113 0.0363
K13201 L85_86 L183_184 0.0199
K13202 L85_86 L59_60 0.0403
K13203 L85_86 L11_57 0.033
K13204 L85_86 L38_39 0.0326
K13205 L85_86 L27_28 0.0293
K13206 L85_86 L78_79 0.0608
K13207 L85_86 L44_45 0.0298
K13208 L85_86 L47_48 0.0335
K13209 L85_86 L29_30 0.0275
K13210 L85_86 L76_77 0.1593
K13211 L85_86 L166_167 0.0316
K13212 L85_86 L185_186 0.0189
K13213 L85_86 L16_17 0.0211
K13214 L85_86 L181_182 0.0184
K13215 L85_86 L118_119 0.0359
K13216 L85_86 L176_177 0.0156
K13217 L85_86 L3_4 0.0156
K13218 L85_86 L6_53 0.0318
K13219 L85_86 L149_150 0.0255
K13220 L85_86 L2_3 0.016
K13221 L85_86 L98_99 0.0284
K13222 L85_86 L84_98 0.03
K13223 L85_86 L48_49 0.0318
K13224 L85_86 L124_125 0.0342
K13225 L85_86 L113_114 0.0344
K13226 L85_86 L52_53 0.0345
K13227 L85_86 L80_81 0.3407
K13228 L85_86 L141_202 0.0602
K13229 L85_86 L146_147 0.0299
K13230 L85_86 L136_137 0.0294
K13231 L85_86 L127_128 0.0401
K13232 L85_86 L138_139 0.0265
K13233 L85_86 L42_43 0.0328
K13234 L85_86 L28_29 0.0284
K13235 L85_86 L157_158 0.0245
K13236 L85_86 L122_123 0.0401
K13237 L85_86 L96_97 0.0255
K13238 L85_86 L129_130 0.0335
K13239 L85_86 L64_65 0.0373
K13240 L85_86 L117_118 0.0381
K13241 L85_86 L51_52 0.0364
K13242 L85_86 L56_57 0.036
K13243 L85_86 L116_117 0.039
K13244 L85_86 L21_22 0.026
K13245 L85_86 L7_8 0.0194
K13246 L85_86 L82_83 0.0934
K13247 L85_86 L14_15 0.0189
K13248 L85_86 L184_185 0.0194
K13249 L85_86 L141_142 0.0297
K13250 L85_86 L199_200 0.2081
K13251 L85_86 L125_187 0.021
K13252 L85_86 L58_59 0.0413
K13253 L85_86 L70_71 0.1829
K13254 L85_86 L68_69 0.0785
K13255 L85_86 L26_27 0.0302
K13256 L85_86 L50_51 0.0371
K13257 L85_86 L83_84 0.0618
K13258 L85_86 L90_91 0.0279
K13259 L85_86 L139_140 0.0252
K13260 L85_86 L161_162 0.0292
K13261 L85_86 L111_112 0.037
K13262 L85_86 L162_163 0.0283
K13263 L85_86 L137_138 0.0278
K13264 L85_86 L179_180 0.0194
K13265 L85_86 L12_13 0.02
K13266 L85_86 L142_143 0.0281
K13267 L85_86 L123_124 0.0376
K13268 L85_86 L191_192 0.1492
K13269 L85_86 L39_40 0.0313
K13270 L85_86 L18_19 0.0199
K13271 L85_86 L130_156 0.0259
K13272 L85_86 L156_157 0.0252
K13273 L85_86 L189_190 0.0194
K13274 L85_86 L11_12 0.0205
K13275 L85_86 L54_55 0.0391
K13276 L85_86 L201_202 0.0878
K13277 L161_166 L181_185 0.0898
K13278 L161_166 L140_145 0.0442
K13279 L161_166 L1_6 0.0728
K13280 L161_166 L13_18 0.1101
K13281 L161_166 L35_40 0.1202
K13282 L161_166 L23_28 0.1706
K13283 L161_166 L73_78 0.0534
K13284 L161_166 L184_188 0.1187
K13285 L161_166 L6_11 0.0803
K13286 L161_166 L163_168 0.2092
K13287 L161_166 L91_95 0.0555
K13288 L161_166 L144_149 0.0498
K13289 L161_166 L130_160 0.2112
K13290 L161_166 L4_9 0.0754
K13291 L161_166 L202_206 0.0509
K13292 L161_166 L109_114 0.0636
K13293 L161_166 L57_61 0.07
K13294 L161_166 L164_169 0.1566
K13295 L161_166 L195_199 0.0297
K13296 L161_166 L106_111 0.0318
K13297 L161_166 L34_39 0.1463
K13298 L161_166 L148_153 0.0465
K13299 L161_166 L201_205 0.0432
K13300 L161_166 L53_57 0.0664
K13301 L161_166 L69_73 0.0564
K13302 L161_166 L200_204 0.0367
K13303 L161_166 L150_155 0.037
K13304 L161_166 L145_150 0.0403
K13305 L161_166 L30_35 0.1436
K13306 L161_166 L131_136 0.0617
K13307 L161_166 L101_105 0.0366
K13308 L161_166 L46_50 0.0317
K13309 L161_166 L196_200 0.0377
K13310 L161_166 L92_96 0.054
K13311 L161_166 L81_86 0.0355
K13312 L161_166 L19_24 0.1139
K13313 L161_166 L120_125 0.0915
K13314 L161_166 L8_13 0.093
K13315 L161_166 L60_64 0.0546
K13316 L161_166 L198_202 0.0537
K13317 L161_166 L193_197 0.0466
K13318 L161_166 L167_172 0.1944
K13319 L161_166 L121_126 0.0336
K13320 L161_166 L97_101 0.0398
K13321 L161_166 L110_115 0.0741
K13322 L161_166 L113_118 0.0518
K13323 L161_166 L141_146 0.0526
K13324 L161_166 L100_104 0.045
K13325 L161_166 L9_14 0.086
K13326 L161_166 L138_143 0.0565
K13327 L161_166 L33_38 0.1706
K13328 L161_166 L18_23 0.1319
K13329 L161_166 L134_139 0.061
K13330 L161_166 L124_129 0.0746
K13331 L161_166 L107_112 0.0407
K13332 L161_166 L78_83 0.0506
K13333 L161_166 L112_117 0.0416
K13334 L161_166 L40_45 0.0853
K13335 L161_166 L59_63 0.0429
K13336 L161_166 L5_10 0.0593
K13337 L161_166 L15_20 0.075
K13338 L161_166 L51_55 0.0414
K13339 L161_166 L58_62 0.0334
K13340 L161_166 L67_71 0.0386
K13341 L161_166 L29_34 0.1838
K13342 L161_166 L206_210 0.0483
K13343 L161_166 L41_74 0.0609
K13344 L161_166 L131_170 0.1037
K13345 L161_166 L205_209 0.0415
K13346 L161_166 L191_195 0.0305
K13347 L161_166 L178_182 0.061
K13348 L161_166 L180_184 0.098
K13349 L161_166 L3_8 0.08
K13350 L161_166 L157_162 0.1944
K13351 L161_166 L149_154 0.0455
K13352 L161_166 L203_207 0.0282
K13353 L161_166 L66_70 0.0303
K13354 L161_166 L117_122 0.0424
K13355 L161_166 L158_189 0.1233
K13356 L161_166 L38_43 0.1038
K13357 L161_166 L135_174 0.0879
K13358 L161_166 L160_165 0.3972
K13359 L161_166 L52_56 0.0515
K13360 L161_166 L115_120 0.082
K13361 L161_166 L80_85 0.0282
K13362 L161_166 L10_15 0.0666
K13363 L161_166 L16_21 0.0992
K13364 L161_166 L158_163 0.159
K13365 L161_166 L185_189 0.1049
K13366 L161_166 L96_100 0.0491
K13367 L161_166 L49_53 0.0629
K13368 L161_166 L186_190 0.0787
K13369 L161_166 L82_87 0.0413
K13370 L161_166 L125_130 0.1027
K13371 L161_166 L108_113 0.0501
K13372 L161_166 L159_164 0.1278
K13373 L161_166 L84_89 0.0486
K13374 L161_166 L204_208 0.0357
K13375 L161_166 L25_30 0.1202
K13376 L161_166 L14_19 0.0989
K13377 L161_166 L44_92 0.0598
K13378 L161_166 L21_26 0.1747
K13379 L161_166 L95_99 0.0503
K13380 L161_166 L116_121 0.033
K13381 L161_166 L74_79 0.0562
K13382 L161_166 L165_170 0.2112
K13383 L161_166 L199_203 0.029
K13384 L161_166 L75_80 0.0289
K13385 L161_166 L143_148 0.051
K13386 L161_166 L70_75 0.0296
K13387 L161_166 L50_54 0.0323
K13388 L161_166 L79_84 0.0521
K13389 L161_166 L56_60 0.0531
K13390 L161_166 L159_190 0.0895
K13391 L161_166 L93_97 0.0435
K13392 L161_166 L134_173 0.101
K13393 L161_166 L139_144 0.0548
K13394 L161_166 L83_88 0.048
K13395 L161_166 L177_181 0.0779
K13396 L161_166 L111_116 0.0325
K13397 L161_166 L162_167 0.2991
K13398 L161_166 L43_91 0.0619
K13399 L161_166 L122_127 0.0431
K13400 L161_166 L135_140 0.0488
K13401 L161_166 L39_44 0.0976
K13402 L161_166 L123_128 0.055
K13403 L161_166 L54_58 0.0329
K13404 L161_166 L146_151 0.0489
K13405 L161_166 L61_65 0.0736
K13406 L161_166 L11_16 0.0891
K13407 L161_166 L77_82 0.043
K13408 L3_4 L167_168 0.0437
K13409 L3_4 L74_90 0.0192
K13410 L3_4 L199_200 0.0175
K13411 L3_4 L115_179 0.1153
K13412 L3_4 L128_129 0.0357
K13413 L3_4 L196_197 0.0201
K13414 L3_4 L13_14 0.1487
K13415 L3_4 L23_24 0.0863
K13416 L3_4 L158_159 0.0794
K13417 L3_4 L136_198 0.0247
K13418 L3_4 L163_164 0.0607
K13419 L3_4 L144_145 0.0182
K13420 L3_4 L91_92 0.0193
K13421 L3_4 L126_127 0.0219
K13422 L3_4 L22_23 0.0843
K13423 L3_4 L204_205 0.0189
K13424 L3_4 L153_154 0.0138
K13425 L3_4 L34_35 0.0441
K13426 L3_4 L41_42 0.0255
K13427 L3_4 L197_198 0.0225
K13428 L3_4 L143_144 0.0182
K13429 L3_4 L200_201 0.0195
K13430 L3_4 L205_206 0.0208
K13431 L3_4 L36_37 0.0338
K13432 L3_4 L131_132 0.0254
K13433 L3_4 L100_101 0.0173
K13434 L3_4 L203_204 0.017
K13435 L3_4 L92_93 0.0193
K13436 L3_4 L81_82 0.0189
K13437 L3_4 L148_149 0.0173
K13438 L3_4 L19_20 0.0983
K13439 L3_4 L187_188 0.0879
K13440 L3_4 L102_103 0.0138
K13441 L3_4 L160_161 0.0591
K13442 L3_4 L64_65 0.036
K13443 L3_4 L26_27 0.0606
K13444 L3_4 L165_166 0.0429
K13445 L3_4 L170_171 0.0335
K13446 L3_4 L193_194 0.0216
K13447 L3_4 L21_65 0.0519
K13448 L3_4 L121_122 0.0236
K13449 L3_4 L9_10 0.2134
K13450 L3_4 L195_196 0.0179
K13451 L3_4 L134_135 0.0255
K13452 L3_4 L41_69 0.024
K13453 L3_4 L171_172 0.0338
K13454 L3_4 L104_105 0.0138
K13455 L3_4 L151_210 0.0203
K13456 L3_4 L37_38 0.0341
K13457 L3_4 L112_113 0.03
K13458 L3_4 L183_184 0.1117
K13459 L3_4 L59_60 0.0296
K13460 L3_4 L11_57 0.0608
K13461 L3_4 L38_39 0.0342
K13462 L3_4 L27_28 0.0624
K13463 L3_4 L96_97 0.0183
K13464 L3_4 L78_79 0.0236
K13465 L3_4 L44_45 0.0257
K13466 L3_4 L29_30 0.0624
K13467 L3_4 L76_77 0.0195
K13468 L3_4 L166_167 0.0435
K13469 L3_4 L185_186 0.1117
K13470 L3_4 L16_17 0.0877
K13471 L3_4 L118_119 0.0398
K13472 L3_4 L180_181 0.1566
K13473 L3_4 L6_53 0.0629
K13474 L3_4 L149_150 0.0172
K13475 L3_4 L98_99 0.0173
K13476 L3_4 L84_98 0.0172
K13477 L3_4 L124_125 0.0568
K13478 L3_4 L113_114 0.0403
K13479 L3_4 L52_53 0.0408
K13480 L3_4 L80_81 0.0171
K13481 L3_4 L141_202 0.0236
K13482 L3_4 L87_88 0.0189
K13483 L3_4 L146_147 0.0172
K13484 L3_4 L136_137 0.0191
K13485 L3_4 L127_128 0.0272
K13486 L3_4 L138_139 0.0192
K13487 L3_4 L42_43 0.0257
K13488 L3_4 L181_182 0.1426
K13489 L3_4 L28_29 0.063
K13490 L3_4 L157_158 0.081
K13491 L3_4 L122_123 0.0295
K13492 L3_4 L129_130 0.0508
K13493 L3_4 L21_22 0.0792
K13494 L3_4 L117_118 0.0298
K13495 L3_4 L51_52 0.0302
K13496 L3_4 L56_57 0.0402
K13497 L3_4 L116_117 0.0238
K13498 L3_4 L154_155 0.0138
K13499 L3_4 L7_8 0.2134
K13500 L3_4 L82_83 0.0208
K13501 L3_4 L14_15 0.1362
K13502 L3_4 L184_185 0.1183
K13503 L3_4 L141_142 0.0181
K13504 L3_4 L125_187 0.0801
K13505 L3_4 L58_59 0.0237
K13506 L3_4 L70_71 0.018
K13507 L3_4 L68_69 0.0216
K13508 L3_4 L89_102 0.0137
K13509 L3_4 L8_9 0.2697
K13510 L3_4 L50_51 0.024
K13511 L3_4 L83_84 0.0226
K13512 L3_4 L90_91 0.0193
K13513 L3_4 L139_140 0.0192
K13514 L3_4 L161_162 0.0607
K13515 L3_4 L111_112 0.0239
K13516 L3_4 L162_163 0.0613
K13517 L3_4 L137_138 0.0192
K13518 L3_4 L179_180 0.1426
K13519 L3_4 L12_13 0.1362
K13520 L3_4 L207_208 0.0156
K13521 L3_4 L142_143 0.0182
K13522 L3_4 L123_124 0.039
K13523 L3_4 L152_153 0.0138
K13524 L3_4 L191_192 0.017
K13525 L3_4 L39_40 0.0341
K13526 L3_4 L18_19 0.1028
K13527 L3_4 L130_156 0.0752
K13528 L3_4 L156_157 0.0794
K13529 L3_4 L189_190 0.0879
K13530 L3_4 L11_12 0.1116
K13531 L3_4 L54_55 0.0239
K13532 L3_4 L201_202 0.0216
K13533 L95_99 L181_185 0.0234
K13534 L95_99 L140_145 0.0988
K13535 L95_99 L1_6 0.0277
K13536 L95_99 L35_40 0.0511
K13537 L95_99 L73_78 0.0599
K13538 L95_99 L6_11 0.0292
K13539 L95_99 L163_168 0.0422
K13540 L95_99 L144_149 0.1536
K13541 L95_99 L130_160 0.036
K13542 L95_99 L4_9 0.0222
K13543 L95_99 L202_206 0.0593
K13544 L95_99 L109_114 0.0288
K13545 L95_99 L57_61 0.0315
K13546 L95_99 L164_169 0.0385
K13547 L95_99 L195_199 0.0256
K13548 L95_99 L106_111 0.0186
K13549 L95_99 L34_39 0.0565
K13550 L95_99 L201_205 0.0424
K13551 L95_99 L53_57 0.0301
K13552 L95_99 L69_73 0.059
K13553 L95_99 L200_204 0.033
K13554 L95_99 L150_155 0.0988
K13555 L95_99 L145_150 0.1033
K13556 L95_99 L30_35 0.0389
K13557 L95_99 L131_136 0.0897
K13558 L95_99 L101_105 0.1144
K13559 L95_99 L46_50 0.0187
K13560 L95_99 L196_200 0.0329
K13561 L95_99 L92_96 0.1832
K13562 L95_99 L81_86 0.0331
K13563 L95_99 L19_24 0.0266
K13564 L95_99 L120_125 0.0307
K13565 L95_99 L160_165 0.0462
K13566 L95_99 L185_189 0.0248
K13567 L95_99 L60_64 0.029
K13568 L95_99 L198_202 0.059
K13569 L95_99 L193_197 0.042
K13570 L95_99 L7_12 0.0235
K13571 L95_99 L137_142 0.1438
K13572 L95_99 L121_126 0.0201
K13573 L95_99 L97_101 0.1216
K13574 L95_99 L110_115 0.0276
K13575 L95_99 L113_118 0.0269
K13576 L95_99 L141_146 0.0958
K13577 L95_99 L100_104 0.1832
K13578 L95_99 L9_14 0.0235
K13579 L95_99 L134_139 0.1226
K13580 L95_99 L124_129 0.0328
K13581 L95_99 L107_112 0.0233
K13582 L95_99 L78_83 0.0602
K13583 L95_99 L112_117 0.024
K13584 L95_99 L40_45 0.0732
K13585 L95_99 L183_187 0.0248
K13586 L95_99 L59_63 0.0254
K13587 L95_99 L5_10 0.0183
K13588 L95_99 L15_20 0.0206
K13589 L95_99 L51_55 0.024
K13590 L95_99 L58_62 0.0202
K13591 L95_99 L67_71 0.0329
K13592 L95_99 L29_34 0.0427
K13593 L95_99 L179_183 0.0234
K13594 L95_99 L158_189 0.0265
K13595 L95_99 L206_210 0.059
K13596 L95_99 L41_74 0.0939
K13597 L95_99 L131_170 0.0992
K13598 L95_99 L205_209 0.0423
K13599 L95_99 L191_195 0.0255
K13600 L95_99 L66_70 0.0256
K13601 L95_99 L98_102 0.1832
K13602 L95_99 L27_32 0.051
K13603 L95_99 L142_147 0.1536
K13604 L95_99 L147_152 0.1438
K13605 L95_99 L178_182 0.0182
K13606 L95_99 L149_154 0.1438
K13607 L95_99 L203_207 0.0256
K13608 L95_99 L2_7 0.0222
K13609 L95_99 L117_122 0.0246
K13610 L95_99 L22_27 0.0394
K13611 L95_99 L135_174 0.0708
K13612 L95_99 L52_56 0.027
K13613 L95_99 L115_120 0.0291
K13614 L95_99 L80_85 0.0257
K13615 L95_99 L10_15 0.0194
K13616 L95_99 L16_21 0.0327
K13617 L95_99 L158_163 0.034
K13618 L95_99 L96_100 0.2054
K13619 L95_99 L49_53 0.0288
K13620 L95_99 L186_190 0.0204
K13621 L95_99 L82_87 0.0426
K13622 L95_99 L125_130 0.0326
K13623 L95_99 L108_113 0.026
K13624 L95_99 L159_164 0.0312
K13625 L95_99 L84_89 0.0991
K13626 L95_99 L204_208 0.0329
K13627 L95_99 L25_30 0.0314
K13628 L95_99 L14_19 0.025
K13629 L95_99 L44_92 0.1439
K13630 L95_99 L21_26 0.0363
K13631 L95_99 L116_121 0.0196
K13632 L95_99 L74_79 0.0991
K13633 L95_99 L165_170 0.0639
K13634 L95_99 L199_203 0.0256
K13635 L95_99 L75_80 0.0257
K13636 L95_99 L70_75 0.0257
K13637 L95_99 L50_54 0.0192
K13638 L95_99 L79_84 0.1011
K13639 L95_99 L56_60 0.028
K13640 L95_99 L159_190 0.0218
K13641 L95_99 L93_97 0.1144
K13642 L95_99 L90_94 0.1832
K13643 L95_99 L134_173 0.08
K13644 L95_99 L139_144 0.1438
K13645 L95_99 L83_88 0.0599
K13646 L95_99 L177_181 0.0221
K13647 L95_99 L111_116 0.0191
K13648 L95_99 L122_127 0.0253
K13649 L95_99 L135_140 0.088
K13650 L95_99 L39_44 0.083
K13651 L95_99 L123_128 0.0289
K13652 L95_99 L12_17 0.025
K13653 L95_99 L54_58 0.0197
K13654 L95_99 L146_151 0.0941
K13655 L95_99 L61_65 0.033
K13656 L95_99 L11_16 0.0309
K13657 L95_99 L77_82 0.0427
K13658 L116_121 L181_185 0.0244
K13659 L116_121 L140_145 0.0158
K13660 L116_121 L1_6 0.0385
K13661 L116_121 L13_18 0.0256
K13662 L116_121 L35_40 0.0255
K13663 L116_121 L23_28 0.0325
K13664 L116_121 L73_78 0.0362
K13665 L116_121 L184_188 0.0257
K13666 L116_121 L6_11 0.0387
K13667 L116_121 L163_168 0.03
K13668 L116_121 L91_95 0.0201
K13669 L116_121 L144_149 0.0191
K13670 L116_121 L130_160 0.033
K13671 L116_121 L4_9 0.0243
K13672 L116_121 L202_206 0.035
K13673 L116_121 L109_114 0.0553
K13674 L116_121 L57_61 0.0555
K13675 L116_121 L164_169 0.0268
K13676 L116_121 L34_39 0.0285
K13677 L116_121 L148_153 0.0192
K13678 L116_121 L201_205 0.0393
K13679 L116_121 L53_57 0.0554
K13680 L116_121 L69_73 0.0376
K13681 L116_121 L200_204 0.043
K13682 L116_121 L150_155 0.0151
K13683 L116_121 L145_150 0.0155
K13684 L116_121 L30_35 0.0267
K13685 L116_121 L131_136 0.0295
K13686 L116_121 L101_105 0.0151
K13687 L116_121 L122_127 0.1506
K13688 L116_121 L196_200 0.0455
K13689 L116_121 L92_96 0.0195
K13690 L116_121 L81_86 0.0405
K13691 L116_121 L19_24 0.0243
K13692 L116_121 L120_125 0.039
K13693 L116_121 L8_13 0.0256
K13694 L116_121 L60_64 0.0797
K13695 L116_121 L198_202 0.0364
K13696 L116_121 L193_197 0.0433
K13697 L116_121 L7_12 0.027
K13698 L116_121 L137_142 0.0209
K13699 L116_121 L167_172 0.0298
K13700 L116_121 L97_101 0.0154
K13701 L116_121 L110_115 0.0387
K13702 L116_121 L113_118 0.0812
K13703 L116_121 L134_139 0.02
K13704 L116_121 L141_146 0.0277
K13705 L116_121 L100_104 0.0186
K13706 L116_121 L9_14 0.0243
K13707 L116_121 L138_143 0.0202
K13708 L116_121 L33_38 0.0297
K13709 L116_121 L18_23 0.0256
K13710 L116_121 L124_129 0.0558
K13711 L116_121 L107_112 0.1402
K13712 L116_121 L78_83 0.0349
K13713 L116_121 L112_117 0.1506
K13714 L116_121 L40_45 0.0241
K13715 L116_121 L183_187 0.0272
K13716 L116_121 L59_63 0.1405
K13717 L116_121 L5_10 0.0194
K13718 L116_121 L15_20 0.0195
K13719 L116_121 L51_55 0.1405
K13720 L116_121 L67_71 0.0481
K13721 L116_121 L29_34 0.0299
K13722 L116_121 L158_189 0.0244
K13723 L116_121 L206_210 0.0337
K13724 L116_121 L41_74 0.0294
K13725 L116_121 L131_170 0.0276
K13726 L116_121 L205_209 0.0375
K13727 L116_121 L98_102 0.0197
K13728 L116_121 L27_32 0.0329
K13729 L116_121 L147_152 0.0197
K13730 L116_121 L178_182 0.0194
K13731 L116_121 L180_184 0.0257
K13732 L116_121 L3_8 0.0255
K13733 L116_121 L157_162 0.0326
K13734 L116_121 L149_154 0.0186
K13735 L116_121 L2_7 0.0269
K13736 L116_121 L117_122 0.1548
K13737 L116_121 L22_27 0.0342
K13738 L116_121 L38_43 0.0278
K13739 L116_121 L135_174 0.0241
K13740 L116_121 L160_165 0.0317
K13741 L116_121 L52_56 0.0797
K13742 L116_121 L115_120 0.0389
K13743 L116_121 L10_15 0.0194
K13744 L116_121 L16_21 0.0387
K13745 L116_121 L158_163 0.031
K13746 L116_121 L185_189 0.0245
K13747 L116_121 L96_100 0.019
K13748 L116_121 L49_53 0.0549
K13749 L116_121 L186_190 0.0195
K13750 L116_121 L82_87 0.0373
K13751 L116_121 L125_130 0.0389
K13752 L116_121 L108_113 0.0796
K13753 L116_121 L159_164 0.0276
K13754 L116_121 L204_208 0.0406
K13755 L116_121 L25_30 0.0275
K13756 L116_121 L14_19 0.0244
K13757 L116_121 L44_92 0.02
K13758 L116_121 L21_26 0.0329
K13759 L116_121 L84_89 0.0268
K13760 L116_121 L74_79 0.0285
K13761 L116_121 L165_170 0.0298
K13762 L116_121 L143_148 0.0197
K13763 L116_121 L79_84 0.0276
K13764 L116_121 L56_60 0.0802
K13765 L116_121 L159_190 0.0195
K13766 L116_121 L93_97 0.0158
K13767 L116_121 L90_94 0.0208
K13768 L116_121 L134_173 0.0269
K13769 L116_121 L139_144 0.0196
K13770 L116_121 L83_88 0.0336
K13771 L116_121 L177_181 0.0243
K13772 L116_121 L179_183 0.0271
K13773 L116_121 L162_167 0.0315
K13774 L116_121 L43_91 0.0207
K13775 L116_121 L142_147 0.0203
K13776 L116_121 L135_140 0.0162
K13777 L116_121 L39_44 0.0268
K13778 L116_121 L123_128 0.0812
K13779 L116_121 L12_17 0.0271
K13780 L116_121 L146_151 0.0269
K13781 L116_121 L61_65 0.0554
K13782 L116_121 L11_16 0.0388
K13783 L116_121 L77_82 0.0391
K13784 L159_190 L181_185 0.1268
K13785 L159_190 L1_6 0.0556
K13786 L159_190 L13_18 0.0988
K13787 L159_190 L23_28 0.1286
K13788 L159_190 L73_78 0.0268
K13789 L159_190 L184_188 0.1144
K13790 L159_190 L6_11 0.0581
K13791 L159_190 L163_168 0.1284
K13792 L159_190 L91_95 0.0232
K13793 L159_190 L144_149 0.0221
K13794 L159_190 L130_160 0.0966
K13795 L159_190 L4_9 0.0867
K13796 L159_190 L109_114 0.0409
K13797 L159_190 L57_61 0.0417
K13798 L159_190 L195_199 0.0162
K13799 L159_190 L106_111 0.0193
K13800 L159_190 L34_39 0.0671
K13801 L159_190 L148_153 0.0206
K13802 L159_190 L201_205 0.0227
K13803 L159_190 L53_57 0.0412
K13804 L159_190 L69_73 0.028
K13805 L159_190 L200_204 0.0199
K13806 L159_190 L131_136 0.0292
K13807 L159_190 L100_104 0.0206
K13808 L159_190 L46_50 0.0193
K13809 L159_190 L196_200 0.0204
K13810 L159_190 L92_96 0.0235
K13811 L159_190 L81_86 0.0193
K13812 L159_190 L19_24 0.1363
K13813 L159_190 L120_125 0.0615
K13814 L159_190 L8_13 0.088
K13815 L159_190 L60_64 0.0312
K13816 L159_190 L198_202 0.0269
K13817 L159_190 L193_197 0.0241
K13818 L159_190 L7_12 0.073
K13819 L159_190 L137_142 0.023
K13820 L159_190 L143_148 0.0219
K13821 L159_190 L167_172 0.0657
K13822 L159_190 L121_126 0.0195
K13823 L159_190 L110_115 0.057
K13824 L159_190 L113_118 0.0312
K13825 L159_190 L134_139 0.0254
K13826 L159_190 L141_146 0.026
K13827 L159_190 L9_14 0.1062
K13828 L159_190 L138_143 0.0234
K13829 L159_190 L33_38 0.0635
K13830 L159_190 L18_23 0.1033
K13831 L159_190 L124_129 0.0423
K13832 L159_190 L107_112 0.0247
K13833 L159_190 L78_83 0.0257
K13834 L159_190 L112_117 0.0249
K13835 L159_190 L183_187 0.0861
K13836 L159_190 L59_63 0.0249
K13837 L159_190 L51_55 0.0248
K13838 L159_190 L58_62 0.0195
K13839 L159_190 L67_71 0.0208
K13840 L159_190 L29_34 0.1131
K13841 L159_190 L179_183 0.0787
K13842 L159_190 L206_210 0.0248
K13843 L159_190 L41_74 0.029
K13844 L159_190 L131_170 0.0404
K13845 L159_190 L205_209 0.0219
K13846 L159_190 L191_195 0.0165
K13847 L159_190 L66_70 0.0165
K13848 L159_190 L98_102 0.0202
K13849 L159_190 L27_32 0.0842
K13850 L159_190 L142_147 0.0216
K13851 L159_190 L147_152 0.0203
K13852 L159_190 L180_184 0.0985
K13853 L159_190 L3_8 0.0759
K13854 L159_190 L157_162 0.1498
K13855 L159_190 L149_154 0.0207
K13856 L159_190 L203_207 0.0155
K13857 L159_190 L2_7 0.0657
K13858 L159_190 L117_122 0.025
K13859 L159_190 L22_27 0.1021
K13860 L159_190 L158_189 0.1916
K13861 L159_190 L38_43 0.0451
K13862 L159_190 L108_113 0.0308
K13863 L159_190 L160_165 0.0791
K13864 L159_190 L52_56 0.031
K13865 L159_190 L115_120 0.0597
K13866 L159_190 L80_85 0.0154
K13867 L159_190 L16_21 0.0604
K13868 L159_190 L158_163 0.2249
K13869 L159_190 L185_189 0.1673
K13870 L159_190 L96_100 0.022
K13871 L159_190 L49_53 0.0405
K13872 L159_190 L82_87 0.0219
K13873 L159_190 L125_130 0.0622
K13874 L159_190 L84_89 0.0246
K13875 L159_190 L204_208 0.0194
K13876 L159_190 L202_206 0.0258
K13877 L159_190 L14_19 0.1266
K13878 L159_190 L44_92 0.0252
K13879 L159_190 L21_26 0.0893
K13880 L159_190 L74_79 0.0274
K13881 L159_190 L165_170 0.0552
K13882 L159_190 L199_203 0.0158
K13883 L159_190 L75_80 0.0158
K13884 L159_190 L70_75 0.0161
K13885 L159_190 L50_54 0.0194
K13886 L159_190 L79_84 0.0259
K13887 L159_190 L56_60 0.0312
K13888 L159_190 L90_94 0.0229
K13889 L159_190 L134_173 0.0471
K13890 L159_190 L139_144 0.0237
K13891 L159_190 L83_88 0.0247
K13892 L159_190 L177_181 0.0968
K13893 L159_190 L111_116 0.0194
K13894 L159_190 L162_167 0.1068
K13895 L159_190 L43_91 0.0249
K13896 L159_190 L122_127 0.025
K13897 L159_190 L39_44 0.0463
K13898 L159_190 L123_128 0.0314
K13899 L159_190 L12_17 0.0789
K13900 L159_190 L54_58 0.0194
K13901 L159_190 L146_151 0.0247
K13902 L159_190 L61_65 0.0418
K13903 L159_190 L11_16 0.0598
K13904 L159_190 L77_82 0.0226
K13905 L83_84 L167_168 0.0536
K13906 L83_84 L74_90 0.0921
K13907 L83_84 L199_200 0.0653
K13908 L83_84 L115_179 0.0284
K13909 L83_84 L128_129 0.0449
K13910 L83_84 L196_197 0.0931
K13911 L83_84 L1_2 0.0233
K13912 L83_84 L23_24 0.0377
K13913 L83_84 L158_159 0.0367
K13914 L83_84 L136_198 0.2117
K13915 L83_84 L163_164 0.044
K13916 L83_84 L144_145 0.0643
K13917 L83_84 L91_92 0.071
K13918 L83_84 L160_161 0.0475
K13919 L83_84 L126_127 0.037
K13920 L83_84 L22_23 0.0386
K13921 L83_84 L138_139 0.0693
K13922 L83_84 L153_154 0.0945
K13923 L83_84 L4_5 0.0222
K13924 L83_84 L34_35 0.0519
K13925 L83_84 L41_42 0.0886
K13926 L83_84 L197_198 0.1537
K13927 L83_84 L143_144 0.0723
K13928 L83_84 L200_201 0.0969
K13929 L83_84 L36_37 0.0725
K13930 L83_84 L131_132 0.0865
K13931 L83_84 L122_123 0.0418
K13932 L83_84 L92_93 0.0634
K13933 L83_84 L13_14 0.0289
K13934 L83_84 L19_20 0.0296
K13935 L83_84 L187_188 0.0308
K13936 L83_84 L102_103 0.1273
K13937 L83_84 L106_107 0.0323
K13938 L83_84 L64_65 0.0451
K13939 L83_84 L8_9 0.0276
K13940 L83_84 L170_171 0.0715
K13941 L83_84 L193_194 0.1387
K13942 L83_84 L21_65 0.0465
K13943 L83_84 L121_122 0.0378
K13944 L83_84 L9_10 0.0271
K13945 L83_84 L195_196 0.0642
K13946 L83_84 L134_135 0.0671
K13947 L83_84 L41_69 0.2072
K13948 L83_84 L171_172 0.0681
K13949 L83_84 L104_105 0.0839
K13950 L83_84 L151_210 0.2623
K13951 L83_84 L37_38 0.0689
K13952 L83_84 L112_113 0.0381
K13953 L83_84 L183_184 0.0293
K13954 L83_84 L59_60 0.0419
K13955 L83_84 L11_57 0.0437
K13956 L83_84 L38_39 0.0653
K13957 L83_84 L27_28 0.0467
K13958 L83_84 L96_97 0.0656
K13959 L83_84 L78_79 0.3334
K13960 L83_84 L44_45 0.0681
K13961 L83_84 L47_48 0.0352
K13962 L83_84 L29_30 0.0442
K13963 L83_84 L76_77 0.0993
K13964 L83_84 L166_167 0.0555
K13965 L83_84 L185_186 0.0282
K13966 L83_84 L16_17 0.0315
K13967 L83_84 L118_119 0.0425
K13968 L83_84 L176_177 0.0225
K13969 L83_84 L6_53 0.0414
K13970 L83_84 L2_3 0.023
K13971 L83_84 L113_114 0.0404
K13972 L83_84 L48_49 0.0373
K13973 L83_84 L124_125 0.046
K13974 L83_84 L52_53 0.0405
K13975 L83_84 L141_202 0.2659
K13976 L83_84 L87_88 0.1877
K13977 L83_84 L136_137 0.0885
K13978 L83_84 L127_128 0.0414
K13979 L83_84 L42_43 0.081
K13980 L83_84 L181_182 0.027
K13981 L83_84 L28_29 0.0455
K13982 L83_84 L157_158 0.0376
K13983 L83_84 L129_130 0.0462
K13984 L83_84 L21_22 0.0393
K13985 L83_84 L117_118 0.0399
K13986 L83_84 L51_52 0.0382
K13987 L83_84 L56_57 0.0427
K13988 L83_84 L116_117 0.0364
K13989 L83_84 L7_8 0.028
K13990 L83_84 L154_155 0.08
K13991 L83_84 L14_15 0.0283
K13992 L83_84 L184_185 0.0288
K13993 L83_84 L141_142 0.095
K13994 L83_84 L125_187 0.0314
K13995 L83_84 L58_59 0.0379
K13996 L83_84 L70_71 0.0648
K13997 L83_84 L68_69 0.1475
K13998 L83_84 L180_181 0.0275
K13999 L83_84 L89_102 0.1637
K14000 L83_84 L26_27 0.0477
K14001 L83_84 L50_51 0.0351
K14002 L83_84 L165_166 0.0573
K14003 L83_84 L90_91 0.0803
K14004 L83_84 L139_140 0.0623
K14005 L83_84 L161_162 0.0464
K14006 L83_84 L111_112 0.035
K14007 L83_84 L162_163 0.0452
K14008 L83_84 L137_138 0.078
K14009 L83_84 L179_180 0.028
K14010 L83_84 L12_13 0.0294
K14011 L83_84 L207_208 0.0611
K14012 L83_84 L142_143 0.0822
K14013 L83_84 L123_124 0.0448
K14014 L83_84 L152_153 0.1136
K14015 L83_84 L191_192 0.0595
K14016 L83_84 L39_40 0.0618
K14017 L83_84 L18_19 0.0303
K14018 L83_84 L130_156 0.0391
K14019 L83_84 L156_157 0.0384
K14020 L83_84 L189_190 0.0295
K14021 L83_84 L11_12 0.0299
K14022 L83_84 L54_55 0.0365
K14023 L83_84 L201_202 0.1743
K14024 L83_88 L140_145 0.0412
K14025 L83_88 L1_6 0.0377
K14026 L83_88 L13_18 0.0301
K14027 L83_88 L35_40 0.0457
K14028 L83_88 L23_28 0.0404
K14029 L83_88 L184_188 0.03
K14030 L83_88 L6_11 0.0395
K14031 L83_88 L163_168 0.0446
K14032 L83_88 L91_95 0.059
K14033 L83_88 L144_149 0.0537
K14034 L83_88 L130_160 0.0389
K14035 L83_88 L4_9 0.0271
K14036 L83_88 L181_185 0.0281
K14037 L83_88 L164_169 0.04
K14038 L83_88 L106_111 0.0312
K14039 L83_88 L34_39 0.0514
K14040 L83_88 L148_153 0.0593
K14041 L83_88 L201_205 0.1104
K14042 L83_88 L9_14 0.0282
K14043 L83_88 L200_204 0.0734
K14044 L83_88 L150_155 0.0418
K14045 L83_88 L145_150 0.0417
K14046 L83_88 L30_35 0.0402
K14047 L83_88 L131_136 0.0977
K14048 L83_88 L101_105 0.0423
K14049 L83_88 L46_50 0.0313
K14050 L83_88 L196_200 0.0726
K14051 L83_88 L92_96 0.0537
K14052 L83_88 L81_86 0.0744
K14053 L83_88 L19_24 0.0306
K14054 L83_88 L120_125 0.0413
K14055 L83_88 L8_13 0.0288
K14056 L83_88 L60_64 0.0489
K14057 L83_88 L193_197 0.1034
K14058 L83_88 L7_12 0.0295
K14059 L83_88 L137_142 0.0643
K14060 L83_88 L167_172 0.0536
K14061 L83_88 L121_126 0.0349
K14062 L83_88 L195_199 0.0549
K14063 L83_88 L97_101 0.0421
K14064 L83_88 L110_115 0.0376
K14065 L83_88 L113_118 0.0443
K14066 L83_88 L134_139 0.052
K14067 L83_88 L141_146 0.1053
K14068 L83_88 L100_104 0.0546
K14069 L83_88 L138_143 0.0581
K14070 L83_88 L33_38 0.054
K14071 L83_88 L18_23 0.0315
K14072 L83_88 L107_112 0.0389
K14073 L83_88 L112_117 0.0404
K14074 L83_88 L40_45 0.0516
K14075 L83_88 L183_187 0.0308
K14076 L83_88 L59_63 0.0439
K14077 L83_88 L5_10 0.022
K14078 L83_88 L15_20 0.0238
K14079 L83_88 L51_55 0.0405
K14080 L83_88 L58_62 0.035
K14081 L83_88 L67_71 0.072
K14082 L83_88 L29_34 0.0448
K14083 L83_88 L179_183 0.0294
K14084 L83_88 L41_74 0.1002
K14085 L83_88 L131_170 0.0646
K14086 L83_88 L205_209 0.1114
K14087 L83_88 L191_195 0.0541
K14088 L83_88 L66_70 0.0545
K14089 L83_88 L98_102 0.0671
K14090 L83_88 L27_32 0.0483
K14091 L83_88 L142_147 0.0655
K14092 L83_88 L147_152 0.0659
K14093 L83_88 L178_182 0.022
K14094 L83_88 L180_184 0.0288
K14095 L83_88 L3_8 0.0277
K14096 L83_88 L157_162 0.0403
K14097 L83_88 L149_154 0.054
K14098 L83_88 L203_207 0.0555
K14099 L83_88 L2_7 0.0282
K14100 L83_88 L117_122 0.042
K14101 L83_88 L22_27 0.0415
K14102 L83_88 L158_189 0.0305
K14103 L83_88 L38_43 0.0627
K14104 L83_88 L135_174 0.0512
K14105 L83_88 L160_165 0.0455
K14106 L83_88 L52_56 0.0444
K14107 L83_88 L115_120 0.0394
K14108 L83_88 L80_85 0.056
K14109 L83_88 L10_15 0.0229
K14110 L83_88 L16_21 0.0437
K14111 L83_88 L158_163 0.0391
K14112 L83_88 L185_189 0.0292
K14113 L83_88 L96_100 0.0544
K14114 L83_88 L165_170 0.054
K14115 L83_88 L186_190 0.0237
K14116 L83_88 L82_87 0.1145
K14117 L83_88 L125_130 0.0435
K14118 L83_88 L108_113 0.0423
K14119 L83_88 L159_164 0.0354
K14120 L83_88 L84_89 0.1098
K14121 L83_88 L204_208 0.0736
K14122 L83_88 L25_30 0.0355
K14123 L83_88 L14_19 0.0293
K14124 L83_88 L44_92 0.0526
K14125 L83_88 L21_26 0.0391
K14126 L83_88 L74_79 0.1051
K14127 L83_88 L199_203 0.0554
K14128 L83_88 L75_80 0.0558
K14129 L83_88 L70_75 0.0553
K14130 L83_88 L50_54 0.0325
K14131 L83_88 L79_84 0.1086
K14132 L83_88 L56_60 0.0466
K14133 L83_88 L93_97 0.0417
K14134 L83_88 L90_94 0.0654
K14135 L83_88 L134_173 0.0582
K14136 L83_88 L139_144 0.0531
K14137 L83_88 L177_181 0.027
K14138 L83_88 L111_116 0.0324
K14139 L83_88 L162_167 0.0463
K14140 L83_88 L43_91 0.0575
K14141 L83_88 L122_127 0.0437
K14142 L83_88 L135_140 0.0405
K14143 L83_88 L39_44 0.0587
K14144 L83_88 L123_128 0.0487
K14145 L83_88 L12_17 0.0309
K14146 L83_88 L54_58 0.0337
K14147 L83_88 L146_151 0.1064
K14148 L83_88 L143_148 0.059
K14149 L83_88 L11_16 0.0415
K14150 L83_88 L77_82 0.1134
K14151 L42_43 L167_168 0.0767
K14152 L42_43 L74_90 0.1375
K14153 L42_43 L199_200 0.0359
K14154 L42_43 L115_179 0.0313
K14155 L42_43 L128_129 0.0441
K14156 L42_43 L196_197 0.0458
K14157 L42_43 L1_2 0.0257
K14158 L42_43 L23_24 0.0457
K14159 L42_43 L158_159 0.0449
K14160 L42_43 L136_198 0.0916
K14161 L42_43 L163_164 0.0564
K14162 L42_43 L144_145 0.0947
K14163 L42_43 L91_92 0.1375
K14164 L42_43 L160_161 0.057
K14165 L42_43 L126_127 0.0322
K14166 L42_43 L22_23 0.0458
K14167 L42_43 L153_154 0.0622
K14168 L42_43 L4_5 0.0255
K14169 L42_43 L34_35 0.0766
K14170 L42_43 L197_198 0.0616
K14171 L42_43 L204_205 0.044
K14172 L42_43 L143_144 0.1006
K14173 L42_43 L200_201 0.045
K14174 L42_43 L205_206 0.0575
K14175 L42_43 L36_37 0.122
K14176 L42_43 L141_142 0.1006
K14177 L42_43 L100_101 0.0842
K14178 L42_43 L203_204 0.0354
K14179 L42_43 L92_93 0.1231
K14180 L42_43 L81_82 0.0443
K14181 L42_43 L13_14 0.0337
K14182 L42_43 L185_186 0.0332
K14183 L42_43 L148_149 0.0844
K14184 L42_43 L19_20 0.0359
K14185 L42_43 L187_188 0.036
K14186 L42_43 L165_166 0.0767
K14187 L42_43 L102_103 0.0652
K14188 L42_43 L106_107 0.0288
K14189 L42_43 L64_65 0.0444
K14190 L42_43 L8_9 0.0315
K14191 L42_43 L170_171 0.116
K14192 L42_43 L21_65 0.05
K14193 L42_43 L121_122 0.0332
K14194 L42_43 L9_10 0.0313
K14195 L42_43 L195_196 0.0363
K14196 L42_43 L171_172 0.118
K14197 L42_43 L104_105 0.0621
K14198 L42_43 L151_210 0.0699
K14199 L42_43 L37_38 0.1244
K14200 L42_43 L112_113 0.0353
K14201 L42_43 L183_184 0.0335
K14202 L42_43 L59_60 0.0386
K14203 L42_43 L11_57 0.0458
K14204 L42_43 L38_39 0.122
K14205 L42_43 L27_28 0.0579
K14206 L42_43 L96_97 0.1004
K14207 L42_43 L78_79 0.0876
K14208 L42_43 L138_139 0.1234
K14209 L42_43 L47_48 0.0327
K14210 L42_43 L29_30 0.057
K14211 L42_43 L76_77 0.0453
K14212 L42_43 L166_167 0.0772
K14213 L42_43 L16_17 0.0362
K14214 L42_43 L118_119 0.0417
K14215 L42_43 L176_177 0.0255
K14216 L42_43 L6_53 0.043
K14217 L42_43 L149_150 0.0808
K14218 L42_43 L2_3 0.0257
K14219 L42_43 L98_99 0.0898
K14220 L42_43 L184_185 0.0335
K14221 L42_43 L84_98 0.0883
K14222 L42_43 L48_49 0.0366
K14223 L42_43 L124_125 0.0487
K14224 L42_43 L113_114 0.0395
K14225 L42_43 L52_53 0.0397
K14226 L42_43 L80_81 0.0356
K14227 L42_43 L141_202 0.0855
K14228 L42_43 L87_88 0.0525
K14229 L42_43 L146_147 0.0844
K14230 L42_43 L127_128 0.0378
K14231 L42_43 L181_182 0.0311
K14232 L42_43 L28_29 0.0577
K14233 L42_43 L157_158 0.0453
K14234 L42_43 L122_123 0.0385
K14235 L42_43 L129_130 0.0496
K14236 L42_43 L21_22 0.0457
K14237 L42_43 L117_118 0.0369
K14238 L42_43 L51_52 0.0355
K14239 L42_43 L56_57 0.0419
K14240 L42_43 L116_117 0.0322
K14241 L42_43 L154_155 0.06
K14242 L42_43 L7_8 0.0316
K14243 L42_43 L82_83 0.0581
K14244 L42_43 L14_15 0.0334
K14245 L42_43 L125_187 0.0359
K14246 L42_43 L58_59 0.0333
K14247 L42_43 L70_71 0.0365
K14248 L42_43 L136_137 0.1234
K14249 L42_43 L180_181 0.0313
K14250 L42_43 L89_102 0.0644
K14251 L42_43 L26_27 0.0577
K14252 L42_43 L50_51 0.0312
K14253 L42_43 L90_91 0.1436
K14254 L42_43 L139_140 0.1128
K14255 L42_43 L161_162 0.0572
K14256 L42_43 L111_112 0.0312
K14257 L42_43 L162_163 0.057
K14258 L42_43 L137_138 0.1276
K14259 L42_43 L179_180 0.0314
K14260 L42_43 L12_13 0.0338
K14261 L42_43 L207_208 0.0326
K14262 L42_43 L142_143 0.1029
K14263 L42_43 L123_124 0.0441
K14264 L42_43 L152_153 0.0629
K14265 L42_43 L39_40 0.1157
K14266 L42_43 L18_19 0.0362
K14267 L42_43 L130_156 0.0453
K14268 L42_43 L156_157 0.0454
K14269 L42_43 L189_190 0.0356
K14270 L42_43 L11_12 0.0337
K14271 L42_43 L54_55 0.0323
K14272 L42_43 L201_202 0.0597
K14273 L207_208 L167_168 0.0305
K14274 L207_208 L74_90 0.0294
K14275 L207_208 L115_179 0.0199
K14276 L207_208 L196_197 0.1369
K14277 L207_208 L1_2 0.0164
K14278 L207_208 L23_24 0.0245
K14279 L207_208 L158_159 0.0238
K14280 L207_208 L136_198 0.0594
K14281 L207_208 L163_164 0.0275
K14282 L207_208 L144_145 0.0255
K14283 L207_208 L91_92 0.0265
K14284 L207_208 L160_161 0.0302
K14285 L207_208 L126_127 0.0414
K14286 L207_208 L22_23 0.0252
K14287 L207_208 L204_205 0.1877
K14288 L207_208 L4_5 0.0152
K14289 L207_208 L34_35 0.0294
K14290 L207_208 L41_42 0.0343
K14291 L207_208 L197_198 0.0854
K14292 L207_208 L143_144 0.0268
K14293 L207_208 L200_201 0.1593
K14294 L207_208 L205_206 0.0934
K14295 L207_208 L36_37 0.0354
K14296 L207_208 L131_132 0.0344
K14297 L207_208 L100_101 0.0255
K14298 L207_208 L203_204 0.3407
K14299 L207_208 L92_93 0.0252
K14300 L207_208 L81_82 0.1674
K14301 L207_208 L13_14 0.0194
K14302 L207_208 L148_149 0.0269
K14303 L207_208 L19_20 0.0194
K14304 L207_208 L187_188 0.0205
K14305 L207_208 L165_166 0.0329
K14306 L207_208 L128_129 0.0373
K14307 L207_208 L106_107 0.0342
K14308 L207_208 L8_9 0.0189
K14309 L207_208 L170_171 0.0355
K14310 L207_208 L193_194 0.0785
K14311 L207_208 L21_65 0.0335
K14312 L207_208 L121_122 0.0413
K14313 L207_208 L9_10 0.0184
K14314 L207_208 L195_196 0.1829
K14315 L207_208 L134_135 0.0298
K14316 L207_208 L41_69 0.0545
K14317 L207_208 L171_172 0.034
K14318 L207_208 L180_181 0.0189
K14319 L207_208 L37_38 0.0339
K14320 L207_208 L112_113 0.0364
K14321 L207_208 L183_184 0.02
K14322 L207_208 L59_60 0.0401
K14323 L207_208 L11_57 0.033
K14324 L207_208 L38_39 0.0325
K14325 L207_208 L27_28 0.0292
K14326 L207_208 L78_79 0.0602
K14327 L207_208 L44_45 0.0297
K14328 L207_208 L47_48 0.0334
K14329 L207_208 L29_30 0.0274
K14330 L207_208 L76_77 0.1479
K14331 L207_208 L166_167 0.0317
K14332 L207_208 L185_186 0.0189
K14333 L207_208 L16_17 0.021
K14334 L207_208 L181_182 0.0185
K14335 L207_208 L118_119 0.036
K14336 L207_208 L176_177 0.0156
K14337 L207_208 L6_53 0.0317
K14338 L207_208 L149_150 0.0256
K14339 L207_208 L2_3 0.016
K14340 L207_208 L98_99 0.0283
K14341 L207_208 L84_98 0.0299
K14342 L207_208 L48_49 0.0317
K14343 L207_208 L124_125 0.0343
K14344 L207_208 L113_114 0.0345
K14345 L207_208 L52_53 0.0344
K14346 L207_208 L80_81 0.2623
K14347 L207_208 L141_202 0.0608
K14348 L207_208 L146_147 0.03
K14349 L207_208 L136_137 0.0295
K14350 L207_208 L127_128 0.0403
K14351 L207_208 L138_139 0.0266
K14352 L207_208 L28_29 0.0283
K14353 L207_208 L157_158 0.0245
K14354 L207_208 L122_123 0.0403
K14355 L207_208 L96_97 0.0254
K14356 L207_208 L129_130 0.0336
K14357 L207_208 L64_65 0.0372
K14358 L207_208 L117_118 0.0383
K14359 L207_208 L51_52 0.0363
K14360 L207_208 L56_57 0.0359
K14361 L207_208 L116_117 0.0391
K14362 L207_208 L21_22 0.0259
K14363 L207_208 L7_8 0.0194
K14364 L207_208 L82_83 0.0911
K14365 L207_208 L14_15 0.0189
K14366 L207_208 L184_185 0.0194
K14367 L207_208 L141_142 0.0298
K14368 L207_208 L199_200 0.2387
K14369 L207_208 L125_187 0.0211
K14370 L207_208 L58_59 0.0411
K14371 L207_208 L70_71 0.1684
K14372 L207_208 L68_69 0.077
K14373 L207_208 L26_27 0.0301
K14374 L207_208 L50_51 0.037
K14375 L207_208 L90_91 0.0278
K14376 L207_208 L139_140 0.0253
K14377 L207_208 L161_162 0.0293
K14378 L207_208 L111_112 0.0371
K14379 L207_208 L162_163 0.0284
K14380 L207_208 L137_138 0.0279
K14381 L207_208 L179_180 0.0194
K14382 L207_208 L12_13 0.0199
K14383 L207_208 L142_143 0.0282
K14384 L207_208 L123_124 0.0377
K14385 L207_208 L191_192 0.1605
K14386 L207_208 L39_40 0.0313
K14387 L207_208 L18_19 0.0199
K14388 L207_208 L130_156 0.026
K14389 L207_208 L156_157 0.0252
K14390 L207_208 L189_190 0.0194
K14391 L207_208 L11_12 0.0205
K14392 L207_208 L54_55 0.039
K14393 L207_208 L201_202 0.0898
K14394 L152_153 L167_168 0.0354
K14395 L152_153 L74_90 0.0789
K14396 L152_153 L115_179 0.0169
K14397 L152_153 L196_197 0.0389
K14398 L152_153 L1_2 0.0138
K14399 L152_153 L23_24 0.0233
K14400 L152_153 L158_159 0.0233
K14401 L152_153 L136_198 0.092
K14402 L152_153 L163_164 0.0285
K14403 L152_153 L144_145 0.0985
K14404 L152_153 L91_92 0.0789
K14405 L152_153 L160_161 0.0286
K14406 L152_153 L126_127 0.0192
K14407 L152_153 L22_23 0.0234
K14408 L152_153 L204_205 0.0405
K14409 L152_153 L4_5 0.0137
K14410 L152_153 L34_35 0.0348
K14411 L152_153 L41_42 0.0622
K14412 L152_153 L197_198 0.0565
K14413 L152_153 L143_144 0.1144
K14414 L152_153 L200_201 0.0399
K14415 L152_153 L205_206 0.062
K14416 L152_153 L36_37 0.0456
K14417 L152_153 L131_132 0.0644
K14418 L152_153 L100_101 0.1062
K14419 L152_153 L203_204 0.0301
K14420 L152_153 L92_93 0.073
K14421 L152_153 L81_82 0.0401
K14422 L152_153 L13_14 0.0177
K14423 L152_153 L148_149 0.1673
K14424 L152_153 L19_20 0.0186
K14425 L152_153 L187_188 0.0188
K14426 L152_153 L165_166 0.0354
K14427 L152_153 L128_129 0.024
K14428 L152_153 L106_107 0.0172
K14429 L152_153 L8_9 0.0168
K14430 L152_153 L170_171 0.0463
K14431 L152_153 L193_194 0.0519
K14432 L152_153 L21_65 0.0256
K14433 L152_153 L121_122 0.0198
K14434 L152_153 L9_10 0.0167
K14435 L152_153 L195_196 0.0294
K14436 L152_153 L134_135 0.0621
K14437 L152_153 L41_69 0.0783
K14438 L152_153 L171_172 0.0466
K14439 L152_153 L180_181 0.0169
K14440 L152_153 L37_38 0.0459
K14441 L152_153 L112_113 0.0204
K14442 L152_153 L183_184 0.0178
K14443 L152_153 L59_60 0.022
K14444 L152_153 L11_57 0.0244
K14445 L152_153 L38_39 0.0456
K14446 L152_153 L27_28 0.0285
K14447 L152_153 L78_79 0.0998
K14448 L152_153 L44_45 0.06
K14449 L152_153 L47_48 0.0188
K14450 L152_153 L29_30 0.0283
K14451 L152_153 L76_77 0.0394
K14452 L152_153 L166_167 0.0355
K14453 L152_153 L185_186 0.0177
K14454 L152_153 L16_17 0.0187
K14455 L152_153 L181_182 0.0168
K14456 L152_153 L118_119 0.0231
K14457 L152_153 L176_177 0.0138
K14458 L152_153 L6_53 0.0232
K14459 L152_153 L149_150 0.1268
K14460 L152_153 L2_3 0.0138
K14461 L152_153 L98_99 0.1363
K14462 L152_153 L84_98 0.1266
K14463 L152_153 L48_49 0.0203
K14464 L152_153 L124_125 0.0258
K14465 L152_153 L113_114 0.0221
K14466 L152_153 L52_53 0.022
K14467 L152_153 L80_81 0.0299
K14468 L152_153 L141_202 0.108
K14469 L152_153 L146_147 0.1673
K14470 L152_153 L136_137 0.0861
K14471 L152_153 L127_128 0.0216
K14472 L152_153 L138_139 0.0861
K14473 L152_153 L28_29 0.0285
K14474 L152_153 L157_158 0.0235
K14475 L152_153 L122_123 0.0221
K14476 L152_153 L96_97 0.088
K14477 L152_153 L129_130 0.0258
K14478 L152_153 L64_65 0.0239
K14479 L152_153 L117_118 0.0212
K14480 L152_153 L51_52 0.0204
K14481 L152_153 L56_57 0.023
K14482 L152_153 L116_117 0.0192
K14483 L152_153 L21_22 0.0233
K14484 L152_153 L7_8 0.0168
K14485 L152_153 L82_83 0.0604
K14486 L152_153 L14_15 0.0176
K14487 L152_153 L184_185 0.0178
K14488 L152_153 L141_142 0.1144
K14489 L152_153 L199_200 0.0298
K14490 L152_153 L125_187 0.0188
K14491 L152_153 L58_59 0.0198
K14492 L152_153 L70_71 0.0293
K14493 L152_153 L68_69 0.0508
K14494 L152_153 L26_27 0.0285
K14495 L152_153 L50_51 0.0186
K14496 L152_153 L90_91 0.0811
K14497 L152_153 L139_140 0.0787
K14498 L152_153 L161_162 0.0287
K14499 L152_153 L111_112 0.0186
K14500 L152_153 L162_163 0.0286
K14501 L152_153 L137_138 0.0891
K14502 L152_153 L179_180 0.0169
K14503 L152_153 L12_13 0.0177
K14504 L152_153 L142_143 0.1216
K14505 L152_153 L123_124 0.0242
K14506 L152_153 L191_192 0.0273
K14507 L152_153 L39_40 0.0449
K14508 L152_153 L18_19 0.0187
K14509 L152_153 L130_156 0.0235
K14510 L152_153 L156_157 0.0235
K14511 L152_153 L189_190 0.0187
K14512 L152_153 L11_12 0.0177
K14513 L152_153 L54_55 0.0192
K14514 L152_153 L201_202 0.0595
K14515 L130_156 L167_168 0.0864
K14516 L130_156 L74_90 0.0335
K14517 L130_156 L115_179 0.1104
K14518 L130_156 L196_197 0.0346
K14519 L130_156 L1_2 0.081
K14520 L130_156 L102_103 0.0233
K14521 L130_156 L136_198 0.0441
K14522 L130_156 L163_164 0.1245
K14523 L130_156 L144_145 0.031
K14524 L130_156 L91_92 0.0332
K14525 L130_156 L160_161 0.1549
K14526 L130_156 L146_147 0.0297
K14527 L130_156 L204_205 0.0321
K14528 L130_156 L153_154 0.0233
K14529 L130_156 L4_5 0.0694
K14530 L130_156 L34_35 0.081
K14531 L130_156 L41_42 0.0454
K14532 L130_156 L197_198 0.0395
K14533 L130_156 L143_144 0.0313
K14534 L130_156 L200_201 0.0333
K14535 L130_156 L205_206 0.0359
K14536 L130_156 L36_37 0.0627
K14537 L130_156 L131_132 0.0458
K14538 L130_156 L100_101 0.029
K14539 L130_156 L203_204 0.0285
K14540 L130_156 L92_93 0.0328
K14541 L130_156 L81_82 0.032
K14542 L130_156 L13_14 0.1128
K14543 L130_156 L148_149 0.0294
K14544 L130_156 L19_20 0.1153
K14545 L130_156 L187_188 0.1891
K14546 L130_156 L165_166 0.0897
K14547 L130_156 L106_107 0.042
K14548 L130_156 L8_9 0.0947
K14549 L130_156 L170_171 0.0635
K14550 L130_156 L193_194 0.0382
K14551 L130_156 L141_142 0.0316
K14552 L130_156 L121_122 0.0468
K14553 L130_156 L195_196 0.0301
K14554 L130_156 L134_135 0.0446
K14555 L130_156 L41_69 0.0428
K14556 L130_156 L171_172 0.0632
K14557 L130_156 L104_105 0.023
K14558 L130_156 L151_210 0.0352
K14559 L130_156 L37_38 0.0624
K14560 L130_156 L112_113 0.0604
K14561 L130_156 L183_184 0.1375
K14562 L130_156 L59_60 0.0632
K14563 L130_156 L11_57 0.1485
K14564 L130_156 L38_39 0.0615
K14565 L130_156 L27_28 0.1389
K14566 L130_156 L96_97 0.0308
K14567 L130_156 L78_79 0.0414
K14568 L130_156 L44_45 0.0442
K14569 L130_156 L47_48 0.0552
K14570 L130_156 L29_30 0.1183
K14571 L130_156 L76_77 0.0332
K14572 L130_156 L166_167 0.0888
K14573 L130_156 L185_186 0.1069
K14574 L130_156 L16_17 0.1644
K14575 L130_156 L118_119 0.0942
K14576 L130_156 L176_177 0.0792
K14577 L130_156 L6_53 0.1262
K14578 L130_156 L149_150 0.0292
K14579 L130_156 L2_3 0.0794
K14580 L130_156 L98_99 0.0294
K14581 L130_156 L184_185 0.1231
K14582 L130_156 L84_98 0.0295
K14583 L130_156 L48_49 0.0783
K14584 L130_156 L124_125 0.2011
K14585 L130_156 L113_114 0.0876
K14586 L130_156 L52_53 0.0855
K14587 L130_156 L80_81 0.0284
K14588 L130_156 L141_202 0.0416
K14589 L130_156 L87_88 0.0323
K14590 L130_156 L136_137 0.0338
K14591 L130_156 L138_139 0.0334
K14592 L130_156 L181_182 0.091
K14593 L130_156 L28_29 0.1299
K14594 L130_156 L122_123 0.064
K14595 L130_156 L9_10 0.0868
K14596 L130_156 L117_118 0.0624
K14597 L130_156 L51_52 0.0597
K14598 L130_156 L56_57 0.0916
K14599 L130_156 L116_117 0.0461
K14600 L130_156 L154_155 0.0231
K14601 L130_156 L7_8 0.1006
K14602 L130_156 L82_83 0.0358
K14603 L130_156 L14_15 0.1001
K14604 L130_156 L199_200 0.0293
K14605 L130_156 L125_187 0.2069
K14606 L130_156 L58_59 0.0464
K14607 L130_156 L70_71 0.0301
K14608 L130_156 L68_69 0.038
K14609 L130_156 L180_181 0.1004
K14610 L130_156 L89_102 0.0234
K14611 L130_156 L26_27 0.1425
K14612 L130_156 L50_51 0.045
K14613 L130_156 L90_91 0.0335
K14614 L130_156 L139_140 0.0331
K14615 L130_156 L161_162 0.1502
K14616 L130_156 L111_112 0.0453
K14617 L130_156 L162_163 0.1386
K14618 L130_156 L137_138 0.0337
K14619 L130_156 L179_180 0.1076
K14620 L130_156 L12_13 0.1234
K14621 L130_156 L142_143 0.0315
K14622 L130_156 L123_124 0.1004
K14623 L130_156 L191_192 0.0287
K14624 L130_156 L39_40 0.0602
K14625 L130_156 L18_19 0.136
K14626 L130_156 L189_190 0.1261
K14627 L130_156 L11_12 0.1276
K14628 L130_156 L54_55 0.0458
K14629 L130_156 L201_202 0.0377
K14630 L189_190 L167_168 0.0683
K14631 L189_190 L74_90 0.0262
K14632 L189_190 L199_200 0.0217
K14633 L189_190 L115_179 0.0953
K14634 L189_190 L128_129 0.042
K14635 L189_190 L196_197 0.0253
K14636 L189_190 L1_2 0.0706
K14637 L189_190 L23_24 0.1556
K14638 L189_190 L158_159 0.2069
K14639 L189_190 L136_198 0.0327
K14640 L189_190 L163_164 0.1123
K14641 L189_190 L144_145 0.0252
K14642 L189_190 L91_92 0.0266
K14643 L189_190 L160_161 0.0947
K14644 L189_190 L126_127 0.0256
K14645 L189_190 L22_23 0.136
K14646 L189_190 L204_205 0.0238
K14647 L189_190 L153_154 0.0188
K14648 L189_190 L4_5 0.0911
K14649 L189_190 L34_35 0.0673
K14650 L189_190 L41_42 0.0351
K14651 L189_190 L197_198 0.0289
K14652 L189_190 L143_144 0.0251
K14653 L189_190 L200_201 0.0245
K14654 L189_190 L205_206 0.0267
K14655 L189_190 L36_37 0.0475
K14656 L189_190 L131_132 0.0354
K14657 L189_190 L100_101 0.0236
K14658 L189_190 L203_204 0.0212
K14659 L189_190 L92_93 0.0267
K14660 L189_190 L81_82 0.0238
K14661 L189_190 L13_14 0.1438
K14662 L189_190 L148_149 0.0237
K14663 L189_190 L165_166 0.0642
K14664 L189_190 L102_103 0.0186
K14665 L189_190 L106_107 0.0296
K14666 L189_190 L64_65 0.0416
K14667 L189_190 L26_27 0.0907
K14668 L189_190 L170_171 0.048
K14669 L189_190 L193_194 0.0277
K14670 L189_190 L21_65 0.0604
K14671 L189_190 L9_10 0.1173
K14672 L189_190 L195_196 0.0222
K14673 L189_190 L134_135 0.0363
K14674 L189_190 L41_69 0.0315
K14675 L189_190 L171_172 0.049
K14676 L189_190 L104_105 0.0187
K14677 L189_190 L151_210 0.0267
K14678 L189_190 L37_38 0.0484
K14679 L189_190 L112_113 0.041
K14680 L189_190 L183_184 0.1439
K14681 L189_190 L11_57 0.095
K14682 L189_190 L38_39 0.049
K14683 L189_190 L27_28 0.098
K14684 L189_190 L78_79 0.031
K14685 L189_190 L44_45 0.036
K14686 L189_190 L47_48 0.0378
K14687 L189_190 L29_30 0.1055
K14688 L189_190 L76_77 0.0245
K14689 L189_190 L166_167 0.0667
K14690 L189_190 L185_186 0.2054
K14691 L189_190 L191_192 0.0211
K14692 L189_190 L118_119 0.0589
K14693 L189_190 L176_177 0.0983
K14694 L189_190 L6_53 0.0885
K14695 L189_190 L149_150 0.0237
K14696 L189_190 L2_3 0.0801
K14697 L189_190 L98_99 0.0234
K14698 L189_190 L84_98 0.0232
K14699 L189_190 L48_49 0.0522
K14700 L189_190 L113_114 0.0573
K14701 L189_190 L52_53 0.0564
K14702 L189_190 L80_81 0.0211
K14703 L189_190 L141_202 0.0311
K14704 L189_190 L87_88 0.0241
K14705 L189_190 L146_147 0.0233
K14706 L189_190 L136_137 0.0263
K14707 L189_190 L127_128 0.0318
K14708 L189_190 L138_139 0.0268
K14709 L189_190 L181_182 0.1354
K14710 L189_190 L28_29 0.1035
K14711 L189_190 L157_158 0.1891
K14712 L189_190 L96_97 0.025
K14713 L189_190 L129_130 0.0616
K14714 L189_190 L21_22 0.1153
K14715 L189_190 L117_118 0.0416
K14716 L189_190 L51_52 0.0407
K14717 L189_190 L56_57 0.0579
K14718 L189_190 L116_117 0.0321
K14719 L189_190 L154_155 0.0188
K14720 L189_190 L7_8 0.1015
K14721 L189_190 L82_83 0.0266
K14722 L189_190 L14_15 0.1536
K14723 L189_190 L184_185 0.1832
K14724 L189_190 L141_142 0.0247
K14725 L189_190 L70_71 0.0222
K14726 L189_190 L68_69 0.0276
K14727 L189_190 L180_181 0.1284
K14728 L189_190 L89_102 0.0185
K14729 L189_190 L8_9 0.1127
K14730 L189_190 L50_51 0.0317
K14731 L189_190 L90_91 0.0265
K14732 L189_190 L139_140 0.0269
K14733 L189_190 L161_162 0.1032
K14734 L189_190 L111_112 0.0319
K14735 L189_190 L162_163 0.1098
K14736 L189_190 L137_138 0.0266
K14737 L189_190 L179_180 0.1124
K14738 L189_190 L12_13 0.1226
K14739 L189_190 L142_143 0.025
K14740 L189_190 L39_40 0.0492
K14741 L189_190 L156_157 0.1555
K14742 L189_190 L11_12 0.1015
K14743 L189_190 L54_55 0.032
K14744 L189_190 L201_202 0.0278
K14745 L11_12 L167_168 0.0585
K14746 L11_12 L74_90 0.0252
K14747 L11_12 L199_200 0.0231
K14748 L11_12 L115_179 0.1536
K14749 L11_12 L128_129 0.053
K14750 L11_12 L196_197 0.0269
K14751 L11_12 L1_2 0.1487
K14752 L11_12 L23_24 0.1231
K14753 L11_12 L158_159 0.1001
K14754 L11_12 L136_198 0.0331
K14755 L11_12 L163_164 0.0795
K14756 L11_12 L144_145 0.0232
K14757 L11_12 L91_92 0.025
K14758 L11_12 L160_161 0.0888
K14759 L11_12 L126_127 0.0297
K14760 L11_12 L22_23 0.1375
K14761 L11_12 L204_205 0.025
K14762 L11_12 L153_154 0.0176
K14763 L11_12 L4_5 0.0895
K14764 L11_12 L34_35 0.0578
K14765 L11_12 L41_42 0.0338
K14766 L11_12 L197_198 0.0302
K14767 L11_12 L143_144 0.0234
K14768 L11_12 L200_201 0.0259
K14769 L11_12 L205_206 0.0276
K14770 L11_12 L36_37 0.0456
K14771 L11_12 L131_132 0.0335
K14772 L11_12 L100_101 0.0221
K14773 L11_12 L203_204 0.0224
K14774 L11_12 L92_93 0.0247
K14775 L11_12 L81_82 0.0251
K14776 L11_12 L148_149 0.0221
K14777 L11_12 L19_20 0.1124
K14778 L11_12 L187_188 0.1438
K14779 L11_12 L165_166 0.0599
K14780 L11_12 L102_103 0.0178
K14781 L11_12 L106_107 0.0358
K14782 L11_12 L64_65 0.0538
K14783 L11_12 L26_27 0.0927
K14784 L11_12 L170_171 0.0451
K14785 L11_12 L193_194 0.0291
K14786 L11_12 L21_65 0.0877
K14787 L11_12 L121_122 0.032
K14788 L11_12 L9_10 0.1124
K14789 L11_12 L195_196 0.0237
K14790 L11_12 L134_135 0.0328
K14791 L11_12 L41_69 0.0324
K14792 L11_12 L171_172 0.045
K14793 L11_12 L104_105 0.0176
K14794 L11_12 L151_210 0.0268
K14795 L11_12 L138_139 0.0248
K14796 L11_12 L37_38 0.0454
K14797 L11_12 L112_113 0.0527
K14798 L11_12 L59_60 0.0416
K14799 L11_12 L129_130 0.0842
K14800 L11_12 L38_39 0.045
K14801 L11_12 L27_28 0.0913
K14802 L11_12 L96_97 0.0233
K14803 L11_12 L78_79 0.0315
K14804 L11_12 L44_45 0.0331
K14805 L11_12 L47_48 0.0495
K14806 L11_12 L29_30 0.0821
K14807 L11_12 L76_77 0.026
K14808 L11_12 L166_167 0.0596
K14809 L11_12 L16_17 0.2054
K14810 L11_12 L176_177 0.0969
K14811 L11_12 L149_150 0.022
K14812 L11_12 L2_3 0.1362
K14813 L11_12 L98_99 0.0223
K14814 L11_12 L6_53 0.1855
K14815 L11_12 L84_98 0.0224
K14816 L11_12 L48_49 0.0783
K14817 L11_12 L124_125 0.095
K14818 L11_12 L113_114 0.0822
K14819 L11_12 L52_53 0.0851
K14820 L11_12 L80_81 0.0225
K14821 L11_12 L141_202 0.0314
K14822 L11_12 L87_88 0.025
K14823 L11_12 L146_147 0.0223
K14824 L11_12 L136_137 0.025
K14825 L11_12 L127_128 0.0381
K14826 L11_12 L181_182 0.1015
K14827 L11_12 L28_29 0.0875
K14828 L11_12 L157_158 0.1128
K14829 L11_12 L122_123 0.0413
K14830 L11_12 L21_22 0.1436
K14831 L11_12 L51_52 0.0533
K14832 L11_12 L154_155 0.0175
K14833 L11_12 L7_8 0.1832
K14834 L11_12 L82_83 0.0277
K14835 L11_12 L58_59 0.0321
K14836 L11_12 L141_142 0.0236
K14837 L11_12 L125_187 0.1536
K14838 L11_12 L70_71 0.0238
K14839 L11_12 L68_69 0.0292
K14840 L11_12 L180_181 0.1226
K14841 L11_12 L89_102 0.0178
K14842 L11_12 L8_9 0.1439
K14843 L11_12 L50_51 0.0387
K14844 L11_12 L90_91 0.0251
K14845 L11_12 L139_140 0.0246
K14846 L11_12 L161_162 0.0876
K14847 L11_12 L111_112 0.0385
K14848 L11_12 L162_163 0.0843
K14849 L11_12 L137_138 0.025
K14850 L11_12 L179_180 0.1438
K14851 L11_12 L142_143 0.0235
K14852 L11_12 L123_124 0.0579
K14853 L11_12 L191_192 0.0226
K14854 L11_12 L39_40 0.0442
K14855 L11_12 L156_157 0.1234
K14856 L11_12 L18_19 0.1439
K14857 L11_12 L201_202 0.0288
K14858 L11_16 L181_185 0.0803
K14859 L11_16 L140_145 0.0259
K14860 L11_16 L13_18 0.1011
K14861 L11_16 L35_40 0.0542
K14862 L11_16 L23_28 0.1112
K14863 L11_16 L73_78 0.046
K14864 L11_16 L184_188 0.0958
K14865 L11_16 L163_168 0.0759
K14866 L11_16 L91_95 0.0327
K14867 L11_16 L144_149 0.0301
K14868 L11_16 L4_9 0.0802
K14869 L11_16 L202_206 0.0435
K14870 L11_16 L109_114 0.1022
K14871 L11_16 L57_61 0.1098
K14872 L11_16 L164_169 0.066
K14873 L11_16 L195_199 0.0285
K14874 L11_16 L158_189 0.0803
K14875 L11_16 L106_111 0.0385
K14876 L11_16 L34_39 0.0611
K14877 L11_16 L148_153 0.0291
K14878 L11_16 L201_205 0.0391
K14879 L11_16 L53_57 0.1086
K14880 L11_16 L69_73 0.0487
K14881 L11_16 L200_204 0.0347
K14882 L11_16 L150_155 0.0234
K14883 L11_16 L145_150 0.0246
K14884 L11_16 L30_35 0.0671
K14885 L11_16 L101_105 0.0234
K14886 L11_16 L46_50 0.0387
K14887 L11_16 L196_200 0.0358
K14888 L11_16 L92_96 0.032
K14889 L11_16 L81_86 0.0336
K14890 L11_16 L19_24 0.0833
K14891 L11_16 L8_13 0.0991
K14892 L11_16 L60_64 0.069
K14893 L11_16 L198_202 0.0458
K14894 L11_16 L193_197 0.0426
K14895 L11_16 L7_12 0.1224
K14896 L11_16 L137_142 0.0332
K14897 L11_16 L167_172 0.0635
K14898 L11_16 L121_126 0.0387
K14899 L11_16 L97_101 0.0247
K14900 L11_16 L113_118 0.0681
K14901 L11_16 L134_139 0.0337
K14902 L11_16 L100_104 0.0287
K14903 L11_16 L138_143 0.0326
K14904 L11_16 L33_38 0.0643
K14905 L11_16 L18_23 0.0991
K14906 L11_16 L124_129 0.1053
K14907 L11_16 L107_112 0.05
K14908 L11_16 L78_83 0.0437
K14909 L11_16 L112_117 0.0503
K14910 L11_16 L40_45 0.0445
K14911 L11_16 L183_187 0.1161
K14912 L11_16 L59_63 0.0506
K14913 L11_16 L5_10 0.0597
K14914 L11_16 L15_20 0.0622
K14915 L11_16 L51_55 0.0506
K14916 L11_16 L58_62 0.0389
K14917 L11_16 L67_71 0.0371
K14918 L11_16 L29_34 0.0774
K14919 L11_16 L179_183 0.1131
K14920 L11_16 L206_210 0.0413
K14921 L11_16 L205_209 0.0375
K14922 L11_16 L191_195 0.0294
K14923 L11_16 L66_70 0.0295
K14924 L11_16 L98_102 0.0297
K14925 L11_16 L27_32 0.0915
K14926 L11_16 L142_147 0.0313
K14927 L11_16 L147_152 0.0296
K14928 L11_16 L178_182 0.0581
K14929 L11_16 L180_184 0.0941
K14930 L11_16 L3_8 0.0939
K14931 L11_16 L157_162 0.1069
K14932 L11_16 L149_154 0.0286
K14933 L11_16 L203_207 0.0268
K14934 L11_16 L2_7 0.1129
K14935 L11_16 L117_122 0.0504
K14936 L11_16 L22_27 0.1298
K14937 L11_16 L38_43 0.0511
K14938 L11_16 L108_113 0.0673
K14939 L11_16 L135_174 0.0441
K14940 L11_16 L52_56 0.069
K14941 L11_16 L80_85 0.0269
K14942 L11_16 L10_15 0.0615
K14943 L11_16 L158_163 0.0939
K14944 L11_16 L185_189 0.0813
K14945 L11_16 L96_100 0.0303
K14946 L11_16 L49_53 0.1051
K14947 L11_16 L186_190 0.0604
K14948 L11_16 L82_87 0.0377
K14949 L11_16 L159_164 0.0792
K14950 L11_16 L9_14 0.0833
K14951 L11_16 L204_208 0.0336
K14952 L11_16 L25_30 0.0812
K14953 L11_16 L14_19 0.0844
K14954 L11_16 L44_92 0.0339
K14955 L11_16 L199_203 0.0276
K14956 L11_16 L75_80 0.0277
K14957 L11_16 L143_148 0.0307
K14958 L11_16 L70_75 0.0286
K14959 L11_16 L50_54 0.0389
K14960 L11_16 L56_60 0.0692
K14961 L11_16 L93_97 0.026
K14962 L11_16 L90_94 0.0334
K14963 L11_16 L134_173 0.0491
K14964 L11_16 L139_144 0.0319
K14965 L11_16 L177_181 0.0775
K14966 L11_16 L111_116 0.0387
K14967 L11_16 L162_167 0.0823
K14968 L11_16 L43_91 0.0348
K14969 L11_16 L122_127 0.0503
K14970 L11_16 L135_140 0.0274
K14971 L11_16 L39_44 0.0495
K14972 L11_16 L123_128 0.0681
K14973 L11_16 L54_58 0.039
K14974 L11_16 L61_65 0.1086
K14975 L11_16 L12_17 0.1262
K14976 L11_16 L77_82 0.0393
K14977 L143_144 L167_168 0.0498
K14978 L143_144 L74_90 0.1226
K14979 L143_144 L115_179 0.0222
K14980 L143_144 L128_129 0.0309
K14981 L143_144 L196_197 0.0449
K14982 L143_144 L1_2 0.0181
K14983 L143_144 L23_24 0.0314
K14984 L143_144 L158_159 0.0315
K14985 L143_144 L136_198 0.1196
K14986 L143_144 L163_164 0.0389
K14987 L143_144 L91_92 0.1536
K14988 L143_144 L160_161 0.0386
K14989 L143_144 L126_127 0.0238
K14990 L143_144 L22_23 0.0313
K14991 L143_144 L204_205 0.0363
K14992 L143_144 L153_154 0.1216
K14993 L143_144 L4_5 0.0182
K14994 L143_144 L34_35 0.049
K14995 L143_144 L41_42 0.0947
K14996 L143_144 L197_198 0.0656
K14997 L143_144 L191_192 0.0317
K14998 L143_144 L205_206 0.0488
K14999 L143_144 L36_37 0.0653
K15000 L143_144 L131_132 0.1004
K15001 L143_144 L100_101 0.1438
K15002 L143_144 L203_204 0.0289
K15003 L143_144 L92_93 0.1438
K15004 L143_144 L81_82 0.0361
K15005 L143_144 L13_14 0.0236
K15006 L143_144 L148_149 0.2054
K15007 L143_144 L19_20 0.025
K15008 L143_144 L187_188 0.0251
K15009 L143_144 L165_166 0.049
K15010 L143_144 L102_103 0.0988
K15011 L143_144 L106_107 0.0214
K15012 L143_144 L64_65 0.0307
K15013 L143_144 L8_9 0.0223
K15014 L143_144 L170_171 0.0667
K15015 L143_144 L193_194 0.0608
K15016 L143_144 L21_65 0.0338
K15017 L143_144 L121_122 0.0245
K15018 L143_144 L9_10 0.0222
K15019 L143_144 L195_196 0.0341
K15020 L143_144 L134_135 0.1076
K15021 L143_144 L41_69 0.1019
K15022 L143_144 L171_172 0.0683
K15023 L143_144 L104_105 0.0988
K15024 L143_144 L151_210 0.067
K15025 L143_144 L138_139 0.2054
K15026 L143_144 L37_38 0.0668
K15027 L143_144 L98_99 0.1438
K15028 L143_144 L112_113 0.0257
K15029 L143_144 L183_184 0.0237
K15030 L143_144 L59_60 0.0277
K15031 L143_144 L11_57 0.0319
K15032 L143_144 L38_39 0.0673
K15033 L143_144 L27_28 0.0386
K15034 L143_144 L44_45 0.1006
K15035 L143_144 L47_48 0.0237
K15036 L143_144 L29_30 0.0386
K15037 L143_144 L166_167 0.0496
K15038 L143_144 L185_186 0.0237
K15039 L143_144 L16_17 0.0248
K15040 L143_144 L118_119 0.0296
K15041 L143_144 L176_177 0.0183
K15042 L143_144 L6_53 0.0302
K15043 L143_144 L149_150 0.1832
K15044 L143_144 L2_3 0.0182
K15045 L143_144 L84_98 0.1226
K15046 L143_144 L48_49 0.026
K15047 L143_144 L124_125 0.0339
K15048 L143_144 L113_114 0.0283
K15049 L143_144 L52_53 0.0282
K15050 L143_144 L80_81 0.0287
K15051 L143_144 L87_88 0.0444
K15052 L143_144 L146_147 0.1439
K15053 L143_144 L136_137 0.1439
K15054 L143_144 L127_128 0.0272
K15055 L143_144 L181_182 0.0223
K15056 L143_144 L28_29 0.0387
K15057 L143_144 L157_158 0.0316
K15058 L143_144 L122_123 0.0278
K15059 L143_144 L161_162 0.0389
K15060 L143_144 L129_130 0.034
K15061 L143_144 L21_22 0.0311
K15062 L143_144 L117_118 0.0267
K15063 L143_144 L51_52 0.0257
K15064 L143_144 L56_57 0.0295
K15065 L143_144 L116_117 0.0238
K15066 L143_144 L154_155 0.1144
K15067 L143_144 L7_8 0.0222
K15068 L143_144 L82_83 0.0482
K15069 L143_144 L14_15 0.0235
K15070 L143_144 L184_185 0.0237
K15071 L143_144 L125_187 0.025
K15072 L143_144 L58_59 0.0245
K15073 L143_144 L70_71 0.0339
K15074 L143_144 L68_69 0.0596
K15075 L143_144 L180_181 0.0224
K15076 L143_144 L89_102 0.088
K15077 L143_144 L26_27 0.0383
K15078 L143_144 L50_51 0.023
K15079 L143_144 L90_91 0.1438
K15080 L143_144 L139_140 0.1832
K15081 L143_144 L111_112 0.0231
K15082 L143_144 L162_163 0.039
K15083 L143_144 L137_138 0.1832
K15084 L143_144 L179_180 0.0223
K15085 L143_144 L12_13 0.0235
K15086 L143_144 L123_124 0.0311
K15087 L143_144 L39_40 0.0668
K15088 L143_144 L18_19 0.025
K15089 L143_144 L156_157 0.0315
K15090 L143_144 L54_55 0.0238
K15091 L13_14 L167_168 0.0599
K15092 L13_14 L74_90 0.025
K15093 L13_14 L199_200 0.0218
K15094 L13_14 L115_179 0.1226
K15095 L13_14 L128_129 0.0444
K15096 L13_14 L196_197 0.0253
K15097 L13_14 L1_2 0.1116
K15098 L13_14 L23_24 0.1436
K15099 L13_14 L158_159 0.1234
K15100 L13_14 L136_198 0.0317
K15101 L13_14 L163_164 0.0876
K15102 L13_14 L144_145 0.0235
K15103 L13_14 L91_92 0.0252
K15104 L13_14 L160_161 0.0843
K15105 L13_14 L126_127 0.0267
K15106 L13_14 L22_23 0.1375
K15107 L13_14 L204_205 0.0237
K15108 L13_14 L153_154 0.0177
K15109 L13_14 L4_5 0.1362
K15110 L13_14 L34_35 0.0606
K15111 L13_14 L41_42 0.0334
K15112 L13_14 L197_198 0.0285
K15113 L13_14 L200_201 0.0245
K15114 L13_14 L205_206 0.0263
K15115 L13_14 L36_37 0.045
K15116 L13_14 L131_132 0.0332
K15117 L13_14 L100_101 0.0223
K15118 L13_14 L203_204 0.0212
K15119 L13_14 L92_93 0.0251
K15120 L13_14 L81_82 0.0237
K15121 L13_14 L148_149 0.0223
K15122 L13_14 L19_20 0.1832
K15123 L13_14 L187_188 0.1438
K15124 L13_14 L165_166 0.0585
K15125 L13_14 L102_103 0.0178
K15126 L13_14 L106_107 0.0315
K15127 L13_14 L64_65 0.0449
K15128 L13_14 L26_27 0.0875
K15129 L13_14 L170_171 0.0445
K15130 L13_14 L193_194 0.0274
K15131 L13_14 L21_65 0.067
K15132 L13_14 L121_122 0.0287
K15133 L13_14 L9_10 0.1832
K15134 L13_14 L195_196 0.0223
K15135 L13_14 L134_135 0.0335
K15136 L13_14 L41_69 0.0309
K15137 L13_14 L171_172 0.045
K15138 L13_14 L104_105 0.0178
K15139 L13_14 L151_210 0.0259
K15140 L13_14 L138_139 0.025
K15141 L13_14 L37_38 0.0454
K15142 L13_14 L112_113 0.0445
K15143 L13_14 L59_60 0.0363
K15144 L13_14 L129_130 0.0654
K15145 L13_14 L38_39 0.0456
K15146 L13_14 L27_28 0.0913
K15147 L13_14 L96_97 0.0237
K15148 L13_14 L78_79 0.0303
K15149 L13_14 L44_45 0.0337
K15150 L13_14 L47_48 0.0417
K15151 L13_14 L29_30 0.0913
K15152 L13_14 L76_77 0.0245
K15153 L13_14 L166_167 0.0596
K15154 L13_14 L16_17 0.1439
K15155 L13_14 L176_177 0.1183
K15156 L13_14 L149_150 0.0222
K15157 L13_14 L2_3 0.1362
K15158 L13_14 L98_99 0.0223
K15159 L13_14 L6_53 0.1196
K15160 L13_14 L84_98 0.0222
K15161 L13_14 L48_49 0.0608
K15162 L13_14 L124_125 0.0723
K15163 L13_14 L113_114 0.0643
K15164 L13_14 L52_53 0.0656
K15165 L13_14 L80_81 0.0213
K15166 L13_14 L141_202 0.0302
K15167 L13_14 L87_88 0.0239
K15168 L13_14 L146_147 0.0221
K15169 L13_14 L136_137 0.0248
K15170 L13_14 L127_128 0.0334
K15171 L13_14 L181_182 0.1438
K15172 L13_14 L28_29 0.0927
K15173 L13_14 L157_158 0.1276
K15174 L13_14 L122_123 0.0361
K15175 L13_14 L21_22 0.1231
K15176 L13_14 L51_52 0.0449
K15177 L13_14 L154_155 0.0177
K15178 L13_14 L7_8 0.1832
K15179 L13_14 L82_83 0.0264
K15180 L13_14 L58_59 0.0289
K15181 L13_14 L141_142 0.0234
K15182 L13_14 L125_187 0.1226
K15183 L13_14 L70_71 0.0224
K15184 L13_14 L68_69 0.0275
K15185 L13_14 L180_181 0.1536
K15186 L13_14 L89_102 0.0177
K15187 L13_14 L8_9 0.2054
K15188 L13_14 L50_51 0.0341
K15189 L13_14 L90_91 0.0251
K15190 L13_14 L139_140 0.025
K15191 L13_14 L161_162 0.0876
K15192 L13_14 L111_112 0.0339
K15193 L13_14 L162_163 0.0888
K15194 L13_14 L137_138 0.025
K15195 L13_14 L179_180 0.1438
K15196 L13_14 L142_143 0.0235
K15197 L13_14 L123_124 0.0482
K15198 L13_14 L191_192 0.0212
K15199 L13_14 L39_40 0.0454
K15200 L13_14 L156_157 0.1234
K15201 L13_14 L18_19 0.2054
K15202 L13_14 L201_202 0.0274
K15203 L128_129 L167_168 0.0658
K15204 L128_129 L74_90 0.0343
K15205 L128_129 L115_179 0.052
K15206 L128_129 L196_197 0.0512
K15207 L128_129 L1_2 0.0421
K15208 L128_129 L102_103 0.0239
K15209 L128_129 L136_198 0.0512
K15210 L128_129 L163_164 0.0702
K15211 L128_129 L144_145 0.03
K15212 L128_129 L91_92 0.0323
K15213 L128_129 L160_161 0.096
K15214 L128_129 L146_147 0.0308
K15215 L128_129 L204_205 0.0451
K15216 L128_129 L153_154 0.0234
K15217 L128_129 L4_5 0.0331
K15218 L128_129 L34_35 0.0606
K15219 L128_129 L41_42 0.0457
K15220 L128_129 L197_198 0.0532
K15221 L128_129 L200_201 0.0479
K15222 L128_129 L205_206 0.0465
K15223 L128_129 L36_37 0.0601
K15224 L128_129 L131_132 0.046
K15225 L128_129 L100_101 0.0284
K15226 L128_129 L203_204 0.0416
K15227 L128_129 L92_93 0.0313
K15228 L128_129 L81_82 0.0449
K15229 L128_129 L148_149 0.0294
K15230 L128_129 L19_20 0.0416
K15231 L128_129 L187_188 0.05
K15232 L128_129 L165_166 0.0763
K15233 L128_129 L106_107 0.0785
K15234 L128_129 L8_9 0.0434
K15235 L128_129 L170_171 0.0608
K15236 L128_129 L193_194 0.0524
K15237 L128_129 L141_142 0.0326
K15238 L128_129 L121_122 0.0934
K15239 L128_129 L195_196 0.0462
K15240 L128_129 L134_135 0.0412
K15241 L128_129 L41_69 0.0498
K15242 L128_129 L171_172 0.0579
K15243 L128_129 L104_105 0.0228
K15244 L128_129 L151_210 0.0403
K15245 L128_129 L37_38 0.0574
K15246 L128_129 L112_113 0.1369
K15247 L128_129 L183_184 0.0489
K15248 L128_129 L59_60 0.1674
K15249 L128_129 L11_57 0.1479
K15250 L128_129 L38_39 0.0546
K15251 L128_129 L27_28 0.0839
K15252 L128_129 L96_97 0.0298
K15253 L128_129 L78_79 0.0477
K15254 L128_129 L44_45 0.041
K15255 L128_129 L47_48 0.1173
K15256 L128_129 L29_30 0.0692
K15257 L128_129 L76_77 0.0477
K15258 L128_129 L166_167 0.0708
K15259 L128_129 L185_186 0.0414
K15260 L128_129 L16_17 0.0543
K15261 L128_129 L118_119 0.2387
K15262 L128_129 L176_177 0.036
K15263 L128_129 L6_53 0.13
K15264 L128_129 L149_150 0.0286
K15265 L128_129 L2_3 0.0387
K15266 L128_129 L98_99 0.03
K15267 L128_129 L184_185 0.0449
K15268 L128_129 L84_98 0.0307
K15269 L128_129 L48_49 0.1492
K15270 L128_129 L124_125 0.1877
K15271 L128_129 L113_114 0.1829
K15272 L128_129 L52_53 0.1684
K15273 L128_129 L80_81 0.0414
K15274 L128_129 L141_202 0.0479
K15275 L128_129 L87_88 0.0412
K15276 L128_129 L136_137 0.0345
K15277 L128_129 L138_139 0.0325
K15278 L128_129 L181_182 0.0406
K15279 L128_129 L28_29 0.0759
K15280 L128_129 L122_123 0.1877
K15281 L128_129 L9_10 0.0402
K15282 L128_129 L117_118 0.1593
K15283 L128_129 L51_52 0.13
K15284 L128_129 L56_57 0.2081
K15285 L128_129 L116_117 0.0898
K15286 L128_129 L154_155 0.0229
K15287 L128_129 L7_8 0.047
K15288 L128_129 L82_83 0.0462
K15289 L128_129 L14_15 0.041
K15290 L128_129 L199_200 0.0438
K15291 L128_129 L125_187 0.0552
K15292 L128_129 L58_59 0.0911
K15293 L128_129 L70_71 0.0459
K15294 L128_129 L68_69 0.052
K15295 L128_129 L180_181 0.0438
K15296 L128_129 L89_102 0.0244
K15297 L128_129 L26_27 0.0935
K15298 L128_129 L50_51 0.0837
K15299 L128_129 L90_91 0.0333
K15300 L128_129 L139_140 0.0314
K15301 L128_129 L161_162 0.0857
K15302 L128_129 L111_112 0.0854
K15303 L128_129 L162_163 0.0772
K15304 L128_129 L137_138 0.0335
K15305 L128_129 L179_180 0.0476
K15306 L128_129 L12_13 0.0483
K15307 L128_129 L142_143 0.0317
K15308 L128_129 L123_124 0.3407
K15309 L128_129 L191_192 0.0449
K15310 L128_129 L39_40 0.0519
K15311 L128_129 L18_19 0.0451
K15312 L128_129 L54_55 0.0878
K15313 L128_129 L201_202 0.0496
K15314 L13_18 L181_185 0.1438
K15315 L13_18 L140_145 0.0218
K15316 L13_18 L1_6 0.0939
K15317 L13_18 L35_40 0.0511
K15318 L13_18 L73_78 0.033
K15319 L13_18 L6_11 0.0991
K15320 L13_18 L163_168 0.08
K15321 L13_18 L144_149 0.0248
K15322 L13_18 L130_160 0.1557
K15323 L13_18 L4_9 0.1439
K15324 L13_18 L202_206 0.0314
K15325 L13_18 L109_114 0.0581
K15326 L13_18 L57_61 0.0602
K15327 L13_18 L164_169 0.0708
K15328 L13_18 L195_199 0.0201
K15329 L13_18 L106_111 0.0255
K15330 L13_18 L34_39 0.0565
K15331 L13_18 L201_205 0.0279
K15332 L13_18 L53_57 0.0599
K15333 L13_18 L69_73 0.0345
K15334 L13_18 L200_204 0.0246
K15335 L13_18 L150_155 0.0193
K15336 L13_18 L145_150 0.0204
K15337 L13_18 L30_35 0.0732
K15338 L13_18 L131_136 0.0346
K15339 L13_18 L101_105 0.0194
K15340 L13_18 L46_50 0.0256
K15341 L13_18 L196_200 0.0253
K15342 L13_18 L92_96 0.0266
K15343 L13_18 L81_86 0.024
K15344 L13_18 L19_24 0.1832
K15345 L13_18 L120_125 0.0958
K15346 L13_18 L160_165 0.0992
K15347 L13_18 L185_189 0.1536
K15348 L13_18 L60_64 0.0426
K15349 L13_18 L198_202 0.0328
K15350 L13_18 L193_197 0.0299
K15351 L13_18 L7_12 0.1832
K15352 L13_18 L137_142 0.0265
K15353 L13_18 L121_126 0.0256
K15354 L13_18 L97_101 0.0206
K15355 L13_18 L110_115 0.0897
K15356 L13_18 L113_118 0.0423
K15357 L13_18 L141_146 0.0307
K15358 L13_18 L100_104 0.0235
K15359 L13_18 L9_14 0.1832
K15360 L13_18 L134_139 0.0283
K15361 L13_18 L124_129 0.059
K15362 L13_18 L107_112 0.0328
K15363 L13_18 L78_83 0.0315
K15364 L13_18 L112_117 0.0329
K15365 L13_18 L40_45 0.0389
K15366 L13_18 L183_187 0.1536
K15367 L13_18 L59_63 0.0331
K15368 L13_18 L5_10 0.0985
K15369 L13_18 L15_20 0.1216
K15370 L13_18 L51_55 0.0331
K15371 L13_18 L58_62 0.0257
K15372 L13_18 L67_71 0.0261
K15373 L13_18 L29_34 0.083
K15374 L13_18 L179_183 0.1438
K15375 L13_18 L158_189 0.1438
K15376 L13_18 L206_210 0.03
K15377 L13_18 L41_74 0.0348
K15378 L13_18 L131_170 0.0462
K15379 L13_18 L205_209 0.0269
K15380 L13_18 L191_195 0.0207
K15381 L13_18 L66_70 0.0207
K15382 L13_18 L98_102 0.0235
K15383 L13_18 L27_32 0.1187
K15384 L13_18 L142_147 0.0248
K15385 L13_18 L147_152 0.0234
K15386 L13_18 L178_182 0.088
K15387 L13_18 L149_154 0.0234
K15388 L13_18 L203_207 0.0191
K15389 L13_18 L2_7 0.1439
K15390 L13_18 L117_122 0.033
K15391 L13_18 L22_27 0.2276
K15392 L13_18 L135_174 0.0385
K15393 L13_18 L52_56 0.0426
K15394 L13_18 L115_120 0.0941
K15395 L13_18 L80_85 0.0192
K15396 L13_18 L10_15 0.1144
K15397 L13_18 L16_21 0.0991
K15398 L13_18 L158_163 0.1319
K15399 L13_18 L96_100 0.025
K15400 L13_18 L49_53 0.059
K15401 L13_18 L186_190 0.1033
K15402 L13_18 L82_87 0.027
K15403 L13_18 L125_130 0.0941
K15404 L13_18 L108_113 0.042
K15405 L13_18 L159_164 0.1091
K15406 L13_18 L84_89 0.0292
K15407 L13_18 L204_208 0.024
K15408 L13_18 L25_30 0.119
K15409 L13_18 L14_19 0.2054
K15410 L13_18 L44_92 0.0285
K15411 L13_18 L21_26 0.1889
K15412 L13_18 L74_79 0.0327
K15413 L13_18 L165_170 0.0639
K15414 L13_18 L199_203 0.0196
K15415 L13_18 L75_80 0.0197
K15416 L13_18 L70_75 0.0202
K15417 L13_18 L50_54 0.0257
K15418 L13_18 L79_84 0.0309
K15419 L13_18 L56_60 0.0427
K15420 L13_18 L93_97 0.0219
K15421 L13_18 L90_94 0.0266
K15422 L13_18 L134_173 0.0422
K15423 L13_18 L139_144 0.0265
K15424 L13_18 L177_181 0.1226
K15425 L13_18 L111_116 0.0256
K15426 L13_18 L122_127 0.0329
K15427 L13_18 L135_140 0.0232
K15428 L13_18 L39_44 0.0427
K15429 L13_18 L123_128 0.0423
K15430 L13_18 L12_17 0.2054
K15431 L13_18 L54_58 0.0257
K15432 L13_18 L146_151 0.0291
K15433 L13_18 L61_65 0.0599
K15434 L13_18 L77_82 0.028
K15435 L23_28 L181_185 0.1572
K15436 L23_28 L140_145 0.0346
K15437 L23_28 L1_6 0.0927
K15438 L23_28 L35_40 0.095
K15439 L23_28 L73_78 0.0444
K15440 L23_28 L6_11 0.1019
K15441 L23_28 L163_168 0.1706
K15442 L23_28 L144_149 0.0391
K15443 L23_28 L130_160 0.2027
K15444 L23_28 L4_9 0.1482
K15445 L23_28 L202_206 0.0421
K15446 L23_28 L109_114 0.0678
K15447 L23_28 L57_61 0.0736
K15448 L23_28 L164_169 0.1403
K15449 L23_28 L195_199 0.0265
K15450 L23_28 L106_111 0.0318
K15451 L23_28 L34_39 0.1081
K15452 L23_28 L201_205 0.0371
K15453 L23_28 L53_57 0.0713
K15454 L23_28 L69_73 0.0465
K15455 L23_28 L200_204 0.0325
K15456 L23_28 L150_155 0.0299
K15457 L23_28 L145_150 0.0321
K15458 L23_28 L30_35 0.1538
K15459 L23_28 L131_136 0.0474
K15460 L23_28 L101_105 0.0301
K15461 L23_28 L46_50 0.0319
K15462 L23_28 L196_200 0.0334
K15463 L23_28 L92_96 0.0427
K15464 L23_28 L81_86 0.0317
K15465 L23_28 L19_24 0.2444
K15466 L23_28 L120_125 0.1069
K15467 L23_28 L160_165 0.1517
K15468 L23_28 L185_189 0.1795
K15469 L23_28 L60_64 0.0541
K15470 L23_28 L198_202 0.0441
K15471 L23_28 L193_197 0.0398
K15472 L23_28 L7_12 0.1187
K15473 L23_28 L137_142 0.0364
K15474 L23_28 L121_126 0.0327
K15475 L23_28 L97_101 0.0323
K15476 L23_28 L110_115 0.0902
K15477 L23_28 L113_118 0.0522
K15478 L23_28 L141_146 0.0418
K15479 L23_28 L100_104 0.0366
K15480 L23_28 L9_14 0.1879
K15481 L23_28 L134_139 0.0459
K15482 L23_28 L124_129 0.0744
K15483 L23_28 L107_112 0.0407
K15484 L23_28 L78_83 0.0423
K15485 L23_28 L112_117 0.0413
K15486 L23_28 L40_45 0.0659
K15487 L23_28 L183_187 0.1319
K15488 L23_28 L59_63 0.0422
K15489 L23_28 L5_10 0.1068
K15490 L23_28 L15_20 0.143
K15491 L23_28 L51_55 0.0414
K15492 L23_28 L58_62 0.0328
K15493 L23_28 L67_71 0.0344
K15494 L23_28 L29_34 0.1944
K15495 L23_28 L179_183 0.1101
K15496 L23_28 L158_189 0.1886
K15497 L23_28 L206_210 0.0403
K15498 L23_28 L41_74 0.0477
K15499 L23_28 L131_170 0.0658
K15500 L23_28 L205_209 0.0358
K15501 L23_28 L191_195 0.0272
K15502 L23_28 L66_70 0.0272
K15503 L23_28 L98_102 0.0321
K15504 L23_28 L27_32 0.1944
K15505 L23_28 L142_147 0.034
K15506 L23_28 L147_152 0.0319
K15507 L23_28 L178_182 0.0979
K15508 L23_28 L149_154 0.0364
K15509 L23_28 L203_207 0.0252
K15510 L23_28 L2_7 0.098
K15511 L23_28 L117_122 0.0417
K15512 L23_28 L22_27 0.2991
K15513 L23_28 L135_174 0.0648
K15514 L23_28 L52_56 0.0526
K15515 L23_28 L115_120 0.0985
K15516 L23_28 L80_85 0.0252
K15517 L23_28 L10_15 0.1262
K15518 L23_28 L16_21 0.1197
K15519 L23_28 L158_163 0.2341
K15520 L23_28 L96_100 0.0394
K15521 L23_28 L49_53 0.0686
K15522 L23_28 L186_190 0.124
K15523 L23_28 L82_87 0.0359
K15524 L23_28 L125_130 0.1143
K15525 L23_28 L108_113 0.0511
K15526 L23_28 L159_164 0.1794
K15527 L23_28 L84_89 0.0397
K15528 L23_28 L204_208 0.0316
K15529 L23_28 L25_30 0.2076
K15530 L23_28 L14_19 0.2276
K15531 L23_28 L44_92 0.0465
K15532 L23_28 L21_26 0.2473
K15533 L23_28 L74_79 0.0447
K15534 L23_28 L165_170 0.0946
K15535 L23_28 L199_203 0.0258
K15536 L23_28 L75_80 0.0259
K15537 L23_28 L70_75 0.0266
K15538 L23_28 L50_54 0.0323
K15539 L23_28 L79_84 0.0421
K15540 L23_28 L56_60 0.0535
K15541 L23_28 L93_97 0.0349
K15542 L23_28 L90_94 0.0366
K15543 L23_28 L134_173 0.0717
K15544 L23_28 L139_144 0.0422
K15545 L23_28 L177_181 0.1319
K15546 L23_28 L111_116 0.0322
K15547 L23_28 L122_127 0.042
K15548 L23_28 L135_140 0.0375
K15549 L23_28 L39_44 0.073
K15550 L23_28 L123_128 0.0538
K15551 L23_28 L12_17 0.1482
K15552 L23_28 L54_58 0.0326
K15553 L23_28 L146_151 0.0395
K15554 L23_28 L61_65 0.0754
K15555 L23_28 L77_82 0.0372
K15556 L143_148 L181_185 0.0235
K15557 L143_148 L140_145 0.1144
K15558 L143_148 L1_6 0.0276
K15559 L143_148 L35_40 0.0502
K15560 L143_148 L73_78 0.059
K15561 L143_148 L6_11 0.0291
K15562 L143_148 L163_168 0.0427
K15563 L143_148 L144_149 0.2054
K15564 L143_148 L130_160 0.0363
K15565 L143_148 L4_9 0.0221
K15566 L143_148 L202_206 0.0602
K15567 L143_148 L109_114 0.0288
K15568 L143_148 L57_61 0.0314
K15569 L143_148 L164_169 0.0389
K15570 L143_148 L195_199 0.0257
K15571 L143_148 L106_111 0.0187
K15572 L143_148 L34_39 0.0555
K15573 L143_148 L201_205 0.0427
K15574 L143_148 L53_57 0.03
K15575 L143_148 L69_73 0.0581
K15576 L143_148 L200_204 0.0331
K15577 L143_148 L150_155 0.1144
K15578 L143_148 L145_150 0.1216
K15579 L143_148 L30_35 0.0385
K15580 L143_148 L131_136 0.0939
K15581 L143_148 L101_105 0.0988
K15582 L143_148 L46_50 0.0186
K15583 L143_148 L196_200 0.0331
K15584 L143_148 L92_96 0.1438
K15585 L143_148 L81_86 0.0329
K15586 L143_148 L19_24 0.0265
K15587 L143_148 L120_125 0.0309
K15588 L143_148 L160_165 0.0468
K15589 L143_148 L185_189 0.025
K15590 L143_148 L60_64 0.0289
K15591 L143_148 L198_202 0.0599
K15592 L143_148 L193_197 0.0423
K15593 L143_148 L7_12 0.0234
K15594 L143_148 L137_142 0.1832
K15595 L143_148 L121_126 0.0202
K15596 L143_148 L97_101 0.1033
K15597 L143_148 L110_115 0.0277
K15598 L143_148 L113_118 0.027
K15599 L143_148 L141_146 0.1011
K15600 L143_148 L100_104 0.1438
K15601 L143_148 L9_14 0.0234
K15602 L143_148 L134_139 0.1439
K15603 L143_148 L124_129 0.033
K15604 L143_148 L107_112 0.0234
K15605 L143_148 L78_83 0.0593
K15606 L143_148 L112_117 0.024
K15607 L143_148 L40_45 0.0708
K15608 L143_148 L183_187 0.025
K15609 L143_148 L59_63 0.0253
K15610 L143_148 L5_10 0.0182
K15611 L143_148 L15_20 0.0204
K15612 L143_148 L51_55 0.024
K15613 L143_148 L58_62 0.0201
K15614 L143_148 L67_71 0.0328
K15615 L143_148 L29_34 0.0422
K15616 L143_148 L179_183 0.0235
K15617 L143_148 L158_189 0.0266
K15618 L143_148 L206_210 0.0599
K15619 L143_148 L41_74 0.0897
K15620 L143_148 L131_170 0.1065
K15621 L143_148 L205_209 0.0426
K15622 L143_148 L191_195 0.0256
K15623 L143_148 L66_70 0.0255
K15624 L143_148 L98_102 0.1438
K15625 L143_148 L27_32 0.0503
K15626 L143_148 L142_147 0.2054
K15627 L143_148 L147_152 0.1832
K15628 L143_148 L178_182 0.0183
K15629 L143_148 L149_154 0.1832
K15630 L143_148 L203_207 0.0257
K15631 L143_148 L2_7 0.0221
K15632 L143_148 L117_122 0.0247
K15633 L143_148 L22_27 0.0391
K15634 L143_148 L135_174 0.0732
K15635 L143_148 L52_56 0.0269
K15636 L143_148 L115_120 0.0292
K15637 L143_148 L80_85 0.0256
K15638 L143_148 L10_15 0.0193
K15639 L143_148 L16_21 0.0326
K15640 L143_148 L158_163 0.0342
K15641 L143_148 L96_100 0.1536
K15642 L143_148 L49_53 0.0288
K15643 L143_148 L186_190 0.0206
K15644 L143_148 L82_87 0.0423
K15645 L143_148 L125_130 0.0327
K15646 L143_148 L108_113 0.0261
K15647 L143_148 L159_164 0.0314
K15648 L143_148 L84_89 0.0941
K15649 L143_148 L204_208 0.0331
K15650 L143_148 L25_30 0.0312
K15651 L143_148 L14_19 0.0248
K15652 L143_148 L44_92 0.1226
K15653 L143_148 L21_26 0.036
K15654 L143_148 L74_79 0.0941
K15655 L143_148 L165_170 0.0657
K15656 L143_148 L199_203 0.0257
K15657 L143_148 L75_80 0.0256
K15658 L143_148 L70_75 0.0256
K15659 L143_148 L50_54 0.0191
K15660 L143_148 L79_84 0.0958
K15661 L143_148 L56_60 0.0279
K15662 L143_148 L93_97 0.0988
K15663 L143_148 L90_94 0.1438
K15664 L143_148 L134_173 0.083
K15665 L143_148 L139_144 0.1832
K15666 L143_148 L177_181 0.0222
K15667 L143_148 L111_116 0.0192
K15668 L143_148 L122_127 0.0254
K15669 L143_148 L135_140 0.0985
K15670 L143_148 L39_44 0.08
K15671 L143_148 L123_128 0.029
K15672 L143_148 L12_17 0.0248
K15673 L143_148 L54_58 0.0196
K15674 L143_148 L146_151 0.0991
K15675 L143_148 L61_65 0.0328
K15676 L143_148 L77_82 0.0424
K15677 L136_198 L167_168 0.0611
K15678 L136_198 L199_200 0.066
K15679 L136_198 L115_179 0.0315
K15680 L136_198 L1_2 0.0257
K15681 L136_198 L23_24 0.0417
K15682 L136_198 L158_159 0.0407
K15683 L136_198 L163_164 0.0491
K15684 L136_198 L144_145 0.0996
K15685 L136_198 L160_161 0.054
K15686 L136_198 L126_127 0.0404
K15687 L136_198 L22_23 0.0428
K15688 L136_198 L204_205 0.0952
K15689 L136_198 L153_154 0.081
K15690 L136_198 L4_5 0.0242
K15691 L136_198 L34_35 0.0577
K15692 L136_198 L41_42 0.1032
K15693 L136_198 L201_202 0.1933
K15694 L136_198 L191_192 0.0621
K15695 L136_198 L200_201 0.0993
K15696 L136_198 L205_206 0.1646
K15697 L136_198 L36_37 0.0845
K15698 L136_198 L131_132 0.1069
K15699 L136_198 L100_101 0.0885
K15700 L136_198 L203_204 0.0648
K15701 L136_198 L81_82 0.0931
K15702 L136_198 L148_149 0.1069
K15703 L136_198 L19_20 0.0325
K15704 L136_198 L187_188 0.0345
K15705 L136_198 L165_166 0.0669
K15706 L136_198 L102_103 0.087
K15707 L136_198 L106_107 0.035
K15708 L136_198 L64_65 0.0508
K15709 L136_198 L8_9 0.0302
K15710 L136_198 L170_171 0.0861
K15711 L136_198 L193_194 0.2045
K15712 L136_198 L21_65 0.0528
K15713 L136_198 L121_122 0.0411
K15714 L136_198 L9_10 0.0295
K15715 L136_198 L134_135 0.0753
K15716 L136_198 L41_69 0.2931
K15717 L136_198 L171_172 0.0802
K15718 L136_198 L104_105 0.0689
K15719 L136_198 L151_210 0.1829
K15720 L136_198 L37_38 0.079
K15721 L136_198 L112_113 0.0419
K15722 L136_198 L183_184 0.0326
K15723 L136_198 L59_60 0.0461
K15724 L136_198 L11_57 0.0488
K15725 L136_198 L38_39 0.0737
K15726 L136_198 L27_28 0.0521
K15727 L136_198 L78_79 0.2659
K15728 L136_198 L44_45 0.074
K15729 L136_198 L47_48 0.0385
K15730 L136_198 L29_30 0.0488
K15731 L136_198 L76_77 0.0969
K15732 L136_198 L166_167 0.0641
K15733 L136_198 L185_186 0.0311
K15734 L136_198 L16_17 0.035
K15735 L136_198 L118_119 0.0477
K15736 L136_198 L176_177 0.0248
K15737 L136_198 L6_53 0.046
K15738 L136_198 L149_150 0.0921
K15739 L136_198 L2_3 0.0252
K15740 L136_198 L98_99 0.1165
K15741 L136_198 L84_98 0.1327
K15742 L136_198 L48_49 0.0412
K15743 L136_198 L124_125 0.0523
K15744 L136_198 L113_114 0.045
K15745 L136_198 L52_53 0.0448
K15746 L136_198 L80_81 0.0642
K15747 L136_198 L141_202 0.3334
K15748 L136_198 L87_88 0.13
K15749 L136_198 L146_147 0.1459
K15750 L136_198 L127_128 0.0462
K15751 L136_198 L181_182 0.0296
K15752 L136_198 L28_29 0.0505
K15753 L136_198 L157_158 0.0419
K15754 L136_198 L122_123 0.0464
K15755 L136_198 L96_97 0.095
K15756 L136_198 L129_130 0.0532
K15757 L136_198 L21_22 0.0438
K15758 L136_198 L117_118 0.0441
K15759 L136_198 L51_52 0.0418
K15760 L136_198 L56_57 0.0474
K15761 L136_198 L116_117 0.0395
K15762 L136_198 L154_155 0.0713
K15763 L136_198 L7_8 0.0308
K15764 L136_198 L82_83 0.1537
K15765 L136_198 L14_15 0.031
K15766 L136_198 L184_185 0.0319
K15767 L136_198 L141_142 0.1855
K15768 L136_198 L125_187 0.0352
K15769 L136_198 L58_59 0.041
K15770 L136_198 L68_69 0.1765
K15771 L136_198 L180_181 0.0303
K15772 L136_198 L89_102 0.0965
K15773 L136_198 L26_27 0.0537
K15774 L136_198 L50_51 0.0378
K15775 L136_198 L161_162 0.0525
K15776 L136_198 L111_112 0.0379
K15777 L136_198 L162_163 0.0508
K15778 L136_198 L179_180 0.0309
K15779 L136_198 L12_13 0.0325
K15780 L136_198 L142_143 0.1476
K15781 L136_198 L123_124 0.0506
K15782 L136_198 L39_40 0.0687
K15783 L136_198 L18_19 0.0334
K15784 L136_198 L156_157 0.0431
K15785 L136_198 L54_55 0.0393
K15786 L144_145 L167_168 0.0496
K15787 L144_145 L74_90 0.1015
K15788 L144_145 L115_179 0.0221
K15789 L144_145 L196_197 0.0416
K15790 L144_145 L1_2 0.018
K15791 L144_145 L23_24 0.0313
K15792 L144_145 L158_159 0.0316
K15793 L144_145 L163_164 0.039
K15794 L144_145 L91_92 0.1438
K15795 L144_145 L160_161 0.0381
K15796 L144_145 L126_127 0.023
K15797 L144_145 L22_23 0.0311
K15798 L144_145 L204_205 0.0341
K15799 L144_145 L153_154 0.1144
K15800 L144_145 L4_5 0.0182
K15801 L144_145 L34_35 0.0492
K15802 L144_145 L41_42 0.0868
K15803 L144_145 L197_198 0.0589
K15804 L144_145 L191_192 0.0299
K15805 L144_145 L205_206 0.0449
K15806 L144_145 L36_37 0.063
K15807 L144_145 L131_132 0.091
K15808 L144_145 L100_101 0.1536
K15809 L144_145 L203_204 0.0275
K15810 L144_145 L92_93 0.1536
K15811 L144_145 L81_82 0.0339
K15812 L144_145 L148_149 0.1832
K15813 L144_145 L19_20 0.025
K15814 L144_145 L187_188 0.025
K15815 L144_145 L165_166 0.048
K15816 L144_145 L102_103 0.088
K15817 L144_145 L106_107 0.0208
K15818 L144_145 L64_65 0.0298
K15819 L144_145 L8_9 0.0222
K15820 L144_145 L170_171 0.0642
K15821 L144_145 L193_194 0.0546
K15822 L144_145 L21_65 0.0331
K15823 L144_145 L121_122 0.0238
K15824 L144_145 L9_10 0.0223
K15825 L144_145 L195_196 0.0321
K15826 L144_145 L134_135 0.1104
K15827 L144_145 L41_69 0.0872
K15828 L144_145 L171_172 0.0667
K15829 L144_145 L104_105 0.1033
K15830 L144_145 L151_210 0.0597
K15831 L144_145 L138_139 0.1832
K15832 L144_145 L37_38 0.0653
K15833 L144_145 L98_99 0.1226
K15834 L144_145 L112_113 0.0251
K15835 L144_145 L183_184 0.0235
K15836 L144_145 L59_60 0.0269
K15837 L144_145 L11_57 0.0314
K15838 L144_145 L38_39 0.0668
K15839 L144_145 L27_28 0.0383
K15840 L144_145 L44_45 0.1029
K15841 L144_145 L47_48 0.0231
K15842 L144_145 L29_30 0.0387
K15843 L144_145 L166_167 0.049
K15844 L144_145 L185_186 0.0237
K15845 L144_145 L16_17 0.0246
K15846 L144_145 L118_119 0.0289
K15847 L144_145 L176_177 0.0183
K15848 L144_145 L6_53 0.0298
K15849 L144_145 L149_150 0.2054
K15850 L144_145 L2_3 0.0181
K15851 L144_145 L84_98 0.1015
K15852 L144_145 L48_49 0.0254
K15853 L144_145 L124_125 0.0333
K15854 L144_145 L113_114 0.0277
K15855 L144_145 L52_53 0.0276
K15856 L144_145 L80_81 0.0274
K15857 L144_145 L87_88 0.041
K15858 L144_145 L146_147 0.1124
K15859 L144_145 L136_137 0.1124
K15860 L144_145 L127_128 0.0263
K15861 L144_145 L181_182 0.0224
K15862 L144_145 L28_29 0.0386
K15863 L144_145 L157_158 0.0315
K15864 L144_145 L122_123 0.0269
K15865 L144_145 L161_162 0.0386
K15866 L144_145 L129_130 0.0333
K15867 L144_145 L21_22 0.0308
K15868 L144_145 L117_118 0.026
K15869 L144_145 L51_52 0.025
K15870 L144_145 L56_57 0.0288
K15871 L144_145 L116_117 0.0231
K15872 L144_145 L154_155 0.1216
K15873 L144_145 L7_8 0.0221
K15874 L144_145 L82_83 0.0445
K15875 L144_145 L14_15 0.0236
K15876 L144_145 L184_185 0.0237
K15877 L144_145 L125_187 0.0247
K15878 L144_145 L58_59 0.0237
K15879 L144_145 L70_71 0.032
K15880 L144_145 L68_69 0.0537
K15881 L144_145 L180_181 0.0223
K15882 L144_145 L89_102 0.0759
K15883 L144_145 L26_27 0.0379
K15884 L144_145 L50_51 0.0224
K15885 L144_145 L90_91 0.1226
K15886 L144_145 L139_140 0.2054
K15887 L144_145 L111_112 0.0225
K15888 L144_145 L162_163 0.0389
K15889 L144_145 L137_138 0.1439
K15890 L144_145 L179_180 0.0222
K15891 L144_145 L12_13 0.0234
K15892 L144_145 L123_124 0.0303
K15893 L144_145 L39_40 0.0673
K15894 L144_145 L18_19 0.025
K15895 L144_145 L156_157 0.0313
K15896 L144_145 L54_55 0.0231
K15897 L6_11 L181_185 0.0813
K15898 L6_11 L140_145 0.0246
K15899 L6_11 L35_40 0.0506
K15900 L6_11 L73_78 0.0437
K15901 L6_11 L184_188 0.0941
K15902 L6_11 L163_168 0.0703
K15903 L6_11 L91_95 0.0309
K15904 L6_11 L144_149 0.0286
K15905 L6_11 L4_9 0.0833
K15906 L6_11 L202_206 0.0413
K15907 L6_11 L109_114 0.1053
K15908 L6_11 L57_61 0.1086
K15909 L6_11 L164_169 0.0616
K15910 L6_11 L195_199 0.0276
K15911 L6_11 L158_189 0.0775
K15912 L6_11 L106_111 0.0387
K15913 L6_11 L34_39 0.0568
K15914 L6_11 L148_153 0.0276
K15915 L6_11 L201_205 0.0375
K15916 L6_11 L53_57 0.1098
K15917 L6_11 L69_73 0.046
K15918 L6_11 L200_204 0.0336
K15919 L6_11 L150_155 0.0222
K15920 L6_11 L145_150 0.0234
K15921 L6_11 L30_35 0.0625
K15922 L6_11 L101_105 0.0223
K15923 L6_11 L46_50 0.0389
K15924 L6_11 L196_200 0.0347
K15925 L6_11 L92_96 0.0303
K15926 L6_11 L81_86 0.0326
K15927 L6_11 L19_24 0.0802
K15928 L6_11 L8_13 0.1011
K15929 L6_11 L60_64 0.0681
K15930 L6_11 L198_202 0.0435
K15931 L6_11 L193_197 0.0408
K15932 L6_11 L7_12 0.1262
K15933 L6_11 L137_142 0.0313
K15934 L6_11 L167_172 0.0586
K15935 L6_11 L121_126 0.0385
K15936 L6_11 L97_101 0.0234
K15937 L6_11 L113_118 0.0684
K15938 L6_11 L134_139 0.0319
K15939 L6_11 L100_104 0.0273
K15940 L6_11 L138_143 0.0307
K15941 L6_11 L33_38 0.0593
K15942 L6_11 L18_23 0.0939
K15943 L6_11 L124_129 0.1022
K15944 L6_11 L107_112 0.0503
K15945 L6_11 L78_83 0.0415
K15946 L6_11 L112_117 0.0504
K15947 L6_11 L40_45 0.0418
K15948 L6_11 L183_187 0.1131
K15949 L6_11 L59_63 0.0503
K15950 L6_11 L5_10 0.0615
K15951 L6_11 L15_20 0.0615
K15952 L6_11 L51_55 0.0507
K15953 L6_11 L58_62 0.0387
K15954 L6_11 L67_71 0.0359
K15955 L6_11 L29_34 0.0714
K15956 L6_11 L179_183 0.1161
K15957 L6_11 L206_210 0.0394
K15958 L6_11 L205_209 0.0361
K15959 L6_11 L191_195 0.0285
K15960 L6_11 L66_70 0.0286
K15961 L6_11 L98_102 0.0281
K15962 L6_11 L27_32 0.082
K15963 L6_11 L142_147 0.0296
K15964 L6_11 L147_152 0.028
K15965 L6_11 L178_182 0.0598
K15966 L6_11 L180_184 0.0958
K15967 L6_11 L3_8 0.0991
K15968 L6_11 L157_162 0.0985
K15969 L6_11 L149_154 0.0272
K15970 L6_11 L203_207 0.026
K15971 L6_11 L2_7 0.1224
K15972 L6_11 L117_122 0.0503
K15973 L6_11 L22_27 0.1156
K15974 L6_11 L38_43 0.0477
K15975 L6_11 L108_113 0.0681
K15976 L6_11 L135_174 0.0416
K15977 L6_11 L52_56 0.0692
K15978 L6_11 L80_85 0.0261
K15979 L6_11 L10_15 0.0622
K15980 L6_11 L158_163 0.0881
K15981 L6_11 L185_189 0.0803
K15982 L6_11 L96_100 0.0287
K15983 L6_11 L49_53 0.1086
K15984 L6_11 L186_190 0.0598
K15985 L6_11 L82_87 0.0362
K15986 L6_11 L159_164 0.075
K15987 L6_11 L9_14 0.0844
K15988 L6_11 L204_208 0.0325
K15989 L6_11 L25_30 0.0767
K15990 L6_11 L14_19 0.0833
K15991 L6_11 L44_92 0.032
K15992 L6_11 L199_203 0.0268
K15993 L6_11 L75_80 0.0269
K15994 L6_11 L70_75 0.0277
K15995 L6_11 L50_54 0.039
K15996 L6_11 L56_60 0.069
K15997 L6_11 L93_97 0.0247
K15998 L6_11 L90_94 0.0314
K15999 L6_11 L134_173 0.0461
K16000 L6_11 L139_144 0.0301
K16001 L6_11 L177_181 0.0803
K16002 L6_11 L111_116 0.0388
K16003 L6_11 L162_167 0.0753
K16004 L6_11 L43_91 0.0327
K16005 L6_11 L122_127 0.05
K16006 L6_11 L135_140 0.0259
K16007 L6_11 L39_44 0.0464
K16008 L6_11 L123_128 0.0673
K16009 L6_11 L54_58 0.0389
K16010 L6_11 L61_65 0.1051
K16011 L6_11 L12_17 0.1224
K16012 L6_11 L77_82 0.0377
K16013 L144_149 L140_145 0.1673
K16014 L144_149 L1_6 0.0272
K16015 L144_149 L35_40 0.0516
K16016 L144_149 L73_78 0.0537
K16017 L144_149 L184_188 0.025
K16018 L144_149 L91_95 0.1438
K16019 L144_149 L130_160 0.0357
K16020 L144_149 L22_27 0.0385
K16021 L144_149 L202_206 0.0546
K16022 L144_149 L109_114 0.0282
K16023 L144_149 L57_61 0.0305
K16024 L144_149 L164_169 0.0395
K16025 L144_149 L195_199 0.0244
K16026 L144_149 L106_111 0.0182
K16027 L144_149 L148_153 0.1832
K16028 L144_149 L201_205 0.0398
K16029 L144_149 L53_57 0.0292
K16030 L144_149 L69_73 0.0531
K16031 L144_149 L200_204 0.0314
K16032 L144_149 L150_155 0.1673
K16033 L144_149 L145_150 0.1916
K16034 L144_149 L30_35 0.0391
K16035 L144_149 L131_136 0.0802
K16036 L144_149 L101_105 0.1266
K16037 L144_149 L46_50 0.0181
K16038 L144_149 L196_200 0.0313
K16039 L144_149 L81_86 0.0312
K16040 L144_149 L120_125 0.0303
K16041 L144_149 L8_13 0.0234
K16042 L144_149 L60_64 0.0279
K16043 L144_149 L198_202 0.0544
K16044 L144_149 L193_197 0.0395
K16045 L144_149 L7_12 0.0232
K16046 L144_149 L137_142 0.1284
K16047 L144_149 L167_172 0.0718
K16048 L144_149 L121_126 0.0196
K16049 L144_149 L97_101 0.1363
K16050 L144_149 L110_115 0.0273
K16051 L144_149 L141_146 0.0844
K16052 L144_149 L122_127 0.0246
K16053 L144_149 L138_143 0.1832
K16054 L144_149 L33_38 0.0699
K16055 L144_149 L18_23 0.0265
K16056 L144_149 L124_129 0.032
K16057 L144_149 L107_112 0.0227
K16058 L144_149 L78_83 0.054
K16059 L144_149 L112_117 0.0233
K16060 L144_149 L40_45 0.0748
K16061 L144_149 L183_187 0.0247
K16062 L144_149 L59_63 0.0245
K16063 L144_149 L5_10 0.0184
K16064 L144_149 L15_20 0.0206
K16065 L144_149 L51_55 0.0233
K16066 L144_149 L58_62 0.0195
K16067 L144_149 L67_71 0.0311
K16068 L144_149 L179_183 0.0233
K16069 L144_149 L206_210 0.0544
K16070 L144_149 L41_74 0.0775
K16071 L144_149 L131_170 0.0937
K16072 L144_149 L205_209 0.0398
K16073 L144_149 L191_195 0.0243
K16074 L144_149 L2_7 0.022
K16075 L144_149 L98_102 0.1127
K16076 L144_149 L27_32 0.0491
K16077 L144_149 L147_152 0.1284
K16078 L144_149 L178_182 0.0185
K16079 L144_149 L180_184 0.0235
K16080 L144_149 L3_8 0.0221
K16081 L144_149 L157_162 0.0394
K16082 L144_149 L203_207 0.0244
K16083 L144_149 L66_70 0.0243
K16084 L144_149 L117_122 0.0239
K16085 L144_149 L38_43 0.1101
K16086 L144_149 L135_174 0.0777
K16087 L144_149 L160_165 0.0456
K16088 L144_149 L52_56 0.0261
K16089 L144_149 L115_120 0.0287
K16090 L144_149 L80_85 0.0243
K16091 L144_149 L10_15 0.0194
K16092 L144_149 L16_21 0.0319
K16093 L144_149 L113_118 0.0262
K16094 L144_149 L49_53 0.0281
K16095 L144_149 L186_190 0.0207
K16096 L144_149 L125_130 0.032
K16097 L144_149 L108_113 0.0254
K16098 L144_149 L159_164 0.0317
K16099 L144_149 L84_89 0.0803
K16100 L144_149 L204_208 0.0313
K16101 L144_149 L25_30 0.0315
K16102 L144_149 L82_87 0.0395
K16103 L144_149 L21_26 0.0354
K16104 L144_149 L74_79 0.0803
K16105 L144_149 L165_170 0.0624
K16106 L144_149 L199_203 0.0245
K16107 L144_149 L75_80 0.0244
K16108 L144_149 L70_75 0.0243
K16109 L144_149 L50_54 0.0186
K16110 L144_149 L79_84 0.0813
K16111 L144_149 L56_60 0.027
K16112 L144_149 L93_97 0.1266
K16113 L144_149 L90_94 0.1127
K16114 L144_149 L111_116 0.0186
K16115 L144_149 L162_167 0.051
K16116 L144_149 L43_91 0.1226
K16117 L144_149 L142_147 0.1354
K16118 L144_149 L135_140 0.1268
K16119 L144_149 L123_128 0.028
K16120 L144_149 L12_17 0.0246
K16121 L144_149 L54_58 0.019
K16122 L144_149 L146_151 0.0833
K16123 L144_149 L61_65 0.0318
K16124 L144_149 L77_82 0.0396
K16125 L22_27 L181_185 0.1293
K16126 L22_27 L140_145 0.0339
K16127 L22_27 L1_6 0.1027
K16128 L22_27 L35_40 0.0879
K16129 L22_27 L73_78 0.0458
K16130 L22_27 L184_188 0.1795
K16131 L22_27 L163_168 0.1463
K16132 L22_27 L91_95 0.0427
K16133 L22_27 L130_160 0.2588
K16134 L22_27 L4_9 0.1233
K16135 L22_27 L202_206 0.0434
K16136 L22_27 L109_114 0.0736
K16137 L22_27 L57_61 0.0811
K16138 L22_27 L164_169 0.1202
K16139 L22_27 L195_199 0.0274
K16140 L22_27 L106_111 0.0334
K16141 L22_27 L34_39 0.101
K16142 L22_27 L148_153 0.0364
K16143 L22_27 L201_205 0.0383
K16144 L22_27 L53_57 0.0781
K16145 L22_27 L69_73 0.0483
K16146 L22_27 L200_204 0.0336
K16147 L22_27 L150_155 0.0294
K16148 L22_27 L145_150 0.0315
K16149 L22_27 L30_35 0.1278
K16150 L22_27 L131_136 0.0486
K16151 L22_27 L101_105 0.0296
K16152 L22_27 L46_50 0.0336
K16153 L22_27 L196_200 0.0345
K16154 L22_27 L92_96 0.0419
K16155 L22_27 L81_86 0.0327
K16156 L22_27 L19_24 0.1676
K16157 L22_27 L120_125 0.123
K16158 L22_27 L8_13 0.1879
K16159 L22_27 L60_64 0.0583
K16160 L22_27 L198_202 0.0456
K16161 L22_27 L193_197 0.0413
K16162 L22_27 L167_172 0.1038
K16163 L22_27 L121_126 0.0345
K16164 L22_27 L97_101 0.0317
K16165 L22_27 L110_115 0.0992
K16166 L22_27 L113_118 0.0559
K16167 L22_27 L141_146 0.0426
K16168 L22_27 L100_104 0.0362
K16169 L22_27 L9_14 0.1437
K16170 L22_27 L138_143 0.0422
K16171 L22_27 L33_38 0.1081
K16172 L22_27 L18_23 0.2444
K16173 L22_27 L134_139 0.045
K16174 L22_27 L124_129 0.0821
K16175 L22_27 L107_112 0.0429
K16176 L22_27 L78_83 0.0436
K16177 L22_27 L112_117 0.0436
K16178 L22_27 L40_45 0.0635
K16179 L22_27 L59_63 0.0447
K16180 L22_27 L5_10 0.0895
K16181 L22_27 L15_20 0.1085
K16182 L22_27 L51_55 0.0438
K16183 L22_27 L58_62 0.0346
K16184 L22_27 L67_71 0.0357
K16185 L22_27 L29_34 0.159
K16186 L22_27 L206_210 0.0414
K16187 L22_27 L41_74 0.0489
K16188 L22_27 L131_170 0.0672
K16189 L22_27 L205_209 0.0369
K16190 L22_27 L191_195 0.0282
K16191 L22_27 L178_182 0.0842
K16192 L22_27 L180_184 0.1572
K16193 L22_27 L3_8 0.1482
K16194 L22_27 L157_162 0.2341
K16195 L22_27 L149_154 0.0359
K16196 L22_27 L203_207 0.026
K16197 L22_27 L66_70 0.0282
K16198 L22_27 L117_122 0.0441
K16199 L22_27 L158_189 0.1465
K16200 L22_27 L38_43 0.073
K16201 L22_27 L135_174 0.0625
K16202 L22_27 L160_165 0.1747
K16203 L22_27 L52_56 0.0563
K16204 L22_27 L115_120 0.1107
K16205 L22_27 L80_85 0.026
K16206 L22_27 L10_15 0.1002
K16207 L22_27 L16_21 0.1438
K16208 L22_27 L158_163 0.1838
K16209 L22_27 L185_189 0.1417
K16210 L22_27 L96_100 0.0389
K16211 L22_27 L49_53 0.0746
K16212 L22_27 L186_190 0.0996
K16213 L22_27 L82_87 0.037
K16214 L22_27 L125_130 0.1345
K16215 L22_27 L108_113 0.0546
K16216 L22_27 L159_164 0.1436
K16217 L22_27 L84_89 0.0404
K16218 L22_27 L204_208 0.0326
K16219 L22_27 L25_30 0.1566
K16220 L22_27 L14_19 0.1608
K16221 L22_27 L44_92 0.0455
K16222 L22_27 L21_26 0.3972
K16223 L22_27 L74_79 0.0457
K16224 L22_27 L165_170 0.0992
K16225 L22_27 L199_203 0.0267
K16226 L22_27 L75_80 0.0268
K16227 L22_27 L70_75 0.0275
K16228 L22_27 L50_54 0.034
K16229 L22_27 L79_84 0.0429
K16230 L22_27 L56_60 0.0574
K16231 L22_27 L93_97 0.0342
K16232 L22_27 L134_173 0.0696
K16233 L22_27 L139_144 0.0415
K16234 L22_27 L177_181 0.1139
K16235 L22_27 L111_116 0.0339
K16236 L22_27 L162_167 0.1706
K16237 L22_27 L43_91 0.0465
K16238 L22_27 L122_127 0.0444
K16239 L22_27 L135_140 0.0366
K16240 L22_27 L39_44 0.0708
K16241 L22_27 L123_128 0.0578
K16242 L22_27 L54_58 0.0343
K16243 L22_27 L146_151 0.0402
K16244 L22_27 L61_65 0.0836
K16245 L22_27 L77_82 0.0384
K16246 L22_23 L167_168 0.0865
K16247 L22_23 L74_90 0.0337
K16248 L22_23 L115_179 0.1006
K16249 L22_23 L196_197 0.0333
K16250 L22_23 L1_2 0.0843
K16251 L22_23 L102_103 0.0235
K16252 L22_23 L163_164 0.1299
K16253 L22_23 L91_92 0.0337
K16254 L22_23 L160_161 0.1389
K16255 L22_23 L146_147 0.0294
K16256 L22_23 L204_205 0.0311
K16257 L22_23 L153_154 0.0233
K16258 L22_23 L4_5 0.0792
K16259 L22_23 L34_35 0.0864
K16260 L22_23 L41_42 0.0457
K16261 L22_23 L197_198 0.0381
K16262 L22_23 L200_201 0.0322
K16263 L22_23 L205_206 0.0349
K16264 L22_23 L36_37 0.0632
K16265 L22_23 L131_132 0.0453
K16266 L22_23 L100_101 0.0294
K16267 L22_23 L203_204 0.0276
K16268 L22_23 L92_93 0.0334
K16269 L22_23 L81_82 0.0312
K16270 L22_23 L148_149 0.0294
K16271 L22_23 L19_20 0.1555
K16272 L22_23 L187_188 0.1644
K16273 L22_23 L165_166 0.0865
K16274 L22_23 L106_107 0.0393
K16275 L22_23 L8_9 0.1076
K16276 L22_23 L170_171 0.0624
K16277 L22_23 L193_194 0.0367
K16278 L22_23 L141_142 0.0313
K16279 L22_23 L121_122 0.0435
K16280 L22_23 L195_196 0.0291
K16281 L22_23 L134_135 0.0449
K16282 L22_23 L41_69 0.0419
K16283 L22_23 L171_172 0.0627
K16284 L22_23 L104_105 0.0233
K16285 L22_23 L151_210 0.0344
K16286 L22_23 L37_38 0.0635
K16287 L22_23 L112_113 0.0553
K16288 L22_23 L183_184 0.1276
K16289 L22_23 L59_60 0.0586
K16290 L22_23 L11_57 0.1409
K16291 L22_23 L38_39 0.0632
K16292 L22_23 L27_28 0.1549
K16293 L22_23 L96_97 0.0313
K16294 L22_23 L78_79 0.0407
K16295 L22_23 L44_45 0.0453
K16296 L22_23 L47_48 0.0516
K16297 L22_23 L29_30 0.1386
K16298 L22_23 L76_77 0.0323
K16299 L22_23 L166_167 0.0873
K16300 L22_23 L185_186 0.1128
K16301 L22_23 L16_17 0.1891
K16302 L22_23 L118_119 0.082
K16303 L22_23 L176_177 0.0794
K16304 L22_23 L6_53 0.121
K16305 L22_23 L149_150 0.0293
K16306 L22_23 L2_3 0.0863
K16307 L22_23 L98_99 0.0297
K16308 L22_23 L184_185 0.1234
K16309 L22_23 L84_98 0.0296
K16310 L22_23 L48_49 0.0726
K16311 L22_23 L124_125 0.1514
K16312 L22_23 L113_114 0.0776
K16313 L22_23 L52_53 0.0791
K16314 L22_23 L80_81 0.0276
K16315 L22_23 L141_202 0.0405
K16316 L22_23 L87_88 0.0316
K16317 L22_23 L136_137 0.0335
K16318 L22_23 L138_139 0.0335
K16319 L22_23 L181_182 0.0947
K16320 L22_23 L28_29 0.1502
K16321 L22_23 L122_123 0.058
K16322 L22_23 L9_10 0.1004
K16323 L22_23 L117_118 0.0568
K16324 L22_23 L51_52 0.0558
K16325 L22_23 L56_57 0.0838
K16326 L22_23 L116_117 0.043
K16327 L22_23 L154_155 0.0232
K16328 L22_23 L7_8 0.1104
K16329 L22_23 L82_83 0.035
K16330 L22_23 L14_15 0.1231
K16331 L22_23 L199_200 0.0283
K16332 L22_23 L125_187 0.1556
K16333 L22_23 L58_59 0.0438
K16334 L22_23 L70_71 0.0291
K16335 L22_23 L68_69 0.0369
K16336 L22_23 L180_181 0.1006
K16337 L22_23 L89_102 0.0235
K16338 L22_23 L26_27 0.1502
K16339 L22_23 L50_51 0.0426
K16340 L22_23 L90_91 0.0338
K16341 L22_23 L139_140 0.0332
K16342 L22_23 L161_162 0.1425
K16343 L22_23 L111_112 0.0423
K16344 L22_23 L162_163 0.1389
K16345 L22_23 L137_138 0.0335
K16346 L22_23 L179_180 0.1029
K16347 L22_23 L12_13 0.1436
K16348 L22_23 L142_143 0.0314
K16349 L22_23 L123_124 0.0859
K16350 L22_23 L191_192 0.0276
K16351 L22_23 L39_40 0.0623
K16352 L22_23 L18_19 0.1891
K16353 L22_23 L54_55 0.0433
K16354 L22_23 L201_202 0.0364
K16355 L100_104 L140_145 0.1062
K16356 L100_104 L1_6 0.026
K16357 L100_104 L35_40 0.0473
K16358 L100_104 L73_78 0.0537
K16359 L100_104 L184_188 0.0234
K16360 L100_104 L91_95 0.1439
K16361 L100_104 L130_160 0.0331
K16362 L100_104 L202_206 0.0537
K16363 L100_104 L109_114 0.027
K16364 L100_104 L57_61 0.0293
K16365 L100_104 L164_169 0.0362
K16366 L100_104 L195_199 0.0243
K16367 L100_104 L106_111 0.0177
K16368 L100_104 L148_153 0.1536
K16369 L100_104 L201_205 0.0395
K16370 L100_104 L53_57 0.0282
K16371 L100_104 L69_73 0.0526
K16372 L100_104 L200_204 0.0312
K16373 L100_104 L150_155 0.1363
K16374 L100_104 L145_150 0.1266
K16375 L100_104 L30_35 0.0365
K16376 L100_104 L131_136 0.0735
K16377 L100_104 L101_105 0.1916
K16378 L100_104 L46_50 0.0177
K16379 L100_104 L196_200 0.0311
K16380 L100_104 L81_86 0.0314
K16381 L100_104 L120_125 0.0286
K16382 L100_104 L8_13 0.0222
K16383 L100_104 L60_64 0.0271
K16384 L100_104 L198_202 0.0531
K16385 L100_104 L193_197 0.0388
K16386 L100_104 L7_12 0.0221
K16387 L100_104 L137_142 0.1015
K16388 L100_104 L167_172 0.0619
K16389 L100_104 L121_126 0.019
K16390 L100_104 L97_101 0.1673
K16391 L100_104 L110_115 0.0259
K16392 L100_104 L141_146 0.0803
K16393 L100_104 L122_127 0.0239
K16394 L100_104 L138_143 0.1226
K16395 L100_104 L33_38 0.0633
K16396 L100_104 L18_23 0.025
K16397 L100_104 L124_129 0.0305
K16398 L100_104 L107_112 0.0221
K16399 L100_104 L78_83 0.0544
K16400 L100_104 L112_117 0.0227
K16401 L100_104 L40_45 0.067
K16402 L100_104 L183_187 0.0232
K16403 L100_104 L59_63 0.0239
K16404 L100_104 L5_10 0.0175
K16405 L100_104 L15_20 0.0195
K16406 L100_104 L51_55 0.0227
K16407 L100_104 L58_62 0.0191
K16408 L100_104 L67_71 0.031
K16409 L100_104 L179_183 0.022
K16410 L100_104 L206_210 0.054
K16411 L100_104 L41_74 0.0757
K16412 L100_104 L131_170 0.0777
K16413 L100_104 L205_209 0.0396
K16414 L100_104 L191_195 0.0241
K16415 L100_104 L2_7 0.0209
K16416 L100_104 L98_102 0.1354
K16417 L100_104 L27_32 0.0455
K16418 L100_104 L147_152 0.1173
K16419 L100_104 L178_182 0.0174
K16420 L100_104 L180_184 0.0221
K16421 L100_104 L3_8 0.0211
K16422 L100_104 L157_162 0.0364
K16423 L100_104 L203_207 0.0244
K16424 L100_104 L66_70 0.0242
K16425 L100_104 L117_122 0.0233
K16426 L100_104 L38_43 0.098
K16427 L100_104 L135_174 0.0651
K16428 L100_104 L160_165 0.0413
K16429 L100_104 L52_56 0.0254
K16430 L100_104 L115_120 0.0272
K16431 L100_104 L80_85 0.0245
K16432 L100_104 L10_15 0.0185
K16433 L100_104 L16_21 0.0303
K16434 L100_104 L113_118 0.0253
K16435 L100_104 L49_53 0.0271
K16436 L100_104 L186_190 0.0194
K16437 L100_104 L125_130 0.0301
K16438 L100_104 L108_113 0.0245
K16439 L100_104 L159_164 0.0295
K16440 L100_104 L84_89 0.0844
K16441 L100_104 L204_208 0.0313
K16442 L100_104 L25_30 0.0297
K16443 L100_104 L82_87 0.0398
K16444 L100_104 L21_26 0.0333
K16445 L100_104 L74_79 0.0802
K16446 L100_104 L165_170 0.0546
K16447 L100_104 L199_203 0.0243
K16448 L100_104 L75_80 0.0244
K16449 L100_104 L70_75 0.0243
K16450 L100_104 L50_54 0.0182
K16451 L100_104 L79_84 0.0833
K16452 L100_104 L56_60 0.0262
K16453 L100_104 L93_97 0.1268
K16454 L100_104 L90_94 0.1124
K16455 L100_104 L111_116 0.0181
K16456 L100_104 L162_167 0.0459
K16457 L100_104 L43_91 0.1124
K16458 L100_104 L142_147 0.1127
K16459 L100_104 L135_140 0.0867
K16460 L100_104 L123_128 0.027
K16461 L100_104 L12_17 0.0233
K16462 L100_104 L54_58 0.0186
K16463 L100_104 L146_151 0.0813
K16464 L100_104 L61_65 0.0306
K16465 L100_104 L77_82 0.0398
K16466 L34_35 L74_90 0.0524
K16467 L34_35 L199_200 0.0327
K16468 L34_35 L115_179 0.0518
K16469 L34_35 L196_197 0.0394
K16470 L34_35 L1_2 0.0424
K16471 L34_35 L23_24 0.0888
K16472 L34_35 L158_159 0.0873
K16473 L34_35 L163_164 0.1221
K16474 L34_35 L91_92 0.0545
K16475 L34_35 L160_161 0.1084
K16476 L34_35 L126_127 0.0378
K16477 L34_35 L204_205 0.0373
K16478 L34_35 L153_154 0.0351
K16479 L34_35 L4_5 0.0443
K16480 L34_35 L41_42 0.0741
K16481 L34_35 L197_198 0.0475
K16482 L34_35 L200_201 0.0384
K16483 L34_35 L205_206 0.0438
K16484 L34_35 L36_37 0.1122
K16485 L34_35 L131_132 0.0727
K16486 L34_35 L100_101 0.0456
K16487 L34_35 L203_204 0.032
K16488 L34_35 L92_93 0.0548
K16489 L34_35 L81_82 0.0374
K16490 L34_35 L148_149 0.045
K16491 L34_35 L19_20 0.0688
K16492 L34_35 L102_103 0.0351
K16493 L34_35 L106_107 0.035
K16494 L34_35 L64_65 0.0613
K16495 L34_35 L8_9 0.0545
K16496 L34_35 L170_171 0.1084
K16497 L34_35 L193_194 0.0455
K16498 L34_35 L21_65 0.0821
K16499 L34_35 L121_122 0.0395
K16500 L34_35 L9_10 0.0548
K16501 L34_35 L195_196 0.0334
K16502 L34_35 L187_188 0.0653
K16503 L34_35 L134_135 0.0772
K16504 L34_35 L41_69 0.0567
K16505 L34_35 L171_172 0.1153
K16506 L34_35 L104_105 0.0355
K16507 L34_35 L151_210 0.0461
K16508 L34_35 L37_38 0.12
K16509 L34_35 L112_113 0.0452
K16510 L34_35 L183_184 0.0585
K16511 L34_35 L59_60 0.0487
K16512 L34_35 L11_57 0.0725
K16513 L34_35 L38_39 0.1258
K16514 L34_35 L27_28 0.12
K16515 L34_35 L78_79 0.0549
K16516 L34_35 L44_45 0.0788
K16517 L34_35 L47_48 0.042
K16518 L34_35 L29_30 0.1279
K16519 L34_35 L76_77 0.0385
K16520 L34_35 L185_186 0.0599
K16521 L34_35 L16_17 0.0642
K16522 L34_35 L118_119 0.0579
K16523 L34_35 L176_177 0.0435
K16524 L34_35 L6_53 0.0669
K16525 L34_35 L149_150 0.0451
K16526 L34_35 L2_3 0.0434
K16527 L34_35 L98_99 0.045
K16528 L34_35 L84_98 0.0442
K16529 L34_35 L48_49 0.051
K16530 L34_35 L124_125 0.0776
K16531 L34_35 L113_114 0.055
K16532 L34_35 L52_53 0.0554
K16533 L34_35 L80_81 0.0321
K16534 L34_35 L141_202 0.0545
K16535 L34_35 L87_88 0.0398
K16536 L34_35 L146_147 0.0438
K16537 L34_35 L136_137 0.0518
K16538 L34_35 L127_128 0.0469
K16539 L34_35 L138_139 0.0538
K16540 L34_35 L181_182 0.054
K16541 L34_35 L28_29 0.1258
K16542 L34_35 L157_158 0.0865
K16543 L34_35 L122_123 0.0484
K16544 L34_35 L96_97 0.0498
K16545 L34_35 L129_130 0.0805
K16546 L34_35 L21_22 0.0828
K16547 L34_35 L117_118 0.0468
K16548 L34_35 L51_52 0.0455
K16549 L34_35 L56_57 0.0584
K16550 L34_35 L116_117 0.0387
K16551 L34_35 L154_155 0.0352
K16552 L34_35 L7_8 0.0537
K16553 L34_35 L82_83 0.0441
K16554 L34_35 L14_15 0.061
K16555 L34_35 L184_185 0.0596
K16556 L34_35 L141_142 0.0475
K16557 L34_35 L125_187 0.063
K16558 L34_35 L58_59 0.0397
K16559 L34_35 L70_71 0.0335
K16560 L34_35 L68_69 0.0458
K16561 L34_35 L180_181 0.0538
K16562 L34_35 L89_102 0.0345
K16563 L34_35 L26_27 0.1122
K16564 L34_35 L50_51 0.0379
K16565 L34_35 L90_91 0.0537
K16566 L34_35 L139_140 0.054
K16567 L34_35 L161_162 0.1153
K16568 L34_35 L111_112 0.0377
K16569 L34_35 L162_163 0.1203
K16570 L34_35 L137_138 0.053
K16571 L34_35 L179_180 0.053
K16572 L34_35 L12_13 0.0595
K16573 L34_35 L142_143 0.0484
K16574 L34_35 L123_124 0.061
K16575 L34_35 L191_192 0.0315
K16576 L34_35 L39_40 0.1279
K16577 L34_35 L18_19 0.0683
K16578 L34_35 L156_157 0.0843
K16579 L34_35 L54_55 0.0388
K16580 L34_35 L201_202 0.0456
K16581 L106_111 L181_185 0.0244
K16582 L106_111 L140_145 0.0151
K16583 L106_111 L1_6 0.0388
K16584 L106_111 L35_40 0.0246
K16585 L106_111 L73_78 0.0336
K16586 L106_111 L184_188 0.0256
K16587 L106_111 L163_168 0.0291
K16588 L106_111 L91_95 0.0191
K16589 L106_111 L130_160 0.0322
K16590 L106_111 L4_9 0.0244
K16591 L106_111 L202_206 0.0325
K16592 L106_111 L109_114 0.056
K16593 L106_111 L57_61 0.0549
K16594 L106_111 L164_169 0.026
K16595 L106_111 L34_39 0.0274
K16596 L106_111 L148_153 0.0182
K16597 L106_111 L201_205 0.0358
K16598 L106_111 L53_57 0.0554
K16599 L106_111 L69_73 0.0349
K16600 L106_111 L200_204 0.0385
K16601 L106_111 L150_155 0.0144
K16602 L106_111 L145_150 0.0147
K16603 L106_111 L30_35 0.026
K16604 L106_111 L131_136 0.0277
K16605 L106_111 L101_105 0.0144
K16606 L106_111 L122_127 0.1273
K16607 L106_111 L196_200 0.0406
K16608 L106_111 L92_96 0.0186
K16609 L106_111 L81_86 0.0365
K16610 L106_111 L19_24 0.0241
K16611 L106_111 L120_125 0.0387
K16612 L106_111 L8_13 0.0256
K16613 L106_111 L60_64 0.0759
K16614 L106_111 L198_202 0.0337
K16615 L106_111 L193_197 0.0393
K16616 L106_111 L7_12 0.027
K16617 L106_111 L137_142 0.0197
K16618 L106_111 L167_172 0.0286
K16619 L106_111 L97_101 0.0147
K16620 L106_111 L110_115 0.039
K16621 L106_111 L113_118 0.0812
K16622 L106_111 L134_139 0.0191
K16623 L106_111 L141_146 0.0261
K16624 L106_111 L9_14 0.0243
K16625 L106_111 L138_143 0.0192
K16626 L106_111 L33_38 0.0285
K16627 L106_111 L18_23 0.0253
K16628 L106_111 L124_129 0.0545
K16629 L106_111 L107_112 0.1548
K16630 L106_111 L78_83 0.0324
K16631 L106_111 L112_117 0.1506
K16632 L106_111 L40_45 0.0231
K16633 L106_111 L183_187 0.027
K16634 L106_111 L59_63 0.1215
K16635 L106_111 L5_10 0.0195
K16636 L106_111 L15_20 0.0194
K16637 L106_111 L51_55 0.1405
K16638 L106_111 L67_71 0.0427
K16639 L106_111 L29_34 0.029
K16640 L106_111 L158_189 0.0242
K16641 L106_111 L206_210 0.0313
K16642 L106_111 L41_74 0.0276
K16643 L106_111 L131_170 0.0261
K16644 L106_111 L205_209 0.0343
K16645 L106_111 L98_102 0.0186
K16646 L106_111 L27_32 0.0317
K16647 L106_111 L147_152 0.0187
K16648 L106_111 L178_182 0.0195
K16649 L106_111 L180_184 0.0257
K16650 L106_111 L3_8 0.0256
K16651 L106_111 L157_162 0.0319
K16652 L106_111 L149_154 0.0177
K16653 L106_111 L2_7 0.0271
K16654 L106_111 L117_122 0.1402
K16655 L106_111 L38_43 0.0265
K16656 L106_111 L135_174 0.0231
K16657 L106_111 L160_165 0.0304
K16658 L106_111 L52_56 0.0797
K16659 L106_111 L115_120 0.0389
K16660 L106_111 L10_15 0.0194
K16661 L106_111 L16_21 0.0381
K16662 L106_111 L158_163 0.0304
K16663 L106_111 L185_189 0.0243
K16664 L106_111 L96_100 0.0181
K16665 L106_111 L49_53 0.0555
K16666 L106_111 L186_190 0.0194
K16667 L106_111 L82_87 0.0342
K16668 L106_111 L125_130 0.0383
K16669 L106_111 L108_113 0.0818
K16670 L106_111 L159_164 0.0271
K16671 L106_111 L204_208 0.0367
K16672 L106_111 L25_30 0.027
K16673 L106_111 L14_19 0.0243
K16674 L106_111 L44_92 0.019
K16675 L106_111 L21_26 0.0321
K16676 L106_111 L84_89 0.0252
K16677 L106_111 L74_79 0.0268
K16678 L106_111 L165_170 0.0283
K16679 L106_111 L79_84 0.026
K16680 L106_111 L56_60 0.0782
K16681 L106_111 L93_97 0.0151
K16682 L106_111 L90_94 0.0197
K16683 L106_111 L134_173 0.0257
K16684 L106_111 L139_144 0.0186
K16685 L106_111 L177_181 0.0245
K16686 L106_111 L179_183 0.0271
K16687 L106_111 L162_167 0.0304
K16688 L106_111 L43_91 0.0196
K16689 L106_111 L142_147 0.0192
K16690 L106_111 L135_140 0.0155
K16691 L106_111 L39_44 0.0256
K16692 L106_111 L123_128 0.0772
K16693 L106_111 L12_17 0.0269
K16694 L106_111 L146_151 0.0253
K16695 L106_111 L61_65 0.0541
K16696 L106_111 L77_82 0.0357
K16697 L34_39 L140_145 0.0671
K16698 L34_39 L1_6 0.0529
K16699 L34_39 L35_40 0.305
K16700 L34_39 L73_78 0.0562
K16701 L34_39 L184_188 0.0555
K16702 L34_39 L91_95 0.0633
K16703 L34_39 L130_160 0.0885
K16704 L34_39 L202_206 0.0534
K16705 L34_39 L109_114 0.0488
K16706 L34_39 L57_61 0.0538
K16707 L34_39 L164_169 0.1634
K16708 L34_39 L195_199 0.029
K16709 L34_39 L148_153 0.0503
K16710 L34_39 L201_205 0.0435
K16711 L34_39 L53_57 0.0514
K16712 L34_39 L69_73 0.0587
K16713 L34_39 L200_204 0.0362
K16714 L34_39 L150_155 0.0517
K16715 L34_39 L145_150 0.0584
K16716 L34_39 L30_35 0.189
K16717 L34_39 L131_136 0.0703
K16718 L34_39 L101_105 0.0528
K16719 L34_39 L46_50 0.0275
K16720 L34_39 L196_200 0.0369
K16721 L34_39 L81_86 0.0356
K16722 L34_39 L120_125 0.0604
K16723 L34_39 L8_13 0.051
K16724 L34_39 L60_64 0.0449
K16725 L34_39 L198_202 0.0558
K16726 L34_39 L193_197 0.0459
K16727 L34_39 L7_12 0.0498
K16728 L34_39 L137_142 0.0598
K16729 L34_39 L167_172 0.2341
K16730 L34_39 L121_126 0.029
K16731 L34_39 L97_101 0.0601
K16732 L34_39 L110_115 0.0524
K16733 L34_39 L141_146 0.0604
K16734 L34_39 L122_127 0.0369
K16735 L34_39 L138_143 0.0619
K16736 L34_39 L33_38 0.2991
K16737 L34_39 L18_23 0.0633
K16738 L34_39 L124_129 0.0558
K16739 L34_39 L107_112 0.0347
K16740 L34_39 L78_83 0.0538
K16741 L34_39 L112_117 0.0354
K16742 L34_39 L40_45 0.189
K16743 L34_39 L183_187 0.054
K16744 L34_39 L59_63 0.037
K16745 L34_39 L5_10 0.0471
K16746 L34_39 L15_20 0.0601
K16747 L34_39 L51_55 0.0356
K16748 L34_39 L58_62 0.0291
K16749 L34_39 L67_71 0.0377
K16750 L34_39 L179_183 0.0491
K16751 L34_39 L206_210 0.0511
K16752 L34_39 L41_74 0.0714
K16753 L34_39 L131_170 0.1298
K16754 L34_39 L205_209 0.0422
K16755 L34_39 L191_195 0.0295
K16756 L34_39 L2_7 0.0455
K16757 L34_39 L98_102 0.0498
K16758 L34_39 L27_32 0.159
K16759 L34_39 L147_152 0.0491
K16760 L34_39 L178_182 0.0463
K16761 L34_39 L180_184 0.0503
K16762 L34_39 L3_8 0.0465
K16763 L34_39 L157_162 0.1038
K16764 L34_39 L203_207 0.028
K16765 L34_39 L66_70 0.0296
K16766 L34_39 L117_122 0.0362
K16767 L34_39 L38_43 0.1944
K16768 L34_39 L135_174 0.1634
K16769 L34_39 L160_165 0.1298
K16770 L34_39 L52_56 0.0424
K16771 L34_39 L115_120 0.0562
K16772 L34_39 L80_85 0.028
K16773 L34_39 L10_15 0.0528
K16774 L34_39 L16_21 0.066
K16775 L34_39 L113_118 0.0422
K16776 L34_39 L49_53 0.0491
K16777 L34_39 L186_190 0.0584
K16778 L34_39 L125_130 0.0651
K16779 L34_39 L108_113 0.0409
K16780 L34_39 L159_164 0.0972
K16781 L34_39 L84_89 0.0568
K16782 L34_39 L204_208 0.0354
K16783 L34_39 L25_30 0.1013
K16784 L34_39 L82_87 0.0424
K16785 L34_39 L21_26 0.0915
K16786 L34_39 L74_79 0.066
K16787 L34_39 L165_170 0.1599
K16788 L34_39 L199_203 0.0285
K16789 L34_39 L75_80 0.0286
K16790 L34_39 L70_75 0.0291
K16791 L34_39 L50_54 0.028
K16792 L34_39 L79_84 0.0611
K16793 L34_39 L56_60 0.0437
K16794 L34_39 L93_97 0.0697
K16795 L34_39 L90_94 0.061
K16796 L34_39 L111_116 0.028
K16797 L34_39 L162_167 0.1706
K16798 L34_39 L43_91 0.0718
K16799 L34_39 L142_147 0.054
K16800 L34_39 L135_140 0.0784
K16801 L34_39 L123_128 0.0447
K16802 L34_39 L12_17 0.0548
K16803 L34_39 L54_58 0.0286
K16804 L34_39 L146_151 0.0562
K16805 L34_39 L61_65 0.0562
K16806 L34_39 L77_82 0.0437
K16807 L148_153 L181_185 0.0222
K16808 L148_153 L140_145 0.0985
K16809 L148_153 L1_6 0.0263
K16810 L148_153 L35_40 0.0457
K16811 L148_153 L73_78 0.0581
K16812 L148_153 L163_168 0.0394
K16813 L148_153 L130_160 0.0338
K16814 L148_153 L4_9 0.021
K16815 L148_153 L202_206 0.0599
K16816 L148_153 L109_114 0.0277
K16817 L148_153 L57_61 0.03
K16818 L148_153 L164_169 0.036
K16819 L148_153 L195_199 0.0256
K16820 L148_153 L201_205 0.0426
K16821 L148_153 L53_57 0.0288
K16822 L148_153 L69_73 0.0568
K16823 L148_153 L200_204 0.0331
K16824 L148_153 L150_155 0.1216
K16825 L148_153 L145_150 0.1144
K16826 L148_153 L30_35 0.0357
K16827 L148_153 L131_136 0.0869
K16828 L148_153 L101_105 0.1033
K16829 L148_153 L46_50 0.0182
K16830 L148_153 L196_200 0.0329
K16831 L148_153 L92_96 0.1226
K16832 L148_153 L81_86 0.033
K16833 L148_153 L19_24 0.0248
K16834 L148_153 L120_125 0.0292
K16835 L148_153 L160_165 0.0427
K16836 L148_153 L185_189 0.0235
K16837 L148_153 L60_64 0.0279
K16838 L148_153 L198_202 0.059
K16839 L148_153 L193_197 0.0418
K16840 L148_153 L7_12 0.0221
K16841 L148_153 L137_142 0.1439
K16842 L148_153 L121_126 0.0197
K16843 L148_153 L97_101 0.0988
K16844 L148_153 L110_115 0.0264
K16845 L148_153 L113_118 0.0261
K16846 L148_153 L141_146 0.0991
K16847 L148_153 L9_14 0.0221
K16848 L148_153 L134_139 0.1124
K16849 L148_153 L124_129 0.0315
K16850 L148_153 L107_112 0.0227
K16851 L148_153 L78_83 0.059
K16852 L148_153 L112_117 0.0234
K16853 L148_153 L40_45 0.0625
K16854 L148_153 L183_187 0.0235
K16855 L148_153 L59_63 0.0246
K16856 L148_153 L5_10 0.0173
K16857 L148_153 L15_20 0.0193
K16858 L148_153 L51_55 0.0233
K16859 L148_153 L58_62 0.0196
K16860 L148_153 L67_71 0.0325
K16861 L148_153 L29_34 0.0391
K16862 L148_153 L179_183 0.0222
K16863 L148_153 L158_189 0.025
K16864 L148_153 L206_210 0.0602
K16865 L148_153 L41_74 0.0836
K16866 L148_153 L131_170 0.0887
K16867 L148_153 L205_209 0.0427
K16868 L148_153 L191_195 0.0254
K16869 L148_153 L66_70 0.0253
K16870 L148_153 L98_102 0.1536
K16871 L148_153 L27_32 0.0459
K16872 L148_153 L142_147 0.1832
K16873 L148_153 L147_152 0.2054
K16874 L148_153 L178_182 0.0174
K16875 L148_153 L149_154 0.2054
K16876 L148_153 L203_207 0.0257
K16877 L148_153 L2_7 0.021
K16878 L148_153 L117_122 0.024
K16879 L148_153 L135_174 0.0641
K16880 L148_153 L52_56 0.026
K16881 L148_153 L115_120 0.0277
K16882 L148_153 L80_85 0.0256
K16883 L148_153 L10_15 0.0182
K16884 L148_153 L16_21 0.0307
K16885 L148_153 L158_163 0.0321
K16886 L148_153 L96_100 0.1438
K16887 L148_153 L49_53 0.0276
K16888 L148_153 L186_190 0.0194
K16889 L148_153 L82_87 0.0424
K16890 L148_153 L125_130 0.0309
K16891 L148_153 L108_113 0.0252
K16892 L148_153 L159_164 0.0295
K16893 L148_153 L84_89 0.0958
K16894 L148_153 L204_208 0.0331
K16895 L148_153 L25_30 0.0293
K16896 L148_153 L14_19 0.0234
K16897 L148_153 L44_92 0.1015
K16898 L148_153 L21_26 0.0335
K16899 L148_153 L74_79 0.0897
K16900 L148_153 L165_170 0.058
K16901 L148_153 L199_203 0.0257
K16902 L148_153 L75_80 0.0256
K16903 L148_153 L70_75 0.0255
K16904 L148_153 L50_54 0.0186
K16905 L148_153 L79_84 0.0941
K16906 L148_153 L56_60 0.0269
K16907 L148_153 L93_97 0.088
K16908 L148_153 L90_94 0.1226
K16909 L148_153 L134_173 0.0718
K16910 L148_153 L139_144 0.1439
K16911 L148_153 L177_181 0.0211
K16912 L148_153 L111_116 0.0187
K16913 L148_153 L122_127 0.0247
K16914 L148_153 L135_140 0.0823
K16915 L148_153 L39_44 0.0699
K16916 L148_153 L123_128 0.028
K16917 L148_153 L12_17 0.0234
K16918 L148_153 L54_58 0.0191
K16919 L148_153 L146_151 0.1011
K16920 L148_153 L61_65 0.0314
K16921 L148_153 L77_82 0.0423
K16922 L201_205 L181_185 0.0262
K16923 L201_205 L140_145 0.0313
K16924 L201_205 L1_6 0.0361
K16925 L201_205 L35_40 0.0387
K16926 L201_205 L73_78 0.1104
K16927 L201_205 L163_168 0.0397
K16928 L201_205 L91_95 0.0423
K16929 L201_205 L130_160 0.0364
K16930 L201_205 L4_9 0.0253
K16931 L201_205 L202_206 0.1145
K16932 L201_205 L109_114 0.0444
K16933 L201_205 L57_61 0.0487
K16934 L201_205 L164_169 0.0356
K16935 L201_205 L195_199 0.0812
K16936 L201_205 L204_208 0.1134
K16937 L201_205 L53_57 0.0464
K16938 L201_205 L69_73 0.1076
K16939 L201_205 L200_204 0.1145
K16940 L201_205 L150_155 0.0313
K16941 L201_205 L145_150 0.0314
K16942 L201_205 L30_35 0.0355
K16943 L201_205 L131_136 0.0681
K16944 L201_205 L101_105 0.0312
K16945 L201_205 L46_50 0.0357
K16946 L201_205 L196_200 0.1134
K16947 L201_205 L92_96 0.0395
K16948 L201_205 L81_86 0.1104
K16949 L201_205 L19_24 0.0279
K16950 L201_205 L120_125 0.0393
K16951 L201_205 L8_13 0.0269
K16952 L201_205 L198_202 0.1134
K16953 L201_205 L7_12 0.0277
K16954 L201_205 L137_142 0.0459
K16955 L201_205 L167_172 0.0459
K16956 L201_205 L121_126 0.0412
K16957 L201_205 L97_101 0.0312
K16958 L201_205 L110_115 0.0362
K16959 L201_205 L134_139 0.0395
K16960 L201_205 L141_146 0.0692
K16961 L201_205 L9_14 0.0261
K16962 L201_205 L138_143 0.0426
K16963 L201_205 L33_38 0.0457
K16964 L201_205 L18_23 0.0289
K16965 L201_205 L124_129 0.0515
K16966 L201_205 L107_112 0.0444
K16967 L201_205 L78_83 0.1114
K16968 L201_205 L112_117 0.0466
K16969 L201_205 L40_45 0.0417
K16970 L201_205 L183_187 0.0288
K16971 L201_205 L59_63 0.0513
K16972 L201_205 L5_10 0.0205
K16973 L201_205 L15_20 0.0219
K16974 L201_205 L51_55 0.0464
K16975 L201_205 L58_62 0.041
K16976 L201_205 L67_71 0.1076
K16977 L201_205 L29_34 0.0396
K16978 L201_205 L179_183 0.0278
K16979 L201_205 L158_189 0.028
K16980 L201_205 L206_210 0.1134
K16981 L201_205 L41_74 0.0673
K16982 L201_205 L131_170 0.0518
K16983 L201_205 L191_195 0.0796
K16984 L201_205 L66_70 0.0782
K16985 L201_205 L98_102 0.0455
K16986 L201_205 L27_32 0.043
K16987 L201_205 L142_147 0.0461
K16988 L201_205 L147_152 0.0459
K16989 L201_205 L178_182 0.0206
K16990 L201_205 L180_184 0.027
K16991 L201_205 L3_8 0.026
K16992 L201_205 L157_162 0.0372
K16993 L201_205 L149_154 0.0398
K16994 L201_205 L203_207 0.0812
K16995 L201_205 L2_7 0.0267
K16996 L201_205 L117_122 0.0489
K16997 L201_205 L38_43 0.0499
K16998 L201_205 L135_174 0.0419
K16999 L201_205 L160_165 0.0411
K17000 L201_205 L115_120 0.0377
K17001 L201_205 L80_85 0.0797
K17002 L201_205 L10_15 0.0212
K17003 L201_205 L16_21 0.0408
K17004 L201_205 L158_163 0.036
K17005 L201_205 L185_189 0.0271
K17006 L201_205 L96_100 0.0396
K17007 L201_205 L49_53 0.0443
K17008 L201_205 L186_190 0.0219
K17009 L201_205 L125_130 0.041
K17010 L201_205 L184_188 0.028
K17011 L201_205 L159_164 0.0324
K17012 L201_205 L25_30 0.0323
K17013 L201_205 L14_19 0.027
K17014 L201_205 L44_92 0.0392
K17015 L201_205 L21_26 0.0362
K17016 L201_205 L84_89 0.0681
K17017 L201_205 L74_79 0.0681
K17018 L201_205 L165_170 0.0464
K17019 L201_205 L199_203 0.0818
K17020 L201_205 L75_80 0.0802
K17021 L201_205 L70_75 0.0797
K17022 L201_205 L50_54 0.0373
K17023 L201_205 L79_84 0.0684
K17024 L201_205 L93_97 0.0312
K17025 L201_205 L90_94 0.0455
K17026 L201_205 L134_173 0.0473
K17027 L201_205 L139_144 0.0398
K17028 L201_205 L177_181 0.0254
K17029 L201_205 L111_116 0.0375
K17030 L201_205 L162_167 0.0414
K17031 L201_205 L43_91 0.042
K17032 L201_205 L122_127 0.0515
K17033 L201_205 L135_140 0.0312
K17034 L201_205 L39_44 0.0471
K17035 L201_205 L12_17 0.0287
K17036 L201_205 L54_58 0.0391
K17037 L201_205 L146_151 0.069
K17038 L201_205 L61_65 0.0513
K17039 L197_198 L167_168 0.0501
K17040 L197_198 L199_200 0.0993
K17041 L197_198 L115_179 0.0289
K17042 L197_198 L1_2 0.0236
K17043 L197_198 L23_24 0.0369
K17044 L197_198 L158_159 0.0358
K17045 L197_198 L163_164 0.0423
K17046 L197_198 L160_161 0.0474
K17047 L197_198 L126_127 0.0462
K17048 L197_198 L204_205 0.1646
K17049 L197_198 L153_154 0.0509
K17050 L197_198 L4_5 0.0219
K17051 L197_198 L41_42 0.0673
K17052 L197_198 L201_202 0.3334
K17053 L197_198 L191_192 0.0947
K17054 L197_198 L200_201 0.1933
K17055 L197_198 L205_206 0.2392
K17056 L197_198 L36_37 0.0642
K17057 L197_198 L131_132 0.0683
K17058 L197_198 L100_101 0.0564
K17059 L197_198 L203_204 0.0952
K17060 L197_198 L81_82 0.1537
K17061 L197_198 L148_149 0.0634
K17062 L197_198 L19_20 0.0288
K17063 L197_198 L187_188 0.0308
K17064 L197_198 L165_166 0.0554
K17065 L197_198 L102_103 0.0553
K17066 L197_198 L106_107 0.0386
K17067 L197_198 L64_65 0.0528
K17068 L197_198 L8_9 0.0274
K17069 L197_198 L170_171 0.0649
K17070 L197_198 L193_194 0.4331
K17071 L197_198 L21_65 0.0508
K17072 L197_198 L121_122 0.0464
K17073 L197_198 L9_10 0.0266
K17074 L197_198 L134_135 0.0531
K17075 L197_198 L41_69 0.1765
K17076 L197_198 L171_172 0.0607
K17077 L197_198 L104_105 0.0456
K17078 L197_198 L151_210 0.1369
K17079 L197_198 L37_38 0.0601
K17080 L197_198 L112_113 0.045
K17081 L197_198 L183_184 0.0295
K17082 L197_198 L59_60 0.0504
K17083 L197_198 L11_57 0.0474
K17084 L197_198 L38_39 0.0564
K17085 L197_198 L27_28 0.0454
K17086 L197_198 L78_79 0.1743
K17087 L197_198 L44_45 0.0526
K17088 L197_198 L47_48 0.0412
K17089 L197_198 L29_30 0.0421
K17090 L197_198 L76_77 0.1743
K17091 L197_198 L166_167 0.0527
K17092 L197_198 L185_186 0.0278
K17093 L197_198 L16_17 0.0316
K17094 L197_198 L118_119 0.0491
K17095 L197_198 L176_177 0.0225
K17096 L197_198 L6_53 0.0448
K17097 L197_198 L149_150 0.0573
K17098 L197_198 L2_3 0.023
K17099 L197_198 L98_99 0.0693
K17100 L197_198 L84_98 0.078
K17101 L197_198 L48_49 0.0423
K17102 L197_198 L124_125 0.0506
K17103 L197_198 L113_114 0.0462
K17104 L197_198 L52_53 0.046
K17105 L197_198 L80_81 0.0931
K17106 L197_198 L141_202 0.1933
K17107 L197_198 L87_88 0.1684
K17108 L197_198 L146_147 0.0803
K17109 L197_198 L127_128 0.0512
K17110 L197_198 L181_182 0.0267
K17111 L197_198 L28_29 0.0438
K17112 L197_198 L157_158 0.037
K17113 L197_198 L122_123 0.0506
K17114 L197_198 L96_97 0.0579
K17115 L197_198 L129_130 0.0512
K17116 L197_198 L21_22 0.0393
K17117 L197_198 L117_118 0.0477
K17118 L197_198 L51_52 0.0448
K17119 L197_198 L56_57 0.0488
K17120 L197_198 L116_117 0.0441
K17121 L197_198 L154_155 0.0462
K17122 L197_198 L7_8 0.0281
K17123 L197_198 L82_83 0.2117
K17124 L197_198 L14_15 0.0277
K17125 L197_198 L184_185 0.0286
K17126 L197_198 L141_142 0.0851
K17127 L197_198 L125_187 0.0317
K17128 L197_198 L58_59 0.0461
K17129 L197_198 L68_69 0.2931
K17130 L197_198 L180_181 0.0275
K17131 L197_198 L89_102 0.0615
K17132 L197_198 L26_27 0.0471
K17133 L197_198 L50_51 0.0418
K17134 L197_198 L161_162 0.0457
K17135 L197_198 L111_112 0.0419
K17136 L197_198 L162_163 0.044
K17137 L197_198 L179_180 0.0282
K17138 L197_198 L12_13 0.0293
K17139 L197_198 L142_143 0.0741
K17140 L197_198 L123_124 0.0523
K17141 L197_198 L39_40 0.053
K17142 L197_198 L18_19 0.0297
K17143 L197_198 L156_157 0.0382
K17144 L197_198 L54_55 0.0439
K17145 L205_209 L181_185 0.0254
K17146 L205_209 L140_145 0.0312
K17147 L205_209 L1_6 0.0347
K17148 L205_209 L35_40 0.0376
K17149 L205_209 L73_78 0.1076
K17150 L205_209 L163_168 0.0384
K17151 L205_209 L91_95 0.042
K17152 L205_209 L130_160 0.035
K17153 L205_209 L4_9 0.0245
K17154 L205_209 L202_206 0.1134
K17155 L205_209 L109_114 0.0425
K17156 L205_209 L57_61 0.0464
K17157 L205_209 L164_169 0.0345
K17158 L205_209 L195_199 0.0796
K17159 L205_209 L204_208 0.1145
K17160 L205_209 L53_57 0.0443
K17161 L205_209 L69_73 0.1034
K17162 L205_209 L200_204 0.1134
K17163 L205_209 L150_155 0.0314
K17164 L205_209 L145_150 0.0313
K17165 L205_209 L30_35 0.0344
K17166 L205_209 L131_136 0.0668
K17167 L205_209 L101_105 0.0312
K17168 L205_209 L46_50 0.0342
K17169 L205_209 L196_200 0.1103
K17170 L205_209 L92_96 0.0392
K17171 L205_209 L81_86 0.1114
K17172 L205_209 L19_24 0.027
K17173 L205_209 L120_125 0.0377
K17174 L205_209 L8_13 0.026
K17175 L205_209 L198_202 0.1103
K17176 L205_209 L7_12 0.0267
K17177 L205_209 L137_142 0.0455
K17178 L205_209 L167_172 0.0444
K17179 L205_209 L121_126 0.0393
K17180 L205_209 L97_101 0.0312
K17181 L205_209 L110_115 0.0348
K17182 L205_209 L134_139 0.0391
K17183 L205_209 L141_146 0.069
K17184 L205_209 L9_14 0.0253
K17185 L205_209 L138_143 0.0423
K17186 L205_209 L33_38 0.0442
K17187 L205_209 L18_23 0.0279
K17188 L205_209 L124_129 0.0489
K17189 L205_209 L107_112 0.0425
K17190 L205_209 L78_83 0.1104
K17191 L205_209 L112_117 0.0444
K17192 L205_209 L40_45 0.0407
K17193 L205_209 L183_187 0.0278
K17194 L205_209 L59_63 0.0487
K17195 L205_209 L5_10 0.0199
K17196 L205_209 L15_20 0.0212
K17197 L205_209 L51_55 0.0443
K17198 L205_209 L58_62 0.0391
K17199 L205_209 L67_71 0.1034
K17200 L205_209 L29_34 0.0383
K17201 L205_209 L179_183 0.0268
K17202 L205_209 L158_189 0.0271
K17203 L205_209 L206_210 0.1145
K17204 L205_209 L41_74 0.066
K17205 L205_209 L131_170 0.0501
K17206 L205_209 L191_195 0.0772
K17207 L205_209 L66_70 0.0759
K17208 L205_209 L98_102 0.0457
K17209 L205_209 L27_32 0.0413
K17210 L205_209 L142_147 0.0459
K17211 L205_209 L147_152 0.0461
K17212 L205_209 L178_182 0.02
K17213 L205_209 L180_184 0.0261
K17214 L205_209 L3_8 0.0251
K17215 L205_209 L157_162 0.0359
K17216 L205_209 L149_154 0.0398
K17217 L205_209 L203_207 0.0818
K17218 L205_209 L2_7 0.0257
K17219 L205_209 L117_122 0.0466
K17220 L205_209 L38_43 0.0486
K17221 L205_209 L135_174 0.0409
K17222 L205_209 L160_165 0.0395
K17223 L205_209 L115_120 0.0362
K17224 L205_209 L80_85 0.0802
K17225 L205_209 L10_15 0.0205
K17226 L205_209 L16_21 0.0391
K17227 L205_209 L158_163 0.0348
K17228 L205_209 L185_189 0.0262
K17229 L205_209 L96_100 0.0395
K17230 L205_209 L49_53 0.0423
K17231 L205_209 L186_190 0.0213
K17232 L205_209 L125_130 0.0393
K17233 L205_209 L184_188 0.027
K17234 L205_209 L159_164 0.0314
K17235 L205_209 L25_30 0.0313
K17236 L205_209 L14_19 0.0261
K17237 L205_209 L44_92 0.0388
K17238 L205_209 L21_26 0.0348
K17239 L205_209 L84_89 0.0684
K17240 L205_209 L74_79 0.0673
K17241 L205_209 L165_170 0.0446
K17242 L205_209 L199_203 0.0812
K17243 L205_209 L75_80 0.0797
K17244 L205_209 L70_75 0.0782
K17245 L205_209 L50_54 0.0357
K17246 L205_209 L79_84 0.0681
K17247 L205_209 L93_97 0.031
K17248 L205_209 L90_94 0.0451
K17249 L205_209 L134_173 0.0462
K17250 L205_209 L139_144 0.0395
K17251 L205_209 L177_181 0.0246
K17252 L205_209 L111_116 0.0358
K17253 L205_209 L162_167 0.0399
K17254 L205_209 L43_91 0.0415
K17255 L205_209 L122_127 0.0489
K17256 L205_209 L135_140 0.0308
K17257 L205_209 L39_44 0.0459
K17258 L205_209 L12_17 0.0277
K17259 L205_209 L54_58 0.0373
K17260 L205_209 L146_151 0.0692
K17261 L205_209 L61_65 0.0487
K17262 L150_155 L181_185 0.0185
K17263 L150_155 L1_6 0.0212
K17264 L150_155 L73_78 0.0412
K17265 L150_155 L184_188 0.0194
K17266 L150_155 L163_168 0.0386
K17267 L150_155 L91_95 0.088
K17268 L150_155 L130_160 0.0272
K17269 L150_155 L4_9 0.0174
K17270 L150_155 L109_114 0.022
K17271 L150_155 L57_61 0.0237
K17272 L150_155 L195_199 0.0194
K17273 L150_155 L53_57 0.0228
K17274 L150_155 L69_73 0.0405
K17275 L150_155 L200_204 0.025
K17276 L150_155 L131_136 0.057
K17277 L150_155 L46_50 0.0144
K17278 L150_155 L196_200 0.0249
K17279 L150_155 L92_96 0.1062
K17280 L150_155 L81_86 0.0249
K17281 L150_155 L19_24 0.0206
K17282 L150_155 L120_125 0.0234
K17283 L150_155 L8_13 0.0182
K17284 L150_155 L60_64 0.0219
K17285 L150_155 L198_202 0.0417
K17286 L150_155 L193_197 0.0308
K17287 L150_155 L7_12 0.0181
K17288 L150_155 L137_142 0.0787
K17289 L150_155 L167_172 0.051
K17290 L150_155 L121_126 0.0155
K17291 L150_155 L110_115 0.0213
K17292 L150_155 L113_118 0.0206
K17293 L150_155 L134_139 0.0968
K17294 L150_155 L141_146 0.0615
K17295 L150_155 L9_14 0.0184
K17296 L150_155 L138_143 0.0985
K17297 L150_155 L33_38 0.05
K17298 L150_155 L18_23 0.0204
K17299 L150_155 L124_129 0.0248
K17300 L150_155 L107_112 0.018
K17301 L150_155 L78_83 0.0417
K17302 L150_155 L112_117 0.0184
K17303 L150_155 L183_187 0.0192
K17304 L150_155 L59_63 0.0193
K17305 L150_155 L51_55 0.0184
K17306 L150_155 L58_62 0.0154
K17307 L150_155 L67_71 0.0246
K17308 L150_155 L29_34 0.0382
K17309 L150_155 L179_183 0.0181
K17310 L150_155 L206_210 0.0423
K17311 L150_155 L41_74 0.0556
K17312 L150_155 L131_170 0.0622
K17313 L150_155 L191_195 0.0193
K17314 L150_155 L66_70 0.0193
K17315 L150_155 L98_102 0.0811
K17316 L150_155 L27_32 0.0366
K17317 L150_155 L142_147 0.0861
K17318 L150_155 L147_152 0.0891
K17319 L150_155 L180_184 0.0183
K17320 L150_155 L3_8 0.0173
K17321 L150_155 L157_162 0.0301
K17322 L150_155 L149_154 0.1916
K17323 L150_155 L203_207 0.0195
K17324 L150_155 L2_7 0.0172
K17325 L150_155 L117_122 0.0189
K17326 L150_155 L158_189 0.0207
K17327 L150_155 L38_43 0.0728
K17328 L150_155 L108_113 0.02
K17329 L150_155 L160_165 0.0339
K17330 L150_155 L52_56 0.0205
K17331 L150_155 L115_120 0.0223
K17332 L150_155 L80_85 0.0195
K17333 L150_155 L16_21 0.0246
K17334 L150_155 L158_163 0.0304
K17335 L150_155 L185_189 0.0195
K17336 L150_155 L96_100 0.1266
K17337 L150_155 L49_53 0.022
K17338 L150_155 L82_87 0.0312
K17339 L150_155 L125_130 0.0247
K17340 L150_155 L84_89 0.0604
K17341 L150_155 L204_208 0.025
K17342 L150_155 L202_206 0.0421
K17343 L150_155 L14_19 0.0194
K17344 L150_155 L44_92 0.0867
K17345 L150_155 L21_26 0.027
K17346 L150_155 L74_79 0.0581
K17347 L150_155 L165_170 0.0445
K17348 L150_155 L199_203 0.0195
K17349 L150_155 L75_80 0.0194
K17350 L150_155 L70_75 0.0194
K17351 L150_155 L50_54 0.0147
K17352 L150_155 L79_84 0.0598
K17353 L150_155 L56_60 0.0212
K17354 L150_155 L90_94 0.073
K17355 L150_155 L134_173 0.0827
K17356 L150_155 L139_144 0.1268
K17357 L150_155 L177_181 0.0175
K17358 L150_155 L111_116 0.0147
K17359 L150_155 L162_167 0.0379
K17360 L150_155 L43_91 0.0759
K17361 L150_155 L122_127 0.0194
K17362 L150_155 L39_44 0.0784
K17363 L150_155 L123_128 0.0219
K17364 L150_155 L12_17 0.0191
K17365 L150_155 L54_58 0.0151
K17366 L150_155 L146_151 0.0622
K17367 L150_155 L61_65 0.0247
K17368 L150_155 L77_82 0.0312
K17369 L205_206 L167_168 0.0459
K17370 L205_206 L74_90 0.0564
K17371 L205_206 L199_200 0.0993
K17372 L205_206 L115_179 0.0265
K17373 L205_206 L196_197 0.1646
K17374 L205_206 L1_2 0.0217
K17375 L205_206 L23_24 0.0339
K17376 L205_206 L158_159 0.0331
K17377 L205_206 L163_164 0.0391
K17378 L205_206 L91_92 0.0474
K17379 L205_206 L160_161 0.043
K17380 L205_206 L126_127 0.0416
K17381 L205_206 L138_139 0.0478
K17382 L205_206 L153_154 0.0548
K17383 L205_206 L4_5 0.0203
K17384 L205_206 L41_42 0.062
K17385 L205_206 L200_201 0.1933
K17386 L205_206 L36_37 0.0579
K17387 L205_206 L131_132 0.0628
K17388 L205_206 L122_123 0.045
K17389 L205_206 L92_93 0.0438
K17390 L205_206 L19_20 0.0266
K17391 L205_206 L187_188 0.0282
K17392 L205_206 L102_103 0.0604
K17393 L205_206 L106_107 0.0352
K17394 L205_206 L64_65 0.0462
K17395 L205_206 L8_9 0.0253
K17396 L205_206 L170_171 0.0584
K17397 L205_206 L193_194 0.2072
K17398 L205_206 L21_65 0.0449
K17399 L205_206 L121_122 0.0419
K17400 L205_206 L9_10 0.0247
K17401 L205_206 L195_196 0.0952
K17402 L205_206 L134_135 0.0504
K17403 L205_206 L41_69 0.1387
K17404 L205_206 L171_172 0.0553
K17405 L205_206 L104_105 0.0483
K17406 L205_206 L151_210 0.1877
K17407 L205_206 L37_38 0.0549
K17408 L205_206 L112_113 0.0405
K17409 L205_206 L183_184 0.027
K17410 L205_206 L59_60 0.0448
K17411 L205_206 L11_57 0.0425
K17412 L205_206 L38_39 0.052
K17413 L205_206 L27_28 0.0415
K17414 L205_206 L96_97 0.0445
K17415 L205_206 L78_79 0.1743
K17416 L205_206 L44_45 0.05
K17417 L205_206 L47_48 0.0372
K17418 L205_206 L29_30 0.0389
K17419 L205_206 L76_77 0.1743
K17420 L205_206 L166_167 0.0479
K17421 L205_206 L185_186 0.0257
K17422 L205_206 L16_17 0.0288
K17423 L205_206 L118_119 0.0437
K17424 L205_206 L176_177 0.0208
K17425 L205_206 L6_53 0.0404
K17426 L205_206 L2_3 0.0212
K17427 L205_206 L113_114 0.0414
K17428 L205_206 L48_49 0.038
K17429 L205_206 L124_125 0.045
K17430 L205_206 L52_53 0.0412
K17431 L205_206 L141_202 0.1933
K17432 L205_206 L87_88 0.2623
K17433 L205_206 L136_137 0.0573
K17434 L205_206 L127_128 0.0451
K17435 L205_206 L181_182 0.0248
K17436 L205_206 L28_29 0.0402
K17437 L205_206 L157_158 0.034
K17438 L205_206 L129_130 0.0451
K17439 L205_206 L21_22 0.0358
K17440 L205_206 L117_118 0.0427
K17441 L205_206 L51_52 0.0404
K17442 L205_206 L56_57 0.0435
K17443 L205_206 L116_117 0.04
K17444 L205_206 L7_8 0.0259
K17445 L205_206 L154_155 0.049
K17446 L205_206 L14_15 0.0257
K17447 L205_206 L184_185 0.0264
K17448 L205_206 L141_142 0.0589
K17449 L205_206 L125_187 0.0289
K17450 L205_206 L58_59 0.0418
K17451 L205_206 L70_71 0.0931
K17452 L205_206 L68_69 0.1866
K17453 L205_206 L180_181 0.0254
K17454 L205_206 L89_102 0.0689
K17455 L205_206 L26_27 0.0428
K17456 L205_206 L50_51 0.0381
K17457 L205_206 L165_166 0.0499
K17458 L205_206 L90_91 0.0515
K17459 L205_206 L139_140 0.0442
K17460 L205_206 L161_162 0.0417
K17461 L205_206 L111_112 0.0382
K17462 L205_206 L162_163 0.0404
K17463 L205_206 L137_138 0.0521
K17464 L205_206 L179_180 0.026
K17465 L205_206 L12_13 0.027
K17466 L205_206 L142_143 0.0533
K17467 L205_206 L123_124 0.0462
K17468 L205_206 L191_192 0.0877
K17469 L205_206 L39_40 0.0493
K17470 L205_206 L18_19 0.0274
K17471 L205_206 L156_157 0.035
K17472 L205_206 L54_55 0.0399
K17473 L205_206 L201_202 0.3334
K17474 L203_204 L167_168 0.0333
K17475 L203_204 L74_90 0.0317
K17476 L203_204 L199_200 0.3334
K17477 L203_204 L115_179 0.0218
K17478 L203_204 L196_197 0.1646
K17479 L203_204 L1_2 0.0179
K17480 L203_204 L23_24 0.0268
K17481 L203_204 L158_159 0.026
K17482 L203_204 L163_164 0.03
K17483 L203_204 L91_92 0.0286
K17484 L203_204 L160_161 0.0331
K17485 L203_204 L126_127 0.0465
K17486 L203_204 L138_139 0.0287
K17487 L203_204 L153_154 0.0283
K17488 L203_204 L4_5 0.0166
K17489 L203_204 L41_42 0.0373
K17490 L203_204 L200_201 0.1933
K17491 L203_204 L36_37 0.0387
K17492 L203_204 L131_132 0.0374
K17493 L203_204 L122_123 0.045
K17494 L203_204 L92_93 0.0272
K17495 L203_204 L19_20 0.0211
K17496 L203_204 L187_188 0.0225
K17497 L203_204 L102_103 0.0299
K17498 L203_204 L106_107 0.0381
K17499 L203_204 L64_65 0.0414
K17500 L203_204 L8_9 0.0207
K17501 L203_204 L170_171 0.0388
K17502 L203_204 L193_194 0.0877
K17503 L203_204 L21_65 0.037
K17504 L203_204 L121_122 0.0462
K17505 L203_204 L9_10 0.0201
K17506 L203_204 L195_196 0.2392
K17507 L203_204 L134_135 0.0323
K17508 L203_204 L41_69 0.0595
K17509 L203_204 L171_172 0.0371
K17510 L203_204 L104_105 0.0265
K17511 L203_204 L151_210 0.0618
K17512 L203_204 L37_38 0.037
K17513 L203_204 L112_113 0.0405
K17514 L203_204 L183_184 0.0219
K17515 L203_204 L59_60 0.0448
K17516 L203_204 L11_57 0.0364
K17517 L203_204 L38_39 0.0354
K17518 L203_204 L27_28 0.0319
K17519 L203_204 L96_97 0.0274
K17520 L203_204 L78_79 0.0653
K17521 L203_204 L44_45 0.0322
K17522 L203_204 L47_48 0.0372
K17523 L203_204 L29_30 0.03
K17524 L203_204 L76_77 0.1743
K17525 L203_204 L166_167 0.0346
K17526 L203_204 L185_186 0.0207
K17527 L203_204 L16_17 0.0231
K17528 L203_204 L118_119 0.04
K17529 L203_204 L176_177 0.0171
K17530 L203_204 L6_53 0.035
K17531 L203_204 L2_3 0.0175
K17532 L203_204 L113_114 0.0382
K17533 L203_204 L48_49 0.0351
K17534 L203_204 L124_125 0.0379
K17535 L203_204 L52_53 0.0381
K17536 L203_204 L141_202 0.066
K17537 L203_204 L87_88 0.0911
K17538 L203_204 L136_137 0.0319
K17539 L203_204 L127_128 0.0451
K17540 L203_204 L181_182 0.0202
K17541 L203_204 L28_29 0.0309
K17542 L203_204 L157_158 0.0268
K17543 L203_204 L129_130 0.0372
K17544 L203_204 L21_22 0.0284
K17545 L203_204 L117_118 0.0427
K17546 L203_204 L51_52 0.0404
K17547 L203_204 L56_57 0.0399
K17548 L203_204 L116_117 0.0437
K17549 L203_204 L7_8 0.0212
K17550 L203_204 L154_155 0.0267
K17551 L203_204 L14_15 0.0206
K17552 L203_204 L184_185 0.0213
K17553 L203_204 L141_142 0.0321
K17554 L203_204 L125_187 0.0231
K17555 L203_204 L58_59 0.046
K17556 L203_204 L70_71 0.2117
K17557 L203_204 L68_69 0.0858
K17558 L203_204 L180_181 0.0207
K17559 L203_204 L89_102 0.032
K17560 L203_204 L26_27 0.033
K17561 L203_204 L50_51 0.0412
K17562 L203_204 L165_166 0.036
K17563 L203_204 L90_91 0.0301
K17564 L203_204 L139_140 0.0273
K17565 L203_204 L161_162 0.032
K17566 L203_204 L111_112 0.0414
K17567 L203_204 L162_163 0.031
K17568 L203_204 L137_138 0.0302
K17569 L203_204 L179_180 0.0213
K17570 L203_204 L12_13 0.0218
K17571 L203_204 L142_143 0.0304
K17572 L203_204 L123_124 0.0419
K17573 L203_204 L191_192 0.2072
K17574 L203_204 L39_40 0.034
K17575 L203_204 L18_19 0.0218
K17576 L203_204 L156_157 0.0276
K17577 L203_204 L54_55 0.0435
K17578 L203_204 L201_202 0.0993
K17579 L203_207 L181_185 0.0182
K17580 L203_207 L140_145 0.0194
K17581 L203_207 L1_6 0.0252
K17582 L203_207 L35_40 0.0251
K17583 L203_207 L73_78 0.0549
K17584 L203_207 L184_188 0.0192
K17585 L203_207 L163_168 0.0263
K17586 L203_207 L91_95 0.0255
K17587 L203_207 L130_160 0.0246
K17588 L203_207 L4_9 0.0177
K17589 L203_207 L202_206 0.0558
K17590 L203_207 L109_114 0.0313
K17591 L203_207 L57_61 0.0336
K17592 L203_207 L164_169 0.0236
K17593 L203_207 L53_57 0.0324
K17594 L203_207 L69_73 0.0541
K17595 L203_207 L200_204 0.1506
K17596 L203_207 L145_150 0.0195
K17597 L203_207 L30_35 0.0236
K17598 L203_207 L131_136 0.0383
K17599 L203_207 L101_105 0.0195
K17600 L203_207 L122_127 0.043
K17601 L203_207 L196_200 0.1402
K17602 L203_207 L92_96 0.0243
K17603 L203_207 L81_86 0.1437
K17604 L203_207 L19_24 0.019
K17605 L203_207 L120_125 0.0269
K17606 L203_207 L8_13 0.0186
K17607 L203_207 L60_64 0.0391
K17608 L203_207 L198_202 0.0553
K17609 L203_207 L193_197 0.0772
K17610 L203_207 L7_12 0.0192
K17611 L203_207 L137_142 0.027
K17612 L203_207 L167_172 0.0292
K17613 L203_207 L97_101 0.0194
K17614 L203_207 L110_115 0.0253
K17615 L203_207 L113_118 0.0358
K17616 L203_207 L134_139 0.0242
K17617 L203_207 L141_146 0.0389
K17618 L203_207 L9_14 0.0181
K17619 L203_207 L138_143 0.0256
K17620 L203_207 L33_38 0.0291
K17621 L203_207 L18_23 0.0196
K17622 L203_207 L124_129 0.035
K17623 L203_207 L107_112 0.0367
K17624 L203_207 L78_83 0.0554
K17625 L203_207 L112_117 0.0385
K17626 L203_207 L40_45 0.0263
K17627 L203_207 L183_187 0.0197
K17628 L203_207 L59_63 0.0427
K17629 L203_207 L5_10 0.0144
K17630 L203_207 L15_20 0.0151
K17631 L203_207 L51_55 0.0384
K17632 L203_207 L67_71 0.1215
K17633 L203_207 L29_34 0.0262
K17634 L203_207 L158_189 0.0191
K17635 L203_207 L206_210 0.056
K17636 L203_207 L41_74 0.0381
K17637 L203_207 L131_170 0.0311
K17638 L203_207 L98_102 0.0271
K17639 L203_207 L27_32 0.0282
K17640 L203_207 L147_152 0.0272
K17641 L203_207 L178_182 0.0144
K17642 L203_207 L180_184 0.0187
K17643 L203_207 L3_8 0.0182
K17644 L203_207 L157_162 0.0252
K17645 L203_207 L149_154 0.0245
K17646 L203_207 L2_7 0.0186
K17647 L203_207 L117_122 0.0406
K17648 L203_207 L38_43 0.0309
K17649 L203_207 L135_174 0.0264
K17650 L203_207 L160_165 0.0268
K17651 L203_207 L52_56 0.0357
K17652 L203_207 L115_120 0.0261
K17653 L203_207 L10_15 0.0147
K17654 L203_207 L16_21 0.0276
K17655 L203_207 L158_163 0.0245
K17656 L203_207 L185_189 0.0186
K17657 L203_207 L96_100 0.0243
K17658 L203_207 L49_53 0.0312
K17659 L203_207 L186_190 0.0151
K17660 L203_207 L82_87 0.0802
K17661 L203_207 L125_130 0.0277
K17662 L203_207 L108_113 0.0343
K17663 L203_207 L159_164 0.0221
K17664 L203_207 L204_208 0.1548
K17665 L203_207 L25_30 0.022
K17666 L203_207 L14_19 0.0186
K17667 L203_207 L44_92 0.0241
K17668 L203_207 L21_26 0.0245
K17669 L203_207 L84_89 0.0388
K17670 L203_207 L74_79 0.0385
K17671 L203_207 L165_170 0.029
K17672 L203_207 L79_84 0.0387
K17673 L203_207 L56_60 0.0373
K17674 L203_207 L93_97 0.0194
K17675 L203_207 L90_94 0.0269
K17676 L203_207 L134_173 0.0296
K17677 L203_207 L139_144 0.0243
K17678 L203_207 L177_181 0.0177
K17679 L203_207 L179_183 0.0192
K17680 L203_207 L162_167 0.0272
K17681 L203_207 L43_91 0.0253
K17682 L203_207 L142_147 0.0271
K17683 L203_207 L135_140 0.0193
K17684 L203_207 L39_44 0.0295
K17685 L203_207 L123_128 0.0393
K17686 L203_207 L12_17 0.0197
K17687 L203_207 L146_151 0.039
K17688 L203_207 L61_65 0.0349
K17689 L203_207 L77_82 0.0797
K17690 L81_82 L167_168 0.0388
K17691 L81_82 L74_90 0.041
K17692 L81_82 L199_200 0.1743
K17693 L81_82 L115_179 0.0241
K17694 L81_82 L196_197 0.2117
K17695 L81_82 L1_2 0.0199
K17696 L81_82 L23_24 0.0302
K17697 L81_82 L158_159 0.0293
K17698 L81_82 L163_164 0.0341
K17699 L81_82 L91_92 0.0359
K17700 L81_82 L160_161 0.0377
K17701 L81_82 L126_127 0.0449
K17702 L81_82 L138_139 0.0357
K17703 L81_82 L153_154 0.037
K17704 L81_82 L4_5 0.0184
K17705 L81_82 L41_42 0.0472
K17706 L81_82 L200_201 0.2659
K17707 L81_82 L36_37 0.0471
K17708 L81_82 L131_132 0.0468
K17709 L81_82 L122_123 0.046
K17710 L81_82 L92_93 0.0338
K17711 L81_82 L19_20 0.0238
K17712 L81_82 L187_188 0.0252
K17713 L81_82 L102_103 0.0405
K17714 L81_82 L106_107 0.0372
K17715 L81_82 L64_65 0.0451
K17716 L81_82 L8_9 0.023
K17717 L81_82 L170_171 0.0468
K17718 L81_82 L193_194 0.1387
K17719 L81_82 L21_65 0.0416
K17720 L81_82 L121_122 0.0448
K17721 L81_82 L9_10 0.0224
K17722 L81_82 L195_196 0.1537
K17723 L81_82 L134_135 0.0393
K17724 L81_82 L41_69 0.0877
K17725 L81_82 L171_172 0.0445
K17726 L81_82 L104_105 0.0346
K17727 L81_82 L151_210 0.0911
K17728 L81_82 L37_38 0.0448
K17729 L81_82 L112_113 0.0412
K17730 L81_82 L183_184 0.0243
K17731 L81_82 L59_60 0.0462
K17732 L81_82 L11_57 0.04
K17733 L81_82 L38_39 0.0426
K17734 L81_82 L27_28 0.0366
K17735 L81_82 L96_97 0.0341
K17736 L81_82 L78_79 0.0993
K17737 L81_82 L44_45 0.0395
K17738 L81_82 L47_48 0.0381
K17739 L81_82 L29_30 0.0342
K17740 L81_82 L76_77 0.3334
K17741 L81_82 L166_167 0.0404
K17742 L81_82 L185_186 0.023
K17743 L81_82 L16_17 0.026
K17744 L81_82 L118_119 0.0425
K17745 L81_82 L176_177 0.0189
K17746 L81_82 L6_53 0.0382
K17747 L81_82 L2_3 0.0194
K17748 L81_82 L113_114 0.0404
K17749 L81_82 L48_49 0.0373
K17750 L81_82 L124_125 0.0418
K17751 L81_82 L52_53 0.0405
K17752 L81_82 L141_202 0.0969
K17753 L81_82 L87_88 0.1877
K17754 L81_82 L136_137 0.0407
K17755 L81_82 L127_128 0.0462
K17756 L81_82 L181_182 0.0224
K17757 L81_82 L28_29 0.0354
K17758 L81_82 L157_158 0.0302
K17759 L81_82 L129_130 0.0414
K17760 L81_82 L21_22 0.0321
K17761 L81_82 L117_118 0.0435
K17762 L81_82 L51_52 0.0414
K17763 L81_82 L56_57 0.0427
K17764 L81_82 L116_117 0.0425
K17765 L81_82 L7_8 0.0236
K17766 L81_82 L154_155 0.0343
K17767 L81_82 L14_15 0.0231
K17768 L81_82 L184_185 0.0237
K17769 L81_82 L141_142 0.0413
K17770 L81_82 L125_187 0.0259
K17771 L81_82 L58_59 0.045
K17772 L81_82 L70_71 0.1646
K17773 L81_82 L68_69 0.1475
K17774 L81_82 L180_181 0.0229
K17775 L81_82 L89_102 0.0444
K17776 L81_82 L26_27 0.0378
K17777 L81_82 L50_51 0.0405
K17778 L81_82 L165_166 0.0421
K17779 L81_82 L90_91 0.0383
K17780 L81_82 L139_140 0.0336
K17781 L81_82 L161_162 0.0364
K17782 L81_82 L111_112 0.0404
K17783 L81_82 L162_163 0.0353
K17784 L81_82 L137_138 0.038
K17785 L81_82 L179_180 0.0235
K17786 L81_82 L12_13 0.0244
K17787 L81_82 L142_143 0.0385
K17788 L81_82 L123_124 0.0448
K17789 L81_82 L191_192 0.1387
K17790 L81_82 L39_40 0.0406
K17791 L81_82 L18_19 0.0245
K17792 L81_82 L156_157 0.0311
K17793 L81_82 L54_55 0.0427
K17794 L81_82 L201_202 0.1743
K17795 L81_86 L181_185 0.0227
K17796 L81_86 L140_145 0.0248
K17797 L81_86 L1_6 0.0315
K17798 L81_86 L35_40 0.0318
K17799 L81_86 L73_78 0.0733
K17800 L81_86 L163_168 0.0331
K17801 L81_86 L91_95 0.0329
K17802 L81_86 L130_160 0.0308
K17803 L81_86 L4_9 0.0221
K17804 L81_86 L202_206 0.0734
K17805 L81_86 L109_114 0.0389
K17806 L81_86 L57_61 0.0421
K17807 L81_86 L164_169 0.0297
K17808 L81_86 L195_199 0.1322
K17809 L81_86 L9_14 0.0227
K17810 L81_86 L53_57 0.0405
K17811 L81_86 L69_73 0.072
K17812 L81_86 L145_150 0.0249
K17813 L81_86 L30_35 0.0298
K17814 L81_86 L131_136 0.0495
K17815 L81_86 L101_105 0.025
K17816 L81_86 L46_50 0.0367
K17817 L81_86 L92_96 0.0312
K17818 L81_86 L19_24 0.0239
K17819 L81_86 L120_125 0.0336
K17820 L81_86 L8_13 0.0234
K17821 L81_86 L60_64 0.0489
K17822 L81_86 L198_202 0.0726
K17823 L81_86 L193_197 0.1034
K17824 L81_86 L7_12 0.024
K17825 L81_86 L137_142 0.0347
K17826 L81_86 L167_172 0.0369
K17827 L81_86 L121_126 0.0427
K17828 L81_86 L97_101 0.025
K17829 L81_86 L110_115 0.0315
K17830 L81_86 L141_146 0.0503
K17831 L81_86 L138_143 0.0328
K17832 L81_86 L33_38 0.0371
K17833 L81_86 L18_23 0.0247
K17834 L81_86 L124_129 0.0437
K17835 L81_86 L78_83 0.0741
K17836 L81_86 L134_139 0.0309
K17837 L81_86 L40_45 0.0336
K17838 L81_86 L183_187 0.0247
K17839 L81_86 L5_10 0.018
K17840 L81_86 L15_20 0.0189
K17841 L81_86 L58_62 0.043
K17842 L81_86 L29_34 0.0331
K17843 L81_86 L179_183 0.024
K17844 L81_86 L158_189 0.0239
K17845 L81_86 L206_210 0.0736
K17846 L81_86 L41_74 0.0498
K17847 L81_86 L131_170 0.0397
K17848 L81_86 L191_195 0.1215
K17849 L81_86 L66_70 0.1273
K17850 L81_86 L98_102 0.0351
K17851 L81_86 L27_32 0.0357
K17852 L81_86 L147_152 0.0349
K17853 L81_86 L178_182 0.0179
K17854 L81_86 L180_184 0.0233
K17855 L81_86 L3_8 0.0227
K17856 L81_86 L157_162 0.0316
K17857 L81_86 L149_154 0.0313
K17858 L81_86 L2_7 0.0233
K17859 L81_86 L38_43 0.0395
K17860 L81_86 L113_118 0.0443
K17861 L81_86 L108_113 0.0423
K17862 L81_86 L135_174 0.0335
K17863 L81_86 L160_165 0.0337
K17864 L81_86 L52_56 0.0444
K17865 L81_86 L115_120 0.0325
K17866 L81_86 L80_85 0.1548
K17867 L81_86 L10_15 0.0184
K17868 L81_86 L16_21 0.0348
K17869 L81_86 L158_163 0.0306
K17870 L81_86 L185_189 0.0233
K17871 L81_86 L96_100 0.0313
K17872 L81_86 L49_53 0.039
K17873 L81_86 L186_190 0.0189
K17874 L81_86 L82_87 0.1145
K17875 L81_86 L125_130 0.0347
K17876 L81_86 L184_188 0.024
K17877 L81_86 L159_164 0.0276
K17878 L81_86 L84_89 0.0507
K17879 L81_86 L25_30 0.0277
K17880 L81_86 L14_19 0.0233
K17881 L81_86 L44_92 0.031
K17882 L81_86 L21_26 0.0309
K17883 L81_86 L74_79 0.0503
K17884 L81_86 L165_170 0.0368
K17885 L81_86 L199_203 0.1405
K17886 L81_86 L75_80 0.1506
K17887 L81_86 L70_75 0.1402
K17888 L81_86 L50_54 0.0385
K17889 L81_86 L79_84 0.0506
K17890 L81_86 L56_60 0.0466
K17891 L81_86 L93_97 0.0249
K17892 L81_86 L90_94 0.0349
K17893 L81_86 L134_173 0.0376
K17894 L81_86 L139_144 0.0311
K17895 L81_86 L177_181 0.0221
K17896 L81_86 L111_116 0.0384
K17897 L81_86 L162_167 0.0343
K17898 L81_86 L43_91 0.0327
K17899 L81_86 L142_147 0.0349
K17900 L81_86 L135_140 0.0246
K17901 L81_86 L39_44 0.0377
K17902 L81_86 L123_128 0.0487
K17903 L81_86 L12_17 0.0247
K17904 L81_86 L54_58 0.0406
K17905 L81_86 L146_151 0.0504
K17906 L81_86 L61_65 0.0439
K17907 L81_86 L77_82 0.1134
K17908 L185_186 L167_168 0.0606
K17909 L185_186 L74_90 0.0246
K17910 L185_186 L199_200 0.0212
K17911 L185_186 L115_179 0.1124
K17912 L185_186 L196_197 0.0245
K17913 L185_186 L1_2 0.0814
K17914 L185_186 L23_24 0.1234
K17915 L185_186 L158_159 0.1436
K17916 L185_186 L163_164 0.0927
K17917 L185_186 L91_92 0.025
K17918 L185_186 L160_161 0.0821
K17919 L185_186 L126_127 0.0255
K17920 L185_186 L204_205 0.0231
K17921 L185_186 L153_154 0.0178
K17922 L185_186 L4_5 0.1183
K17923 L185_186 L41_42 0.0328
K17924 L185_186 L200_201 0.0238
K17925 L185_186 L36_37 0.0438
K17926 L185_186 L131_132 0.0331
K17927 L185_186 L100_101 0.0223
K17928 L185_186 L92_93 0.025
K17929 L185_186 L148_149 0.0223
K17930 L185_186 L19_20 0.1536
K17931 L185_186 L187_188 0.1439
K17932 L185_186 L165_166 0.0578
K17933 L185_186 L102_103 0.0176
K17934 L185_186 L106_107 0.0299
K17935 L185_186 L64_65 0.041
K17936 L185_186 L26_27 0.0795
K17937 L185_186 L170_171 0.0442
K17938 L185_186 L193_194 0.0267
K17939 L185_186 L21_65 0.0586
K17940 L185_186 L121_122 0.0275
K17941 L185_186 L9_10 0.1536
K17942 L185_186 L195_196 0.0217
K17943 L185_186 L134_135 0.0338
K17944 L185_186 L41_69 0.03
K17945 L185_186 L171_172 0.045
K17946 L185_186 L104_105 0.0177
K17947 L185_186 L151_210 0.0255
K17948 L185_186 L138_139 0.0251
K17949 L185_186 L37_38 0.0445
K17950 L185_186 L112_113 0.0416
K17951 L185_186 L59_60 0.0339
K17952 L185_186 L129_130 0.0597
K17953 L185_186 L38_39 0.045
K17954 L185_186 L27_28 0.0843
K17955 L185_186 L96_97 0.0236
K17956 L185_186 L78_79 0.0295
K17957 L185_186 L44_45 0.0335
K17958 L185_186 L47_48 0.0384
K17959 L185_186 L29_30 0.0888
K17960 L185_186 L76_77 0.0238
K17961 L185_186 L166_167 0.0595
K17962 L185_186 L16_17 0.1015
K17963 L185_186 L176_177 0.1362
K17964 L185_186 L149_150 0.0224
K17965 L185_186 L2_3 0.0969
K17966 L185_186 L98_99 0.0221
K17967 L185_186 L6_53 0.095
K17968 L185_186 L84_98 0.022
K17969 L185_186 L48_49 0.0537
K17970 L185_186 L124_125 0.0656
K17971 L185_186 L113_114 0.0589
K17972 L185_186 L52_53 0.0579
K17973 L185_186 L80_81 0.0206
K17974 L185_186 L141_202 0.0296
K17975 L185_186 L87_88 0.0233
K17976 L185_186 L146_147 0.0221
K17977 L185_186 L136_137 0.0247
K17978 L185_186 L127_128 0.0316
K17979 L185_186 L181_182 0.2054
K17980 L185_186 L28_29 0.0876
K17981 L185_186 L157_158 0.1375
K17982 L185_186 L122_123 0.0341
K17983 L185_186 L21_22 0.1001
K17984 L185_186 L51_52 0.0413
K17985 L185_186 L154_155 0.0178
K17986 L185_186 L7_8 0.1226
K17987 L185_186 L82_83 0.0257
K17988 L185_186 L58_59 0.0274
K17989 L185_186 L141_142 0.0233
K17990 L185_186 L125_187 0.1124
K17991 L185_186 L70_71 0.0217
K17992 L185_186 L68_69 0.0266
K17993 L185_186 L180_181 0.1832
K17994 L185_186 L89_102 0.0175
K17995 L185_186 L8_9 0.1438
K17996 L185_186 L50_51 0.032
K17997 L185_186 L90_91 0.0248
K17998 L185_186 L139_140 0.0252
K17999 L185_186 L161_162 0.0875
K18000 L185_186 L111_112 0.0321
K18001 L185_186 L162_163 0.0913
K18002 L185_186 L137_138 0.025
K18003 L185_186 L179_180 0.1439
K18004 L185_186 L142_143 0.0235
K18005 L185_186 L123_124 0.0449
K18006 L185_186 L191_192 0.0206
K18007 L185_186 L39_40 0.0451
K18008 L185_186 L156_157 0.1231
K18009 L185_186 L18_19 0.1438
K18010 L185_186 L201_202 0.0267
K18011 L8_13 L181_185 0.1536
K18012 L8_13 L140_145 0.0204
K18013 L8_13 L1_6 0.0991
K18014 L8_13 L35_40 0.0463
K18015 L8_13 L73_78 0.0315
K18016 L8_13 L163_168 0.0699
K18017 L8_13 L130_160 0.1381
K18018 L8_13 L4_9 0.1832
K18019 L8_13 L202_206 0.03
K18020 L8_13 L109_114 0.059
K18021 L8_13 L57_61 0.0599
K18022 L8_13 L164_169 0.0625
K18023 L8_13 L195_199 0.0196
K18024 L8_13 L53_57 0.0602
K18025 L8_13 L69_73 0.033
K18026 L8_13 L200_204 0.024
K18027 L8_13 L145_150 0.0193
K18028 L8_13 L30_35 0.0641
K18029 L8_13 L131_136 0.0326
K18030 L8_13 L101_105 0.0183
K18031 L8_13 L46_50 0.0257
K18032 L8_13 L196_200 0.0246
K18033 L8_13 L92_96 0.025
K18034 L8_13 L19_24 0.1439
K18035 L8_13 L120_125 0.0941
K18036 L8_13 L160_165 0.0844
K18037 L8_13 L185_189 0.1438
K18038 L8_13 L60_64 0.0423
K18039 L8_13 L198_202 0.0314
K18040 L8_13 L193_197 0.0289
K18041 L8_13 L7_12 0.2054
K18042 L8_13 L137_142 0.0248
K18043 L8_13 L121_126 0.0255
K18044 L8_13 L97_101 0.0194
K18045 L8_13 L110_115 0.0941
K18046 L8_13 L113_118 0.0424
K18047 L8_13 L141_146 0.0291
K18048 L8_13 L9_14 0.2054
K18049 L8_13 L134_139 0.0265
K18050 L8_13 L124_129 0.0581
K18051 L8_13 L107_112 0.0329
K18052 L8_13 L78_83 0.0301
K18053 L8_13 L112_117 0.033
K18054 L8_13 L40_45 0.036
K18055 L8_13 L183_187 0.1438
K18056 L8_13 L59_63 0.0329
K18057 L8_13 L5_10 0.1144
K18058 L8_13 L15_20 0.1144
K18059 L8_13 L51_55 0.0331
K18060 L8_13 L58_62 0.0256
K18061 L8_13 L67_71 0.0254
K18062 L8_13 L29_34 0.0718
K18063 L8_13 L179_183 0.1536
K18064 L8_13 L158_189 0.1226
K18065 L8_13 L206_210 0.0288
K18066 L8_13 L41_74 0.0327
K18067 L8_13 L131_170 0.0422
K18068 L8_13 L191_195 0.0201
K18069 L8_13 L66_70 0.0202
K18070 L8_13 L98_102 0.0222
K18071 L8_13 L27_32 0.098
K18072 L8_13 L142_147 0.0234
K18073 L8_13 L147_152 0.0221
K18074 L8_13 L178_182 0.0988
K18075 L8_13 L149_154 0.0221
K18076 L8_13 L2_7 0.1832
K18077 L8_13 L117_122 0.0329
K18078 L8_13 L135_174 0.0357
K18079 L8_13 L52_56 0.0427
K18080 L8_13 L115_120 0.0958
K18081 L8_13 L80_85 0.0187
K18082 L8_13 L10_15 0.1216
K18083 L8_13 L16_21 0.0939
K18084 L8_13 L158_163 0.1101
K18085 L8_13 L96_100 0.0235
K18086 L8_13 L49_53 0.0599
K18087 L8_13 L186_190 0.0988
K18088 L8_13 L82_87 0.0261
K18089 L8_13 L125_130 0.0897
K18090 L8_13 L108_113 0.0423
K18091 L8_13 L159_164 0.094
K18092 L8_13 L84_89 0.0277
K18093 L8_13 L204_208 0.0233
K18094 L8_13 L25_30 0.1
K18095 L8_13 L14_19 0.1832
K18096 L8_13 L44_92 0.0266
K18097 L8_13 L21_26 0.1607
K18098 L8_13 L74_79 0.0309
K18099 L8_13 L165_170 0.0568
K18100 L8_13 L199_203 0.0191
K18101 L8_13 L75_80 0.0192
K18102 L8_13 L70_75 0.0197
K18103 L8_13 L50_54 0.0257
K18104 L8_13 L79_84 0.0292
K18105 L8_13 L56_60 0.0426
K18106 L8_13 L93_97 0.0206
K18107 L8_13 L90_94 0.025
K18108 L8_13 L134_173 0.0391
K18109 L8_13 L139_144 0.0248
K18110 L8_13 L177_181 0.1438
K18111 L8_13 L111_116 0.0256
K18112 L8_13 L122_127 0.0328
K18113 L8_13 L135_140 0.0218
K18114 L8_13 L39_44 0.0394
K18115 L8_13 L123_128 0.042
K18116 L8_13 L12_17 0.1832
K18117 L8_13 L54_58 0.0257
K18118 L8_13 L146_151 0.0276
K18119 L8_13 L61_65 0.059
K18120 L8_13 L77_82 0.027
K18121 L185_189 L140_145 0.0221
K18122 L185_189 L1_6 0.0775
K18123 L185_189 L35_40 0.0516
K18124 L185_189 L73_78 0.0318
K18125 L185_189 L184_188 0.2054
K18126 L185_189 L91_95 0.0265
K18127 L185_189 L130_160 0.1376
K18128 L185_189 L202_206 0.0306
K18129 L185_189 L109_114 0.0537
K18130 L185_189 L57_61 0.054
K18131 L185_189 L164_169 0.0777
K18132 L185_189 L195_199 0.0196
K18133 L185_189 L53_57 0.0537
K18134 L185_189 L69_73 0.0332
K18135 L185_189 L200_204 0.0239
K18136 L185_189 L145_150 0.0207
K18137 L185_189 L30_35 0.0748
K18138 L185_189 L131_136 0.0339
K18139 L185_189 L101_105 0.0194
K18140 L185_189 L46_50 0.0243
K18141 L185_189 L196_200 0.0246
K18142 L185_189 L120_125 0.0844
K18143 L185_189 L60_64 0.0395
K18144 L185_189 L198_202 0.032
K18145 L185_189 L193_197 0.029
K18146 L185_189 L7_12 0.1127
K18147 L185_189 L137_142 0.0263
K18148 L185_189 L167_172 0.0718
K18149 L185_189 L121_126 0.0244
K18150 L185_189 L97_101 0.0206
K18151 L185_189 L110_115 0.0802
K18152 L185_189 L141_146 0.0303
K18153 L185_189 L122_127 0.0313
K18154 L185_189 L138_143 0.0266
K18155 L185_189 L33_38 0.0699
K18156 L185_189 L18_23 0.1438
K18157 L185_189 L124_129 0.0544
K18158 L185_189 L107_112 0.0312
K18159 L185_189 L78_83 0.0305
K18160 L185_189 L112_117 0.0313
K18161 L185_189 L40_45 0.0391
K18162 L185_189 L183_187 0.1354
K18163 L185_189 L59_63 0.0312
K18164 L185_189 L5_10 0.1062
K18165 L185_189 L15_20 0.1363
K18166 L185_189 L51_55 0.0312
K18167 L185_189 L58_62 0.0243
K18168 L185_189 L67_71 0.0251
K18169 L185_189 L179_183 0.1284
K18170 L185_189 L206_210 0.0293
K18171 L185_189 L41_74 0.0337
K18172 L185_189 L131_170 0.0456
K18173 L185_189 L191_195 0.02
K18174 L185_189 L2_7 0.1015
K18175 L185_189 L98_102 0.0232
K18176 L185_189 L27_32 0.0989
K18177 L185_189 L147_152 0.0233
K18178 L185_189 L178_182 0.1268
K18179 L185_189 L180_184 0.1832
K18180 L185_189 L3_8 0.1226
K18181 L185_189 L157_162 0.2276
K18182 L185_189 L66_70 0.02
K18183 L185_189 L117_122 0.0314
K18184 L185_189 L38_43 0.0503
K18185 L185_189 L135_174 0.0395
K18186 L185_189 L160_165 0.0937
K18187 L185_189 L52_56 0.0395
K18188 L185_189 L115_120 0.0833
K18189 L185_189 L80_85 0.0186
K18190 L185_189 L10_15 0.1266
K18191 L185_189 L16_21 0.0803
K18192 L185_189 L113_118 0.0398
K18193 L185_189 L49_53 0.0531
K18194 L185_189 L186_190 0.1916
K18195 L185_189 L125_130 0.0833
K18196 L185_189 L108_113 0.0395
K18197 L185_189 L159_164 0.1431
K18198 L185_189 L84_89 0.0286
K18199 L185_189 L204_208 0.0233
K18200 L185_189 L25_30 0.126
K18201 L185_189 L82_87 0.0261
K18202 L185_189 L21_26 0.1234
K18203 L185_189 L74_79 0.0319
K18204 L185_189 L165_170 0.0624
K18205 L185_189 L199_203 0.0191
K18206 L185_189 L75_80 0.019
K18207 L185_189 L70_75 0.0195
K18208 L185_189 L50_54 0.0243
K18209 L185_189 L79_84 0.0301
K18210 L185_189 L56_60 0.0396
K18211 L185_189 L93_97 0.022
K18212 L185_189 L90_94 0.0262
K18213 L185_189 L111_116 0.0244
K18214 L185_189 L162_167 0.1187
K18215 L185_189 L43_91 0.0283
K18216 L185_189 L142_147 0.0247
K18217 L185_189 L135_140 0.0237
K18218 L185_189 L123_128 0.0398
K18219 L185_189 L12_17 0.1173
K18220 L185_189 L54_58 0.0244
K18221 L185_189 L146_151 0.0287
K18222 L185_189 L61_65 0.0537
K18223 L185_189 L77_82 0.027
K18224 L198_202 L140_145 0.0423
K18225 L198_202 L1_6 0.0413
K18226 L198_202 L35_40 0.0493
K18227 L198_202 L184_188 0.033
K18228 L198_202 L163_168 0.0491
K18229 L198_202 L91_95 0.0593
K18230 L198_202 L130_160 0.0434
K18231 L198_202 L4_9 0.0292
K18232 L198_202 L181_185 0.0306
K18233 L198_202 L164_169 0.0438
K18234 L198_202 L9_14 0.0305
K18235 L198_202 L200_204 0.0741
K18236 L198_202 L145_150 0.0421
K18237 L198_202 L30_35 0.0436
K18238 L198_202 L131_136 0.1086
K18239 L198_202 L101_105 0.0412
K18240 L198_202 L46_50 0.0336
K18241 L198_202 L196_200 0.0744
K18242 L198_202 L92_96 0.054
K18243 L198_202 L19_24 0.0332
K18244 L198_202 L120_125 0.046
K18245 L198_202 L60_64 0.054
K18246 L198_202 L193_197 0.1134
K18247 L198_202 L7_12 0.0322
K18248 L198_202 L137_142 0.0671
K18249 L198_202 L167_172 0.0597
K18250 L198_202 L121_126 0.0378
K18251 L198_202 L195_199 0.056
K18252 L198_202 L97_101 0.0417
K18253 L198_202 L110_115 0.0415
K18254 L198_202 L113_118 0.0489
K18255 L198_202 L134_139 0.0544
K18256 L198_202 L141_146 0.1086
K18257 L198_202 L138_143 0.0602
K18258 L198_202 L33_38 0.0592
K18259 L198_202 L18_23 0.0344
K18260 L198_202 L107_112 0.0421
K18261 L198_202 L112_117 0.0439
K18262 L198_202 L40_45 0.0549
K18263 L198_202 L183_187 0.034
K18264 L198_202 L59_63 0.0474
K18265 L198_202 L5_10 0.0237
K18266 L198_202 L15_20 0.0257
K18267 L198_202 L51_55 0.0437
K18268 L198_202 L58_62 0.0376
K18269 L198_202 L67_71 0.0734
K18270 L198_202 L29_34 0.0488
K18271 L198_202 L179_183 0.0324
K18272 L198_202 L41_74 0.1053
K18273 L198_202 L131_170 0.0735
K18274 L198_202 L191_195 0.0558
K18275 L198_202 L66_70 0.0554
K18276 L198_202 L98_102 0.0643
K18277 L198_202 L27_32 0.0534
K18278 L198_202 L142_147 0.0667
K18279 L198_202 L147_152 0.0654
K18280 L198_202 L178_182 0.0238
K18281 L198_202 L180_184 0.0315
K18282 L198_202 L3_8 0.03
K18283 L198_202 L157_162 0.0444
K18284 L198_202 L149_154 0.0537
K18285 L198_202 L2_7 0.0308
K18286 L198_202 L117_122 0.0457
K18287 L198_202 L158_189 0.0334
K18288 L198_202 L38_43 0.0678
K18289 L198_202 L135_174 0.0554
K18290 L198_202 L160_165 0.0513
K18291 L198_202 L52_56 0.0487
K18292 L198_202 L115_120 0.0437
K18293 L198_202 L80_85 0.0549
K18294 L198_202 L10_15 0.0247
K18295 L198_202 L16_21 0.0484
K18296 L198_202 L158_163 0.0429
K18297 L198_202 L96_100 0.0537
K18298 L198_202 L165_170 0.0615
K18299 L198_202 L186_190 0.0258
K18300 L198_202 L82_87 0.1076
K18301 L198_202 L125_130 0.0487
K18302 L198_202 L108_113 0.0466
K18303 L198_202 L159_164 0.0385
K18304 L198_202 L84_89 0.1022
K18305 L198_202 L204_208 0.0733
K18306 L198_202 L25_30 0.0384
K18307 L198_202 L14_19 0.0318
K18308 L198_202 L44_92 0.0537
K18309 L198_202 L21_26 0.0431
K18310 L198_202 L74_79 0.1064
K18311 L198_202 L199_203 0.0558
K18312 L198_202 L75_80 0.0554
K18313 L198_202 L70_75 0.0555
K18314 L198_202 L50_54 0.0349
K18315 L198_202 L79_84 0.1053
K18316 L198_202 L56_60 0.0513
K18317 L198_202 L93_97 0.0418
K18318 L198_202 L90_94 0.0659
K18319 L198_202 L134_173 0.0634
K18320 L198_202 L139_144 0.0546
K18321 L198_202 L177_181 0.0293
K18322 L198_202 L111_116 0.035
K18323 L198_202 L162_167 0.0514
K18324 L198_202 L43_91 0.059
K18325 L198_202 L122_127 0.0476
K18326 L198_202 L135_140 0.0421
K18327 L198_202 L39_44 0.0628
K18328 L198_202 L123_128 0.0543
K18329 L198_202 L12_17 0.0338
K18330 L198_202 L54_58 0.0362
K18331 L198_202 L146_151 0.1051
K18332 L198_202 L77_82 0.1104
K18333 L26_27 L167_168 0.1153
K18334 L26_27 L74_90 0.042
K18335 L26_27 L199_200 0.0339
K18336 L26_27 L115_179 0.0766
K18337 L26_27 L196_197 0.0406
K18338 L26_27 L1_2 0.063
K18339 L26_27 L23_24 0.1386
K18340 L26_27 L158_159 0.1183
K18341 L26_27 L91_92 0.0415
K18342 L26_27 L126_127 0.0473
K18343 L26_27 L204_205 0.0377
K18344 L26_27 L153_154 0.0283
K18345 L26_27 L4_5 0.058
K18346 L26_27 L41_42 0.0579
K18347 L26_27 L200_201 0.0391
K18348 L26_27 L50_51 0.0475
K18349 L26_27 L131_132 0.0572
K18350 L26_27 L100_101 0.0357
K18351 L26_27 L92_93 0.0409
K18352 L26_27 L148_149 0.0359
K18353 L26_27 L19_20 0.0947
K18354 L26_27 L187_188 0.1035
K18355 L26_27 L165_166 0.1221
K18356 L26_27 L102_103 0.0286
K18357 L26_27 L106_107 0.0437
K18358 L26_27 L64_65 0.096
K18359 L26_27 L8_9 0.0757
K18360 L26_27 L170_171 0.0817
K18361 L26_27 L193_194 0.0456
K18362 L26_27 L21_65 0.1608
K18363 L26_27 L121_122 0.0496
K18364 L26_27 L9_10 0.0722
K18365 L26_27 L195_196 0.0349
K18366 L26_27 L134_135 0.0554
K18367 L26_27 L41_69 0.053
K18368 L26_27 L171_172 0.0811
K18369 L26_27 L104_105 0.0282
K18370 L26_27 L151_210 0.0424
K18371 L26_27 L37_38 0.0827
K18372 L26_27 L112_113 0.0601
K18373 L26_27 L183_184 0.0876
K18374 L26_27 L59_60 0.0659
K18375 L26_27 L11_57 0.1179
K18376 L26_27 L38_39 0.0811
K18377 L26_27 L78_79 0.0507
K18378 L26_27 L44_45 0.0559
K18379 L26_27 L47_48 0.0559
K18380 L26_27 L76_77 0.0392
K18381 L26_27 L166_167 0.1203
K18382 L26_27 L16_17 0.1123
K18383 L26_27 L118_119 0.0852
K18384 L26_27 L176_177 0.0591
K18385 L26_27 L6_53 0.1029
K18386 L26_27 L149_150 0.0355
K18387 L26_27 L2_3 0.0624
K18388 L26_27 L98_99 0.0363
K18389 L26_27 L84_98 0.0364
K18390 L26_27 L48_49 0.0733
K18391 L26_27 L124_125 0.1312
K18392 L26_27 L113_114 0.079
K18393 L26_27 L52_53 0.0802
K18394 L26_27 L80_81 0.0331
K18395 L26_27 L141_202 0.0504
K18396 L26_27 L87_88 0.0387
K18397 L26_27 L146_147 0.0362
K18398 L26_27 L136_137 0.0417
K18399 L26_27 L127_128 0.0634
K18400 L26_27 L138_139 0.0412
K18401 L26_27 L181_182 0.0704
K18402 L26_27 L157_158 0.1299
K18403 L26_27 L122_123 0.0652
K18404 L26_27 L96_97 0.0381
K18405 L26_27 L129_130 0.1489
K18406 L26_27 L21_22 0.1549
K18407 L26_27 L117_118 0.0627
K18408 L26_27 L51_52 0.0607
K18409 L26_27 L56_57 0.0868
K18410 L26_27 L116_117 0.0484
K18411 L26_27 L154_155 0.028
K18412 L26_27 L7_8 0.0781
K18413 L26_27 L82_83 0.043
K18414 L26_27 L14_15 0.0821
K18415 L26_27 L184_185 0.0843
K18416 L26_27 L141_142 0.0387
K18417 L26_27 L125_187 0.1055
K18418 L26_27 L58_59 0.0499
K18419 L26_27 L70_71 0.035
K18420 L26_27 L68_69 0.0459
K18421 L26_27 L180_181 0.0736
K18422 L26_27 L89_102 0.0287
K18423 L26_27 L36_37 0.0832
K18424 L26_27 L90_91 0.0419
K18425 L26_27 L139_140 0.0406
K18426 L26_27 L111_112 0.0472
K18427 L26_27 L137_138 0.0416
K18428 L26_27 L179_180 0.0758
K18429 L26_27 L12_13 0.0913
K18430 L26_27 L142_143 0.0386
K18431 L26_27 L123_124 0.0918
K18432 L26_27 L191_192 0.0332
K18433 L26_27 L39_40 0.0786
K18434 L26_27 L18_19 0.1032
K18435 L26_27 L156_157 0.1389
K18436 L26_27 L54_55 0.0487
K18437 L26_27 L201_202 0.0449
K18438 L170_171 L167_168 0.12
K18439 L170_171 L74_90 0.0766
K18440 L170_171 L199_200 0.0397
K18441 L170_171 L115_179 0.042
K18442 L170_171 L196_197 0.0503
K18443 L170_171 L1_2 0.0339
K18444 L170_171 L23_24 0.0615
K18445 L170_171 L158_159 0.0609
K18446 L170_171 L163_164 0.0786
K18447 L170_171 L91_92 0.0736
K18448 L170_171 L160_161 0.0832
K18449 L170_171 L126_127 0.0407
K18450 L170_171 L204_205 0.0471
K18451 L170_171 L153_154 0.0456
K18452 L170_171 L4_5 0.033
K18453 L170_171 L41_42 0.118
K18454 L170_171 L200_201 0.0487
K18455 L170_171 L131_132 0.1244
K18456 L170_171 L100_101 0.0569
K18457 L170_171 L92_93 0.0704
K18458 L170_171 L148_149 0.0595
K18459 L170_171 L19_20 0.0475
K18460 L170_171 L187_188 0.0496
K18461 L170_171 L165_166 0.1279
K18462 L170_171 L102_103 0.0456
K18463 L170_171 L106_107 0.0362
K18464 L170_171 L64_65 0.0601
K18465 L170_171 L8_9 0.0412
K18466 L170_171 L193_194 0.0628
K18467 L170_171 L21_65 0.0697
K18468 L170_171 L121_122 0.0419
K18469 L170_171 L9_10 0.0406
K18470 L170_171 L195_196 0.0405
K18471 L170_171 L134_135 0.1073
K18472 L170_171 L41_69 0.0841
K18473 L170_171 L104_105 0.0438
K18474 L170_171 L151_210 0.0636
K18475 L170_171 L184_185 0.045
K18476 L170_171 L112_113 0.0457
K18477 L170_171 L183_184 0.0454
K18478 L170_171 L59_60 0.0499
K18479 L170_171 L11_57 0.0616
K18480 L170_171 L51_52 0.0454
K18481 L170_171 L27_28 0.0811
K18482 L170_171 L78_79 0.0776
K18483 L170_171 L44_45 0.1033
K18484 L170_171 L47_48 0.0419
K18485 L170_171 L29_30 0.0773
K18486 L170_171 L76_77 0.0484
K18487 L170_171 L166_167 0.1258
K18488 L170_171 L16_17 0.0492
K18489 L170_171 L118_119 0.0559
K18490 L170_171 L176_177 0.0338
K18491 L170_171 L6_53 0.0571
K18492 L170_171 L149_150 0.0578
K18493 L170_171 L2_3 0.0338
K18494 L170_171 L98_99 0.0596
K18495 L170_171 L84_98 0.0599
K18496 L170_171 L48_49 0.0479
K18497 L170_171 L124_125 0.0676
K18498 L170_171 L113_114 0.0525
K18499 L170_171 L52_53 0.0521
K18500 L170_171 L80_81 0.0387
K18501 L170_171 L141_202 0.0788
K18502 L170_171 L87_88 0.0519
K18503 L170_171 L146_147 0.061
K18504 L170_171 L136_137 0.079
K18505 L170_171 L127_128 0.0497
K18506 L170_171 L138_139 0.0757
K18507 L170_171 L181_182 0.0409
K18508 L170_171 L28_29 0.0796
K18509 L170_171 L157_158 0.0623
K18510 L170_171 L122_123 0.0502
K18511 L170_171 L96_97 0.063
K18512 L170_171 L129_130 0.0707
K18513 L170_171 L21_22 0.0627
K18514 L170_171 L117_118 0.0479
K18515 L170_171 L56_57 0.0555
K18516 L170_171 L116_117 0.0406
K18517 L170_171 L154_155 0.0445
K18518 L170_171 L7_8 0.0416
K18519 L170_171 L82_83 0.0579
K18520 L170_171 L14_15 0.0438
K18521 L170_171 L141_142 0.0688
K18522 L170_171 L125_187 0.0498
K18523 L170_171 L58_59 0.0418
K18524 L170_171 L70_71 0.0404
K18525 L170_171 L68_69 0.0621
K18526 L170_171 L180_181 0.0415
K18527 L170_171 L89_102 0.0459
K18528 L170_171 L50_51 0.039
K18529 L170_171 L90_91 0.0758
K18530 L170_171 L139_140 0.0722
K18531 L170_171 L161_162 0.0827
K18532 L170_171 L111_112 0.0392
K18533 L170_171 L162_163 0.0811
K18534 L170_171 L137_138 0.0781
K18535 L170_171 L179_180 0.0419
K18536 L170_171 L12_13 0.045
K18537 L170_171 L142_143 0.0683
K18538 L170_171 L123_124 0.0598
K18539 L170_171 L191_192 0.0383
K18540 L170_171 L18_19 0.0484
K18541 L170_171 L156_157 0.0632
K18542 L170_171 L54_55 0.0404
K18543 L170_171 L201_202 0.0616
K18544 L141_142 L167_168 0.049
K18545 L141_142 L74_90 0.1536
K18546 L141_142 L115_179 0.0224
K18547 L141_142 L196_197 0.0533
K18548 L141_142 L1_2 0.0182
K18549 L141_142 L23_24 0.0311
K18550 L141_142 L158_159 0.031
K18551 L141_142 L163_164 0.0381
K18552 L141_142 L91_92 0.1226
K18553 L141_142 L160_161 0.039
K18554 L141_142 L126_127 0.0254
K18555 L141_142 L204_205 0.0416
K18556 L141_142 L153_154 0.0985
K18557 L141_142 L4_5 0.018
K18558 L141_142 L41_42 0.1029
K18559 L141_142 L191_192 0.036
K18560 L141_142 L36_37 0.0673
K18561 L141_142 L131_132 0.1104
K18562 L141_142 L100_101 0.1015
K18563 L141_142 L92_93 0.1015
K18564 L141_142 L148_149 0.1439
K18565 L141_142 L19_20 0.0246
K18566 L141_142 L187_188 0.0251
K18567 L141_142 L165_166 0.0498
K18568 L141_142 L102_103 0.0988
K18569 L141_142 L106_107 0.0226
K18570 L141_142 L64_65 0.0324
K18571 L141_142 L8_9 0.0221
K18572 L141_142 L193_194 0.0783
K18573 L141_142 L21_65 0.0348
K18574 L141_142 L121_122 0.0261
K18575 L141_142 L9_10 0.022
K18576 L141_142 L195_196 0.0387
K18577 L141_142 L134_135 0.091
K18578 L141_142 L41_69 0.1412
K18579 L141_142 L171_172 0.0683
K18580 L141_142 L104_105 0.0759
K18581 L141_142 L151_210 0.0877
K18582 L141_142 L138_139 0.1439
K18583 L141_142 L37_38 0.0668
K18584 L141_142 L98_99 0.1438
K18585 L141_142 L112_113 0.027
K18586 L141_142 L183_184 0.0237
K18587 L141_142 L59_60 0.0293
K18588 L141_142 L11_57 0.0326
K18589 L141_142 L38_39 0.0653
K18590 L141_142 L27_28 0.0386
K18591 L141_142 L44_45 0.0868
K18592 L141_142 L47_48 0.0249
K18593 L141_142 L29_30 0.0379
K18594 L141_142 L166_167 0.0496
K18595 L141_142 L16_17 0.025
K18596 L141_142 L118_119 0.0309
K18597 L141_142 L176_177 0.0182
K18598 L141_142 L6_53 0.0308
K18599 L141_142 L149_150 0.1124
K18600 L141_142 L2_3 0.0182
K18601 L141_142 L84_98 0.1536
K18602 L141_142 L48_49 0.027
K18603 L141_142 L124_125 0.0347
K18604 L141_142 L113_114 0.0294
K18605 L141_142 L52_53 0.0293
K18606 L141_142 L80_81 0.032
K18607 L141_142 L87_88 0.053
K18608 L141_142 L146_147 0.2054
K18609 L141_142 L136_137 0.2054
K18610 L141_142 L127_128 0.029
K18611 L141_142 L181_182 0.0221
K18612 L141_142 L28_29 0.0383
K18613 L141_142 L157_158 0.0313
K18614 L141_142 L122_123 0.0295
K18615 L141_142 L161_162 0.0389
K18616 L141_142 L129_130 0.035
K18617 L141_142 L21_22 0.0314
K18618 L141_142 L117_118 0.0282
K18619 L141_142 L51_52 0.027
K18620 L141_142 L56_57 0.0308
K18621 L141_142 L116_117 0.0252
K18622 L141_142 L154_155 0.0823
K18623 L141_142 L7_8 0.0222
K18624 L141_142 L82_83 0.0579
K18625 L141_142 L14_15 0.0232
K18626 L141_142 L184_185 0.0235
K18627 L141_142 L125_187 0.0252
K18628 L141_142 L58_59 0.026
K18629 L141_142 L70_71 0.0385
K18630 L141_142 L68_69 0.0758
K18631 L141_142 L180_181 0.0222
K18632 L141_142 L89_102 0.1033
K18633 L141_142 L50_51 0.0243
K18634 L141_142 L90_91 0.1438
K18635 L141_142 L139_140 0.1124
K18636 L141_142 L111_112 0.0244
K18637 L141_142 L162_163 0.0386
K18638 L141_142 L137_138 0.1832
K18639 L141_142 L179_180 0.0223
K18640 L141_142 L12_13 0.0235
K18641 L141_142 L123_124 0.0326
K18642 L141_142 L39_40 0.063
K18643 L141_142 L18_19 0.0248
K18644 L141_142 L156_157 0.0315
K18645 L141_142 L54_55 0.0252
K18646 L122_123 L167_168 0.0515
K18647 L122_123 L74_90 0.0307
K18648 L122_123 L199_200 0.0477
K18649 L122_123 L115_179 0.041
K18650 L122_123 L196_197 0.0523
K18651 L122_123 L1_2 0.0336
K18652 L122_123 L23_24 0.0536
K18653 L122_123 L158_159 0.0501
K18654 L122_123 L163_164 0.0532
K18655 L122_123 L91_92 0.0288
K18656 L122_123 L160_161 0.0659
K18657 L122_123 L126_127 0.1877
K18658 L122_123 L204_205 0.0462
K18659 L122_123 L153_154 0.0215
K18660 L122_123 L4_5 0.0278
K18661 L122_123 L41_42 0.0399
K18662 L122_123 L200_201 0.0491
K18663 L122_123 L36_37 0.0499
K18664 L122_123 L131_132 0.04
K18665 L122_123 L100_101 0.0259
K18666 L122_123 L92_93 0.0279
K18667 L122_123 L148_149 0.0267
K18668 L122_123 L165_166 0.0579
K18669 L122_123 L102_103 0.022
K18670 L122_123 L106_107 0.1475
K18671 L122_123 L64_65 0.1674
K18672 L122_123 L193_194 0.0495
K18673 L122_123 L21_65 0.0911
K18674 L122_123 L9_10 0.0336
K18675 L122_123 L195_196 0.0506
K18676 L122_123 L134_135 0.0359
K18677 L122_123 L41_69 0.0447
K18678 L122_123 L171_172 0.048
K18679 L122_123 L104_105 0.0209
K18680 L122_123 L151_210 0.0377
K18681 L122_123 L37_38 0.0477
K18682 L122_123 L112_113 0.2392
K18683 L122_123 L183_184 0.0387
K18684 L122_123 L11_57 0.0969
K18685 L122_123 L38_39 0.0456
K18686 L122_123 L27_28 0.0605
K18687 L122_123 L78_79 0.0439
K18688 L122_123 L44_45 0.0357
K18689 L122_123 L47_48 0.1866
K18690 L122_123 L29_30 0.0528
K18691 L122_123 L76_77 0.0488
K18692 L122_123 L166_167 0.0546
K18693 L122_123 L191_192 0.0495
K18694 L122_123 L118_119 0.1933
K18695 L122_123 L176_177 0.0296
K18696 L122_123 L6_53 0.0931
K18697 L122_123 L149_150 0.026
K18698 L122_123 L2_3 0.0314
K18699 L122_123 L98_99 0.0274
K18700 L122_123 L84_98 0.0281
K18701 L122_123 L48_49 0.1387
K18702 L122_123 L113_114 0.1646
K18703 L122_123 L52_53 0.1537
K18704 L122_123 L80_81 0.0448
K18705 L122_123 L141_202 0.0441
K18706 L122_123 L87_88 0.0401
K18707 L122_123 L146_147 0.0282
K18708 L122_123 L136_137 0.0308
K18709 L122_123 L127_128 0.3407
K18710 L122_123 L138_139 0.0289
K18711 L122_123 L181_182 0.0338
K18712 L122_123 L28_29 0.0564
K18713 L122_123 L157_158 0.0541
K18714 L122_123 L96_97 0.0269
K18715 L122_123 L129_130 0.0934
K18716 L122_123 L21_22 0.0632
K18717 L122_123 L117_118 0.3334
K18718 L122_123 L51_52 0.2117
K18719 L122_123 L56_57 0.1743
K18720 L122_123 L116_117 0.1933
K18721 L122_123 L154_155 0.0209
K18722 L122_123 L7_8 0.038
K18723 L122_123 L82_83 0.0448
K18724 L122_123 L14_15 0.0339
K18725 L122_123 L184_185 0.0363
K18726 L122_123 L70_71 0.0504
K18727 L122_123 L68_69 0.0492
K18728 L122_123 L180_181 0.0359
K18729 L122_123 L89_102 0.0226
K18730 L122_123 L8_9 0.0357
K18731 L122_123 L50_51 0.1537
K18732 L122_123 L90_91 0.0297
K18733 L122_123 L139_140 0.028
K18734 L122_123 L161_162 0.0611
K18735 L122_123 L111_112 0.1646
K18736 L122_123 L162_163 0.0569
K18737 L122_123 L137_138 0.0298
K18738 L122_123 L179_180 0.0383
K18739 L122_123 L12_13 0.0385
K18740 L122_123 L142_143 0.0286
K18741 L122_123 L39_40 0.0436
K18742 L122_123 L156_157 0.0586
K18743 L122_123 L54_55 0.1743
K18744 L122_123 L201_202 0.0477
K18745 L195_199 L181_185 0.0191
K18746 L195_199 L140_145 0.0195
K18747 L195_199 L1_6 0.0268
K18748 L195_199 L35_40 0.026
K18749 L195_199 L73_78 0.0555
K18750 L195_199 L184_188 0.0202
K18751 L195_199 L163_168 0.0275
K18752 L195_199 L91_95 0.0256
K18753 L195_199 L130_160 0.0261
K18754 L195_199 L4_9 0.0186
K18755 L195_199 L202_206 0.0558
K18756 L195_199 L109_114 0.0337
K18757 L195_199 L57_61 0.0362
K18758 L195_199 L164_169 0.0246
K18759 L195_199 L53_57 0.0349
K18760 L195_199 L69_73 0.0554
K18761 L195_199 L200_204 0.1506
K18762 L195_199 L145_150 0.0195
K18763 L195_199 L30_35 0.0246
K18764 L195_199 L131_136 0.0389
K18765 L195_199 L101_105 0.0194
K18766 L195_199 L122_127 0.0484
K18767 L195_199 L196_200 0.1548
K18768 L195_199 L92_96 0.0244
K18769 L195_199 L19_24 0.02
K18770 L195_199 L120_125 0.0286
K18771 L195_199 L60_64 0.0431
K18772 L195_199 L193_197 0.0812
K18773 L195_199 L7_12 0.0203
K18774 L195_199 L137_142 0.0272
K18775 L195_199 L167_172 0.0304
K18776 L195_199 L97_101 0.0194
K18777 L195_199 L110_115 0.0269
K18778 L195_199 L113_118 0.0393
K18779 L195_199 L134_139 0.0244
K18780 L195_199 L141_146 0.0389
K18781 L195_199 L9_14 0.019
K18782 L195_199 L138_143 0.0257
K18783 L195_199 L33_38 0.0303
K18784 L195_199 L18_23 0.0207
K18785 L195_199 L124_129 0.0378
K18786 L195_199 L107_112 0.0406
K18787 L195_199 L78_83 0.0554
K18788 L195_199 L112_117 0.043
K18789 L195_199 L40_45 0.027
K18790 L195_199 L183_187 0.0209
K18791 L195_199 L59_63 0.0481
K18792 L195_199 L5_10 0.0151
K18793 L195_199 L15_20 0.0158
K18794 L195_199 L51_55 0.0427
K18795 L195_199 L67_71 0.1405
K18796 L195_199 L29_34 0.0274
K18797 L195_199 L158_189 0.02
K18798 L195_199 L206_210 0.0553
K18799 L195_199 L41_74 0.0387
K18800 L195_199 L131_170 0.0322
K18801 L195_199 L98_102 0.0269
K18802 L195_199 L27_32 0.0296
K18803 L195_199 L147_152 0.027
K18804 L195_199 L178_182 0.0151
K18805 L195_199 L180_184 0.0197
K18806 L195_199 L3_8 0.0191
K18807 L195_199 L157_162 0.0266
K18808 L195_199 L149_154 0.0243
K18809 L195_199 L2_7 0.0197
K18810 L195_199 L117_122 0.0455
K18811 L195_199 L38_43 0.0318
K18812 L195_199 L135_174 0.0271
K18813 L195_199 L160_165 0.0283
K18814 L195_199 L52_56 0.0391
K18815 L195_199 L115_120 0.0277
K18816 L195_199 L10_15 0.0154
K18817 L195_199 L16_21 0.0294
K18818 L195_199 L158_163 0.0257
K18819 L195_199 L96_100 0.0243
K18820 L195_199 L49_53 0.0336
K18821 L195_199 L186_190 0.0158
K18822 L195_199 L82_87 0.0782
K18823 L195_199 L125_130 0.0295
K18824 L195_199 L108_113 0.0375
K18825 L195_199 L159_164 0.0231
K18826 L195_199 L204_208 0.1402
K18827 L195_199 L25_30 0.0231
K18828 L195_199 L14_19 0.0195
K18829 L195_199 L44_92 0.0243
K18830 L195_199 L21_26 0.026
K18831 L195_199 L84_89 0.0385
K18832 L195_199 L74_79 0.0388
K18833 L195_199 L165_170 0.0304
K18834 L195_199 L79_84 0.0387
K18835 L195_199 L56_60 0.041
K18836 L195_199 L93_97 0.0195
K18837 L195_199 L90_94 0.0271
K18838 L195_199 L134_173 0.0304
K18839 L195_199 L139_144 0.0245
K18840 L195_199 L177_181 0.0186
K18841 L195_199 L179_183 0.0203
K18842 L195_199 L162_167 0.0286
K18843 L195_199 L43_91 0.0256
K18844 L195_199 L142_147 0.0271
K18845 L195_199 L135_140 0.0195
K18846 L195_199 L39_44 0.0303
K18847 L195_199 L123_128 0.0433
K18848 L195_199 L12_17 0.0208
K18849 L195_199 L146_151 0.0387
K18850 L195_199 L61_65 0.0376
K18851 L195_199 L77_82 0.0797
K18852 L97_101 L181_185 0.0194
K18853 L97_101 L1_6 0.0223
K18854 L97_101 L73_78 0.0421
K18855 L97_101 L184_188 0.0204
K18856 L97_101 L163_168 0.0419
K18857 L97_101 L91_95 0.1144
K18858 L97_101 L130_160 0.0289
K18859 L97_101 L4_9 0.0185
K18860 L97_101 L109_114 0.0228
K18861 L97_101 L57_61 0.0248
K18862 L97_101 L53_57 0.0238
K18863 L97_101 L69_73 0.0417
K18864 L97_101 L200_204 0.0249
K18865 L97_101 L131_136 0.0581
K18866 L97_101 L46_50 0.0147
K18867 L97_101 L196_200 0.0249
K18868 L97_101 L92_96 0.1673
K18869 L97_101 L19_24 0.0221
K18870 L97_101 L120_125 0.0246
K18871 L97_101 L60_64 0.0227
K18872 L97_101 L193_197 0.031
K18873 L97_101 L7_12 0.0192
K18874 L97_101 L137_142 0.0789
K18875 L97_101 L167_172 0.0561
K18876 L97_101 L121_126 0.0158
K18877 L97_101 L110_115 0.0222
K18878 L97_101 L113_118 0.0212
K18879 L97_101 L134_139 0.1062
K18880 L97_101 L141_146 0.0604
K18881 L97_101 L9_14 0.0195
K18882 L97_101 L138_143 0.0988
K18883 L97_101 L33_38 0.0575
K18884 L97_101 L18_23 0.0219
K18885 L97_101 L124_129 0.0257
K18886 L97_101 L107_112 0.0184
K18887 L97_101 L78_83 0.0423
K18888 L97_101 L112_117 0.0189
K18889 L97_101 L183_187 0.0202
K18890 L97_101 L59_63 0.0199
K18891 L97_101 L51_55 0.0189
K18892 L97_101 L58_62 0.0158
K18893 L97_101 L67_71 0.0249
K18894 L97_101 L29_34 0.0424
K18895 L97_101 L179_183 0.0191
K18896 L97_101 L206_210 0.0417
K18897 L97_101 L41_74 0.0597
K18898 L97_101 L131_170 0.0672
K18899 L97_101 L191_195 0.0194
K18900 L97_101 L66_70 0.0194
K18901 L97_101 L98_102 0.0861
K18902 L97_101 L27_32 0.0403
K18903 L97_101 L142_147 0.0811
K18904 L97_101 L147_152 0.0789
K18905 L97_101 L180_184 0.0193
K18906 L97_101 L3_8 0.0183
K18907 L97_101 L157_162 0.0321
K18908 L97_101 L149_154 0.1266
K18909 L97_101 L2_7 0.0181
K18910 L97_101 L117_122 0.0193
K18911 L97_101 L158_189 0.022
K18912 L97_101 L38_43 0.0897
K18913 L97_101 L108_113 0.0205
K18914 L97_101 L160_165 0.0364
K18915 L97_101 L52_56 0.0213
K18916 L97_101 L115_120 0.0234
K18917 L97_101 L80_85 0.0195
K18918 L97_101 L16_21 0.026
K18919 L97_101 L158_163 0.0325
K18920 L97_101 L96_100 0.1916
K18921 L97_101 L49_53 0.0229
K18922 L97_101 L82_87 0.0313
K18923 L97_101 L125_130 0.0259
K18924 L97_101 L84_89 0.0615
K18925 L97_101 L204_208 0.0249
K18926 L97_101 L202_206 0.0418
K18927 L97_101 L14_19 0.0207
K18928 L97_101 L44_92 0.1268
K18929 L97_101 L21_26 0.0292
K18930 L97_101 L74_79 0.0615
K18931 L97_101 L165_170 0.0483
K18932 L97_101 L199_203 0.0195
K18933 L97_101 L75_80 0.0195
K18934 L97_101 L70_75 0.0195
K18935 L97_101 L50_54 0.0151
K18936 L97_101 L79_84 0.0622
K18937 L97_101 L56_60 0.0219
K18938 L97_101 L90_94 0.0861
K18939 L97_101 L134_173 0.0934
K18940 L97_101 L139_144 0.1266
K18941 L97_101 L177_181 0.0184
K18942 L97_101 L111_116 0.0151
K18943 L97_101 L162_167 0.041
K18944 L97_101 L43_91 0.0985
K18945 L97_101 L122_127 0.0198
K18946 L97_101 L39_44 0.1012
K18947 L97_101 L123_128 0.0226
K18948 L97_101 L12_17 0.0203
K18949 L97_101 L54_58 0.0155
K18950 L97_101 L146_151 0.0598
K18951 L97_101 L61_65 0.0258
K18952 L97_101 L77_82 0.0314
K18953 L195_196 L167_168 0.0348
K18954 L195_196 L199_200 0.3334
K18955 L195_196 L115_179 0.0231
K18956 L195_196 L1_2 0.019
K18957 L195_196 L23_24 0.0281
K18958 L195_196 L158_159 0.0273
K18959 L195_196 L163_164 0.0314
K18960 L195_196 L160_161 0.035
K18961 L195_196 L126_127 0.0532
K18962 L195_196 L204_205 0.1646
K18963 L195_196 L153_154 0.0277
K18964 L195_196 L4_5 0.0174
K18965 L195_196 L41_42 0.0383
K18966 L195_196 L201_202 0.0993
K18967 L195_196 L191_192 0.4331
K18968 L195_196 L200_201 0.1933
K18969 L195_196 L36_37 0.0404
K18970 L195_196 L131_132 0.0385
K18971 L195_196 L100_101 0.0317
K18972 L195_196 L148_149 0.0338
K18973 L195_196 L19_20 0.0222
K18974 L195_196 L187_188 0.0237
K18975 L195_196 L165_166 0.0379
K18976 L195_196 L102_103 0.0293
K18977 L195_196 L106_107 0.0425
K18978 L195_196 L64_65 0.0459
K18979 L195_196 L8_9 0.0218
K18980 L195_196 L193_194 0.0947
K18981 L195_196 L21_65 0.0402
K18982 L195_196 L121_122 0.0523
K18983 L195_196 L9_10 0.0211
K18984 L195_196 L134_135 0.033
K18985 L195_196 L41_69 0.0615
K18986 L195_196 L171_172 0.0386
K18987 L195_196 L104_105 0.0261
K18988 L195_196 L151_210 0.0594
K18989 L195_196 L37_38 0.0385
K18990 L195_196 L112_113 0.045
K18991 L195_196 L183_184 0.0231
K18992 L195_196 L59_60 0.0504
K18993 L195_196 L11_57 0.0393
K18994 L195_196 L38_39 0.0367
K18995 L195_196 L27_28 0.0336
K18996 L195_196 L78_79 0.0653
K18997 L195_196 L44_45 0.0329
K18998 L195_196 L47_48 0.0412
K18999 L195_196 L29_30 0.0314
K19000 L195_196 L76_77 0.1743
K19001 L195_196 L166_167 0.0363
K19002 L195_196 L16_17 0.0244
K19003 L195_196 L118_119 0.0441
K19004 L195_196 L176_177 0.018
K19005 L195_196 L6_53 0.0378
K19006 L195_196 L149_150 0.0319
K19007 L195_196 L2_3 0.0184
K19008 L195_196 L98_99 0.0357
K19009 L195_196 L84_98 0.038
K19010 L195_196 L48_49 0.0385
K19011 L195_196 L124_125 0.0411
K19012 L195_196 L113_114 0.0419
K19013 L195_196 L52_53 0.0418
K19014 L195_196 L80_81 0.2117
K19015 L195_196 L141_202 0.066
K19016 L195_196 L87_88 0.0837
K19017 L195_196 L146_147 0.0383
K19018 L195_196 L127_128 0.0512
K19019 L195_196 L181_182 0.0212
K19020 L195_196 L28_29 0.0325
K19021 L195_196 L157_158 0.0282
K19022 L195_196 L96_97 0.032
K19023 L195_196 L129_130 0.0404
K19024 L195_196 L21_22 0.0301
K19025 L195_196 L117_118 0.0477
K19026 L195_196 L51_52 0.0448
K19027 L195_196 L56_57 0.0439
K19028 L195_196 L116_117 0.0491
K19029 L195_196 L154_155 0.0262
K19030 L195_196 L7_8 0.0224
K19031 L195_196 L82_83 0.0931
K19032 L195_196 L14_15 0.0217
K19033 L195_196 L184_185 0.0224
K19034 L195_196 L125_187 0.0245
K19035 L195_196 L58_59 0.052
K19036 L195_196 L68_69 0.0923
K19037 L195_196 L180_181 0.0218
K19038 L195_196 L89_102 0.0312
K19039 L195_196 L50_51 0.046
K19040 L195_196 L161_162 0.0337
K19041 L195_196 L111_112 0.0462
K19042 L195_196 L162_163 0.0326
K19043 L195_196 L179_180 0.0225
K19044 L195_196 L12_13 0.023
K19045 L195_196 L142_143 0.0363
K19046 L195_196 L123_124 0.0464
K19047 L195_196 L39_40 0.0351
K19048 L195_196 L18_19 0.0229
K19049 L195_196 L156_157 0.0291
K19050 L195_196 L54_55 0.0488
K19051 L118_119 L167_168 0.0618
K19052 L118_119 L74_90 0.0325
K19053 L118_119 L199_200 0.0419
K19054 L118_119 L115_179 0.0589
K19055 L118_119 L196_197 0.0477
K19056 L118_119 L1_2 0.0477
K19057 L118_119 L23_24 0.074
K19058 L118_119 L158_159 0.0683
K19059 L118_119 L163_164 0.0682
K19060 L118_119 L91_92 0.031
K19061 L118_119 L160_161 0.0868
K19062 L118_119 L126_127 0.0898
K19063 L118_119 L204_205 0.0427
K19064 L118_119 L153_154 0.0227
K19065 L118_119 L4_5 0.0367
K19066 L118_119 L41_42 0.0428
K19067 L118_119 L200_201 0.045
K19068 L118_119 L36_37 0.0555
K19069 L118_119 L131_132 0.0431
K19070 L118_119 L100_101 0.0276
K19071 L118_119 L92_93 0.0302
K19072 L118_119 L148_149 0.0283
K19073 L118_119 L19_20 0.0579
K19074 L118_119 L187_188 0.0741
K19075 L118_119 L165_166 0.0689
K19076 L118_119 L102_103 0.023
K19077 L118_119 L106_107 0.0917
K19078 L118_119 L64_65 0.2081
K19079 L118_119 L193_194 0.048
K19080 L118_119 L21_65 0.1479
K19081 L118_119 L121_122 0.0993
K19082 L118_119 L9_10 0.0445
K19083 L118_119 L134_135 0.0395
K19084 L118_119 L41_69 0.0462
K19085 L118_119 L171_172 0.0539
K19086 L118_119 L104_105 0.0221
K19087 L118_119 L151_210 0.0383
K19088 L118_119 L138_139 0.0311
K19089 L118_119 L37_38 0.0536
K19090 L118_119 L112_113 0.1933
K19091 L118_119 L59_60 0.1743
K19092 L118_119 L129_130 0.1593
K19093 L118_119 L38_39 0.0516
K19094 L118_119 L27_28 0.0786
K19095 L118_119 L96_97 0.0288
K19096 L118_119 L78_79 0.0448
K19097 L118_119 L44_45 0.0393
K19098 L118_119 L47_48 0.1576
K19099 L118_119 L29_30 0.0674
K19100 L118_119 L76_77 0.0448
K19101 L118_119 L166_167 0.0653
K19102 L118_119 L16_17 0.0822
K19103 L118_119 L176_177 0.0402
K19104 L118_119 L149_150 0.0277
K19105 L118_119 L2_3 0.0434
K19106 L118_119 L98_99 0.0288
K19107 L118_119 L6_53 0.1743
K19108 L118_119 L84_98 0.0293
K19109 L118_119 L48_49 0.2334
K19110 L118_119 L124_125 0.1933
K19111 L118_119 L113_114 0.3334
K19112 L118_119 L52_53 0.2659
K19113 L118_119 L80_81 0.0399
K19114 L118_119 L141_202 0.045
K19115 L118_119 L87_88 0.039
K19116 L118_119 L146_147 0.0294
K19117 L118_119 L136_137 0.0326
K19118 L118_119 L127_128 0.1593
K19119 L118_119 L181_182 0.0449
K19120 L118_119 L28_29 0.0727
K19121 L118_119 L157_158 0.0753
K19122 L118_119 L21_22 0.0916
K19123 L118_119 L51_52 0.1743
K19124 L118_119 L154_155 0.0222
K19125 L118_119 L7_8 0.0527
K19126 L118_119 L82_83 0.0435
K19127 L118_119 L58_59 0.0969
K19128 L118_119 L125_187 0.0851
K19129 L118_119 L70_71 0.0439
K19130 L118_119 L68_69 0.0477
K19131 L118_119 L180_181 0.0488
K19132 L118_119 L89_102 0.0234
K19133 L118_119 L8_9 0.0482
K19134 L118_119 L50_51 0.0969
K19135 L118_119 L90_91 0.0317
K19136 L118_119 L139_140 0.0303
K19137 L118_119 L161_162 0.0799
K19138 L118_119 L111_112 0.0993
K19139 L118_119 L162_163 0.0737
K19140 L118_119 L137_138 0.0319
K19141 L118_119 L179_180 0.0533
K19142 L118_119 L142_143 0.0303
K19143 L118_119 L123_124 0.3334
K19144 L118_119 L191_192 0.0427
K19145 L118_119 L39_40 0.0496
K19146 L118_119 L156_157 0.0838
K19147 L118_119 L18_19 0.0643
K19148 L118_119 L201_202 0.0462
K19149 L101_105 L181_185 0.0184
K19150 L101_105 L1_6 0.0213
K19151 L101_105 L73_78 0.0417
K19152 L101_105 L184_188 0.0193
K19153 L101_105 L163_168 0.0382
K19154 L101_105 L91_95 0.0985
K19155 L101_105 L130_160 0.027
K19156 L101_105 L4_9 0.0175
K19157 L101_105 L109_114 0.022
K19158 L101_105 L57_61 0.0238
K19159 L101_105 L53_57 0.0229
K19160 L101_105 L69_73 0.0409
K19161 L101_105 L200_204 0.0249
K19162 L101_105 L131_136 0.0556
K19163 L101_105 L46_50 0.0144
K19164 L101_105 L196_200 0.0248
K19165 L101_105 L92_96 0.1268
K19166 L101_105 L19_24 0.0207
K19167 L101_105 L120_125 0.0234
K19168 L101_105 L60_64 0.0219
K19169 L101_105 L193_197 0.0307
K19170 L101_105 L7_12 0.0181
K19171 L101_105 L137_142 0.073
K19172 L101_105 L167_172 0.05
K19173 L101_105 L121_126 0.0154
K19174 L101_105 L110_115 0.0212
K19175 L101_105 L113_118 0.0205
K19176 L101_105 L134_139 0.0867
K19177 L101_105 L141_146 0.0598
K19178 L101_105 L9_14 0.0185
K19179 L101_105 L138_143 0.088
K19180 L101_105 L33_38 0.051
K19181 L101_105 L18_23 0.0206
K19182 L101_105 L124_129 0.0247
K19183 L101_105 L107_112 0.0179
K19184 L101_105 L78_83 0.0421
K19185 L101_105 L112_117 0.0184
K19186 L101_105 L183_187 0.0191
K19187 L101_105 L59_63 0.0194
K19188 L101_105 L51_55 0.0184
K19189 L101_105 L58_62 0.0155
K19190 L101_105 L67_71 0.0247
K19191 L101_105 L29_34 0.0386
K19192 L101_105 L179_183 0.0181
K19193 L101_105 L206_210 0.0418
K19194 L101_105 L41_74 0.057
K19195 L101_105 L131_170 0.0601
K19196 L101_105 L191_195 0.0193
K19197 L101_105 L66_70 0.0193
K19198 L101_105 L98_102 0.0891
K19199 L101_105 L27_32 0.037
K19200 L101_105 L142_147 0.0789
K19201 L101_105 L147_152 0.0811
K19202 L101_105 L180_184 0.0182
K19203 L101_105 L3_8 0.0174
K19204 L101_105 L157_162 0.0299
K19205 L101_105 L149_154 0.1363
K19206 L101_105 L2_7 0.0172
K19207 L101_105 L117_122 0.0189
K19208 L101_105 L158_189 0.0206
K19209 L101_105 L38_43 0.0762
K19210 L101_105 L108_113 0.0199
K19211 L101_105 L160_165 0.0336
K19212 L101_105 L52_56 0.0206
K19213 L101_105 L115_120 0.0222
K19214 L101_105 L80_85 0.0195
K19215 L101_105 L16_21 0.0247
K19216 L101_105 L158_163 0.0302
K19217 L101_105 L96_100 0.1673
K19218 L101_105 L49_53 0.022
K19219 L101_105 L82_87 0.0314
K19220 L101_105 L125_130 0.0246
K19221 L101_105 L84_89 0.0622
K19222 L101_105 L204_208 0.0249
K19223 L101_105 L202_206 0.0417
K19224 L101_105 L14_19 0.0195
K19225 L101_105 L44_92 0.0968
K19226 L101_105 L21_26 0.0272
K19227 L101_105 L74_79 0.0597
K19228 L101_105 L165_170 0.0437
K19229 L101_105 L199_203 0.0194
K19230 L101_105 L75_80 0.0195
K19231 L101_105 L70_75 0.0194
K19232 L101_105 L50_54 0.0147
K19233 L101_105 L79_84 0.0615
K19234 L101_105 L56_60 0.0213
K19235 L101_105 L90_94 0.0787
K19236 L101_105 L134_173 0.0784
K19237 L101_105 L139_144 0.1062
K19238 L101_105 L177_181 0.0174
K19239 L101_105 L111_116 0.0147
K19240 L101_105 L162_167 0.0375
K19241 L101_105 L43_91 0.0823
K19242 L101_105 L122_127 0.0193
K19243 L101_105 L39_44 0.0827
K19244 L101_105 L123_128 0.0219
K19245 L101_105 L12_17 0.0192
K19246 L101_105 L54_58 0.0151
K19247 L101_105 L146_151 0.0604
K19248 L101_105 L61_65 0.0248
K19249 L101_105 L77_82 0.0313
K19250 L41_69 L167_168 0.0592
K19251 L41_69 L74_90 0.213
K19252 L41_69 L199_200 0.0607
K19253 L41_69 L115_179 0.0304
K19254 L41_69 L196_197 0.0923
K19255 L41_69 L1_2 0.025
K19256 L41_69 L23_24 0.0407
K19257 L41_69 L158_159 0.0393
K19258 L41_69 L163_164 0.0474
K19259 L41_69 L91_92 0.1194
K19260 L41_69 L160_161 0.0525
K19261 L41_69 L126_127 0.0387
K19262 L41_69 L153_154 0.0703
K19263 L41_69 L4_5 0.0234
K19264 L41_69 L204_205 0.0858
K19265 L41_69 L200_201 0.0896
K19266 L41_69 L36_37 0.0859
K19267 L41_69 L100_101 0.084
K19268 L41_69 L92_93 0.0972
K19269 L41_69 L148_149 0.0921
K19270 L41_69 L19_20 0.0317
K19271 L41_69 L187_188 0.0333
K19272 L41_69 L165_166 0.0654
K19273 L41_69 L102_103 0.0824
K19274 L41_69 L106_107 0.0335
K19275 L41_69 L64_65 0.0502
K19276 L41_69 L8_9 0.0293
K19277 L41_69 L21_65 0.0524
K19278 L41_69 L121_122 0.0394
K19279 L41_69 L9_10 0.0286
K19280 L41_69 L171_172 0.0779
K19281 L41_69 L104_105 0.0649
K19282 L41_69 L151_210 0.1492
K19283 L41_69 L37_38 0.0793
K19284 L41_69 L112_113 0.0404
K19285 L41_69 L183_184 0.0315
K19286 L41_69 L59_60 0.045
K19287 L41_69 L11_57 0.048
K19288 L41_69 L38_39 0.0733
K19289 L41_69 L27_28 0.0513
K19290 L41_69 L96_97 0.0913
K19291 L41_69 L78_79 0.2809
K19292 L41_69 L138_139 0.1103
K19293 L41_69 L47_48 0.0373
K19294 L41_69 L29_30 0.0477
K19295 L41_69 L76_77 0.0917
K19296 L41_69 L166_167 0.0623
K19297 L41_69 L16_17 0.0344
K19298 L41_69 L176_177 0.0239
K19299 L41_69 L6_53 0.0451
K19300 L41_69 L149_150 0.0809
K19301 L41_69 L2_3 0.0245
K19302 L41_69 L98_99 0.112
K19303 L41_69 L184_185 0.0308
K19304 L41_69 L84_98 0.1286
K19305 L41_69 L48_49 0.0403
K19306 L41_69 L124_125 0.051
K19307 L41_69 L113_114 0.0436
K19308 L41_69 L52_53 0.0438
K19309 L41_69 L80_81 0.0601
K19310 L41_69 L141_202 0.2334
K19311 L41_69 L87_88 0.123
K19312 L41_69 L146_147 0.1183
K19313 L41_69 L127_128 0.0446
K19314 L41_69 L181_182 0.0285
K19315 L41_69 L28_29 0.0495
K19316 L41_69 L157_158 0.0405
K19317 L41_69 L129_130 0.052
K19318 L41_69 L21_22 0.0431
K19319 L41_69 L117_118 0.0425
K19320 L41_69 L51_52 0.0406
K19321 L41_69 L56_57 0.0465
K19322 L41_69 L116_117 0.0378
K19323 L41_69 L154_155 0.0629
K19324 L41_69 L7_8 0.03
K19325 L41_69 L82_83 0.1475
K19326 L41_69 L14_15 0.0301
K19327 L41_69 L125_187 0.0341
K19328 L41_69 L58_59 0.0395
K19329 L41_69 L70_71 0.0621
K19330 L41_69 L136_137 0.1668
K19331 L41_69 L180_181 0.0292
K19332 L41_69 L89_102 0.0917
K19333 L41_69 L50_51 0.0364
K19334 L41_69 L90_91 0.1546
K19335 L41_69 L139_140 0.0922
K19336 L41_69 L161_162 0.0509
K19337 L41_69 L111_112 0.0363
K19338 L41_69 L162_163 0.0492
K19339 L41_69 L137_138 0.135
K19340 L41_69 L179_180 0.0299
K19341 L41_69 L12_13 0.0317
K19342 L41_69 L142_143 0.1201
K19343 L41_69 L123_124 0.0492
K19344 L41_69 L39_40 0.0678
K19345 L41_69 L18_19 0.0326
K19346 L41_69 L156_157 0.0417
K19347 L41_69 L54_55 0.0379
K19348 L41_69 L201_202 0.1576
K19349 L138_143 L181_185 0.025
K19350 L138_143 L140_145 0.1216
K19351 L138_143 L1_6 0.0291
K19352 L138_143 L35_40 0.0557
K19353 L138_143 L73_78 0.0593
K19354 L138_143 L163_168 0.0465
K19355 L138_143 L130_160 0.0392
K19356 L138_143 L4_9 0.0234
K19357 L138_143 L202_206 0.0599
K19358 L138_143 L109_114 0.0301
K19359 L138_143 L57_61 0.0328
K19360 L138_143 L164_169 0.0423
K19361 L138_143 L53_57 0.0314
K19362 L138_143 L69_73 0.059
K19363 L138_143 L200_204 0.0331
K19364 L138_143 L145_150 0.1144
K19365 L138_143 L30_35 0.0418
K19366 L138_143 L131_136 0.0991
K19367 L138_143 L46_50 0.0191
K19368 L138_143 L196_200 0.0331
K19369 L138_143 L92_96 0.1536
K19370 L138_143 L19_24 0.0283
K19371 L138_143 L120_125 0.0327
K19372 L138_143 L160_165 0.0518
K19373 L138_143 L60_64 0.0299
K19374 L138_143 L193_197 0.0426
K19375 L138_143 L7_12 0.0248
K19376 L138_143 L137_142 0.2054
K19377 L138_143 L121_126 0.0207
K19378 L138_143 L110_115 0.0292
K19379 L138_143 L113_118 0.028
K19380 L138_143 L141_146 0.0991
K19381 L138_143 L9_14 0.0248
K19382 L138_143 L134_139 0.1832
K19383 L138_143 L124_129 0.0345
K19384 L138_143 L107_112 0.024
K19385 L138_143 L78_83 0.059
K19386 L138_143 L112_117 0.0247
K19387 L138_143 L40_45 0.0812
K19388 L138_143 L183_187 0.0266
K19389 L138_143 L59_63 0.026
K19390 L138_143 L5_10 0.0193
K19391 L138_143 L15_20 0.0218
K19392 L138_143 L51_55 0.0246
K19393 L138_143 L58_62 0.0207
K19394 L138_143 L67_71 0.0329
K19395 L138_143 L29_34 0.0459
K19396 L138_143 L179_183 0.025
K19397 L138_143 L158_189 0.0285
K19398 L138_143 L206_210 0.059
K19399 L138_143 L41_74 0.0941
K19400 L138_143 L131_170 0.1305
K19401 L138_143 L191_195 0.0257
K19402 L138_143 L66_70 0.0256
K19403 L138_143 L98_102 0.1226
K19404 L138_143 L27_32 0.0555
K19405 L138_143 L142_147 0.1832
K19406 L138_143 L147_152 0.1439
K19407 L138_143 L178_182 0.0194
K19408 L138_143 L149_154 0.1439
K19409 L138_143 L2_7 0.0234
K19410 L138_143 L117_122 0.0254
K19411 L138_143 L135_174 0.0849
K19412 L138_143 L52_56 0.0279
K19413 L138_143 L115_120 0.0309
K19414 L138_143 L80_85 0.0255
K19415 L138_143 L10_15 0.0204
K19416 L138_143 L16_21 0.0346
K19417 L138_143 L158_163 0.0366
K19418 L138_143 L96_100 0.1438
K19419 L138_143 L49_53 0.03
K19420 L138_143 L186_190 0.0219
K19421 L138_143 L82_87 0.042
K19422 L138_143 L125_130 0.0348
K19423 L138_143 L108_113 0.027
K19424 L138_143 L159_164 0.0335
K19425 L138_143 L84_89 0.0897
K19426 L138_143 L204_208 0.0329
K19427 L138_143 L25_30 0.0333
K19428 L138_143 L14_19 0.0265
K19429 L138_143 L44_92 0.1438
K19430 L138_143 L21_26 0.0389
K19431 L138_143 L74_79 0.0958
K19432 L138_143 L165_170 0.0756
K19433 L138_143 L199_203 0.0257
K19434 L138_143 L75_80 0.0256
K19435 L138_143 L70_75 0.0256
K19436 L138_143 L50_54 0.0196
K19437 L138_143 L79_84 0.0941
K19438 L138_143 L56_60 0.0289
K19439 L138_143 L93_97 0.1033
K19440 L138_143 L90_94 0.1536
K19441 L138_143 L134_173 0.098
K19442 L138_143 L139_144 0.2054
K19443 L138_143 L177_181 0.0235
K19444 L138_143 L111_116 0.0197
K19445 L138_143 L122_127 0.0261
K19446 L138_143 L135_140 0.1144
K19447 L138_143 L39_44 0.093
K19448 L138_143 L123_128 0.03
K19449 L138_143 L12_17 0.0265
K19450 L138_143 L54_58 0.0201
K19451 L138_143 L146_151 0.0939
K19452 L138_143 L61_65 0.0344
K19453 L138_143 L77_82 0.0423
K19454 L18_23 L181_185 0.1226
K19455 L18_23 L140_145 0.0232
K19456 L18_23 L1_6 0.0869
K19457 L18_23 L35_40 0.0569
K19458 L18_23 L73_78 0.0345
K19459 L18_23 L163_168 0.093
K19460 L18_23 L130_160 0.1627
K19461 L18_23 L4_9 0.1124
K19462 L18_23 L202_206 0.0328
K19463 L18_23 L109_114 0.0568
K19464 L18_23 L57_61 0.0599
K19465 L18_23 L164_169 0.0812
K19466 L18_23 L53_57 0.059
K19467 L18_23 L69_73 0.0362
K19468 L18_23 L200_204 0.0253
K19469 L18_23 L145_150 0.0218
K19470 L18_23 L30_35 0.0849
K19471 L18_23 L131_136 0.0368
K19472 L18_23 L46_50 0.0254
K19473 L18_23 L196_200 0.026
K19474 L18_23 L92_96 0.0285
K19475 L18_23 L19_24 0.2054
K19476 L18_23 L120_125 0.0941
K19477 L18_23 L160_165 0.1175
K19478 L18_23 L60_64 0.0427
K19479 L18_23 L193_197 0.031
K19480 L18_23 L7_12 0.1439
K19481 L18_23 L137_142 0.0283
K19482 L18_23 L121_126 0.0256
K19483 L18_23 L110_115 0.0836
K19484 L18_23 L113_118 0.042
K19485 L18_23 L141_146 0.0326
K19486 L18_23 L9_14 0.1439
K19487 L18_23 L134_139 0.0304
K19488 L18_23 L124_129 0.0593
K19489 L18_23 L107_112 0.0325
K19490 L18_23 L78_83 0.033
K19491 L18_23 L112_117 0.0328
K19492 L18_23 L40_45 0.0423
K19493 L18_23 L183_187 0.1438
K19494 L18_23 L59_63 0.0331
K19495 L18_23 L5_10 0.0823
K19496 L18_23 L15_20 0.1144
K19497 L18_23 L51_55 0.0329
K19498 L18_23 L58_62 0.0257
K19499 L18_23 L67_71 0.0268
K19500 L18_23 L29_34 0.098
K19501 L18_23 L179_183 0.1226
K19502 L18_23 L158_189 0.1536
K19503 L18_23 L206_210 0.0314
K19504 L18_23 L41_74 0.0371
K19505 L18_23 L131_170 0.051
K19506 L18_23 L191_195 0.0212
K19507 L18_23 L66_70 0.0212
K19508 L18_23 L98_102 0.025
K19509 L18_23 L27_32 0.1482
K19510 L18_23 L142_147 0.0265
K19511 L18_23 L147_152 0.0248
K19512 L18_23 L178_182 0.0759
K19513 L18_23 L149_154 0.0248
K19514 L18_23 L2_7 0.1124
K19515 L18_23 L117_122 0.0329
K19516 L18_23 L135_174 0.0418
K19517 L18_23 L52_56 0.0423
K19518 L18_23 L115_120 0.0897
K19519 L18_23 L80_85 0.0197
K19520 L18_23 L10_15 0.0985
K19521 L18_23 L16_21 0.1011
K19522 L18_23 L158_163 0.1572
K19523 L18_23 L96_100 0.0266
K19524 L18_23 L49_53 0.0575
K19525 L18_23 L186_190 0.0988
K19526 L18_23 L82_87 0.028
K19527 L18_23 L125_130 0.0958
K19528 L18_23 L108_113 0.0415
K19529 L18_23 L159_164 0.1252
K19530 L18_23 L84_89 0.0309
K19531 L18_23 L204_208 0.0246
K19532 L18_23 L25_30 0.1407
K19533 L18_23 L14_19 0.1832
K19534 L18_23 L44_92 0.0306
K19535 L18_23 L21_26 0.2007
K19536 L18_23 L74_79 0.0348
K19537 L18_23 L165_170 0.0729
K19538 L18_23 L199_203 0.0201
K19539 L18_23 L75_80 0.0202
K19540 L18_23 L70_75 0.0207
K19541 L18_23 L50_54 0.0256
K19542 L18_23 L79_84 0.0327
K19543 L18_23 L56_60 0.0426
K19544 L18_23 L93_97 0.0234
K19545 L18_23 L90_94 0.0285
K19546 L18_23 L134_173 0.0459
K19547 L18_23 L139_144 0.0283
K19548 L18_23 L177_181 0.1015
K19549 L18_23 L111_116 0.0255
K19550 L18_23 L122_127 0.033
K19551 L18_23 L135_140 0.0249
K19552 L18_23 L39_44 0.0465
K19553 L18_23 L123_128 0.0424
K19554 L18_23 L12_17 0.1832
K19555 L18_23 L54_58 0.0257
K19556 L18_23 L146_151 0.0307
K19557 L18_23 L61_65 0.0602
K19558 L18_23 L77_82 0.029
K19559 L180_181 L167_168 0.0548
K19560 L180_181 L74_90 0.0234
K19561 L180_181 L199_200 0.0213
K19562 L180_181 L196_197 0.0245
K19563 L180_181 L23_24 0.1029
K19564 L180_181 L158_159 0.1076
K19565 L180_181 L163_164 0.0781
K19566 L180_181 L91_92 0.0236
K19567 L180_181 L160_161 0.0757
K19568 L180_181 L126_127 0.0266
K19569 L180_181 L204_205 0.023
K19570 L180_181 L153_154 0.0169
K19571 L180_181 L4_5 0.1426
K19572 L180_181 L41_42 0.0311
K19573 L180_181 L200_201 0.0237
K19574 L180_181 L131_132 0.0313
K19575 L180_181 L100_101 0.0211
K19576 L180_181 L92_93 0.0235
K19577 L180_181 L1_2 0.1153
K19578 L180_181 L148_149 0.0212
K19579 L180_181 L19_20 0.1127
K19580 L180_181 L187_188 0.1284
K19581 L180_181 L165_166 0.0537
K19582 L180_181 L102_103 0.0168
K19583 L180_181 L106_107 0.0319
K19584 L180_181 L64_65 0.0434
K19585 L180_181 L193_194 0.0264
K19586 L180_181 L21_65 0.0622
K19587 L180_181 L121_122 0.0287
K19588 L180_181 L134_135 0.0315
K19589 L180_181 L171_172 0.0419
K19590 L180_181 L104_105 0.0168
K19591 L180_181 L151_210 0.0249
K19592 L180_181 L37_38 0.0416
K19593 L180_181 L124_125 0.071
K19594 L180_181 L183_184 0.1832
K19595 L180_181 L59_60 0.0357
K19596 L180_181 L11_57 0.0723
K19597 L180_181 L38_39 0.0417
K19598 L180_181 L27_28 0.0758
K19599 L180_181 L96_97 0.0222
K19600 L180_181 L78_79 0.0288
K19601 L180_181 L44_45 0.0313
K19602 L180_181 L47_48 0.0418
K19603 L180_181 L29_30 0.0758
K19604 L180_181 L76_77 0.0237
K19605 L180_181 L166_167 0.0545
K19606 L180_181 L16_17 0.1015
K19607 L180_181 L176_177 0.2697
K19608 L180_181 L149_150 0.0212
K19609 L180_181 L2_3 0.1426
K19610 L180_181 L98_99 0.0211
K19611 L180_181 L84_98 0.021
K19612 L180_181 L48_49 0.061
K19613 L180_181 L80_81 0.0207
K19614 L180_181 L141_202 0.0289
K19615 L180_181 L87_88 0.0229
K19616 L180_181 L146_147 0.0211
K19617 L180_181 L136_137 0.0235
K19618 L180_181 L127_128 0.0331
K19619 L180_181 L138_139 0.0237
K19620 L180_181 L28_29 0.0766
K19621 L180_181 L157_158 0.1104
K19622 L180_181 L129_130 0.0636
K19623 L180_181 L21_22 0.0947
K19624 L180_181 L117_118 0.0363
K19625 L180_181 L56_57 0.0482
K19626 L180_181 L116_117 0.0289
K19627 L180_181 L154_155 0.0169
K19628 L180_181 L82_83 0.0253
K19629 L180_181 L14_15 0.1438
K19630 L180_181 L184_185 0.2054
K19631 L180_181 L125_187 0.1124
K19632 L180_181 L58_59 0.0286
K19633 L180_181 L70_71 0.0218
K19634 L180_181 L68_69 0.0263
K19635 L180_181 L89_102 0.0167
K19636 L180_181 L36_37 0.0412
K19637 L180_181 L90_91 0.0235
K19638 L180_181 L139_140 0.0237
K19639 L180_181 L161_162 0.0781
K19640 L180_181 L162_163 0.079
K19641 L180_181 L137_138 0.0237
K19642 L180_181 L12_13 0.1438
K19643 L180_181 L142_143 0.0223
K19644 L180_181 L123_124 0.0478
K19645 L180_181 L191_192 0.0207
K19646 L180_181 L39_40 0.0416
K19647 L180_181 L18_19 0.1173
K19648 L180_181 L156_157 0.1076
K19649 L180_181 L54_55 0.0287
K19650 L180_181 L201_202 0.0264
K19651 L107_112 L181_185 0.0313
K19652 L107_112 L140_145 0.0189
K19653 L107_112 L1_6 0.0504
K19654 L107_112 L35_40 0.0311
K19655 L107_112 L73_78 0.042
K19656 L107_112 L163_168 0.037
K19657 L107_112 L91_95 0.024
K19658 L107_112 L130_160 0.0415
K19659 L107_112 L4_9 0.0313
K19660 L107_112 L202_206 0.0405
K19661 L107_112 L109_114 0.0744
K19662 L107_112 L57_61 0.0726
K19663 L107_112 L164_169 0.0331
K19664 L107_112 L9_14 0.0312
K19665 L107_112 L53_57 0.0734
K19666 L107_112 L69_73 0.0437
K19667 L107_112 L145_150 0.0184
K19668 L107_112 L30_35 0.033
K19669 L107_112 L131_136 0.0348
K19670 L107_112 L46_50 0.1437
K19671 L107_112 L92_96 0.0233
K19672 L107_112 L19_24 0.0309
K19673 L107_112 L120_125 0.0503
K19674 L107_112 L60_64 0.1034
K19675 L107_112 L193_197 0.0489
K19676 L107_112 L7_12 0.0349
K19677 L107_112 L137_142 0.0247
K19678 L107_112 L167_172 0.0362
K19679 L107_112 L121_126 0.1273
K19680 L107_112 L110_115 0.0507
K19681 L107_112 L141_146 0.0326
K19682 L107_112 L33_38 0.0361
K19683 L107_112 L124_129 0.072
K19684 L107_112 L78_83 0.0404
K19685 L107_112 L134_139 0.0239
K19686 L107_112 L40_45 0.029
K19687 L107_112 L183_187 0.0349
K19688 L107_112 L5_10 0.0249
K19689 L107_112 L15_20 0.0248
K19690 L107_112 L58_62 0.1215
K19691 L107_112 L29_34 0.0369
K19692 L107_112 L179_183 0.0351
K19693 L107_112 L158_189 0.031
K19694 L107_112 L206_210 0.039
K19695 L107_112 L41_74 0.0347
K19696 L107_112 L131_170 0.0328
K19697 L107_112 L191_195 0.043
K19698 L107_112 L66_70 0.0427
K19699 L107_112 L98_102 0.0233
K19700 L107_112 L27_32 0.0405
K19701 L107_112 L147_152 0.0233
K19702 L107_112 L178_182 0.025
K19703 L107_112 L180_184 0.0331
K19704 L107_112 L3_8 0.033
K19705 L107_112 L157_162 0.0409
K19706 L107_112 L149_154 0.0221
K19707 L107_112 L2_7 0.0349
K19708 L107_112 L38_43 0.0334
K19709 L107_112 L113_118 0.1134
K19710 L107_112 L108_113 0.1145
K19711 L107_112 L135_174 0.0291
K19712 L107_112 L160_165 0.0389
K19713 L107_112 L52_56 0.1104
K19714 L107_112 L115_120 0.0506
K19715 L107_112 L80_85 0.0365
K19716 L107_112 L10_15 0.0249
K19717 L107_112 L16_21 0.0495
K19718 L107_112 L158_163 0.0389
K19719 L107_112 L96_100 0.0227
K19720 L107_112 L49_53 0.0736
K19721 L107_112 L186_190 0.0249
K19722 L107_112 L82_87 0.0423
K19723 L107_112 L125_130 0.0498
K19724 L107_112 L184_188 0.0329
K19725 L107_112 L159_164 0.0346
K19726 L107_112 L84_89 0.0315
K19727 L107_112 L25_30 0.0345
K19728 L107_112 L14_19 0.0311
K19729 L107_112 L44_92 0.0239
K19730 L107_112 L21_26 0.0413
K19731 L107_112 L74_79 0.0336
K19732 L107_112 L165_170 0.0359
K19733 L107_112 L199_203 0.0385
K19734 L107_112 L75_80 0.0384
K19735 L107_112 L70_75 0.0405
K19736 L107_112 L50_54 0.1405
K19737 L107_112 L79_84 0.0325
K19738 L107_112 L56_60 0.1076
K19739 L107_112 L93_97 0.0189
K19740 L107_112 L90_94 0.0247
K19741 L107_112 L134_173 0.0323
K19742 L107_112 L139_144 0.0233
K19743 L107_112 L177_181 0.0314
K19744 L107_112 L111_116 0.1506
K19745 L107_112 L162_167 0.0388
K19746 L107_112 L43_91 0.0246
K19747 L107_112 L142_147 0.024
K19748 L107_112 L135_140 0.0194
K19749 L107_112 L39_44 0.0322
K19750 L107_112 L123_128 0.1057
K19751 L107_112 L12_17 0.0347
K19752 L107_112 L54_58 0.1322
K19753 L107_112 L146_151 0.0315
K19754 L107_112 L61_65 0.0713
K19755 L107_112 L77_82 0.0443
K19756 L37_38 L167_168 0.1203
K19757 L37_38 L74_90 0.0781
K19758 L37_38 L199_200 0.0377
K19759 L37_38 L115_179 0.0416
K19760 L37_38 L196_197 0.0472
K19761 L37_38 L1_2 0.0341
K19762 L37_38 L23_24 0.0632
K19763 L37_38 L158_159 0.0615
K19764 L37_38 L163_164 0.0796
K19765 L37_38 L91_92 0.0781
K19766 L37_38 L160_161 0.0811
K19767 L37_38 L126_127 0.0387
K19768 L37_38 L204_205 0.0445
K19769 L37_38 L153_154 0.0456
K19770 L37_38 L4_5 0.0338
K19771 L37_38 L41_42 0.122
K19772 L37_38 L200_201 0.0459
K19773 L37_38 L131_132 0.116
K19774 L37_38 L100_101 0.0595
K19775 L37_38 L92_93 0.0757
K19776 L37_38 L148_149 0.0596
K19777 L37_38 L19_20 0.049
K19778 L37_38 L187_188 0.0492
K19779 L37_38 L165_166 0.1203
K19780 L37_38 L102_103 0.0466
K19781 L37_38 L106_107 0.0348
K19782 L37_38 L64_65 0.0579
K19783 L37_38 L8_9 0.0419
K19784 L37_38 L193_194 0.0579
K19785 L37_38 L21_65 0.0687
K19786 L37_38 L121_122 0.04
K19787 L37_38 L9_10 0.0415
K19788 L37_38 L134_135 0.1106
K19789 L37_38 L104_105 0.0456
K19790 L37_38 L151_210 0.0601
K19791 L37_38 L184_185 0.045
K19792 L37_38 L112_113 0.0438
K19793 L37_38 L183_184 0.0451
K19794 L37_38 L59_60 0.048
K19795 L37_38 L11_57 0.061
K19796 L37_38 L51_52 0.044
K19797 L37_38 L27_28 0.0832
K19798 L37_38 L78_79 0.0743
K19799 L37_38 L44_45 0.1157
K19800 L37_38 L47_48 0.0405
K19801 L37_38 L29_30 0.0811
K19802 L37_38 L76_77 0.0461
K19803 L37_38 L166_167 0.1221
K19804 L37_38 L16_17 0.0496
K19805 L37_38 L176_177 0.0338
K19806 L37_38 L6_53 0.0566
K19807 L37_38 L149_150 0.0585
K19808 L37_38 L2_3 0.0342
K19809 L37_38 L98_99 0.061
K19810 L37_38 L84_98 0.0606
K19811 L37_38 L48_49 0.0467
K19812 L37_38 L124_125 0.0654
K19813 L37_38 L113_114 0.0505
K19814 L37_38 L52_53 0.0508
K19815 L37_38 L80_81 0.0371
K19816 L37_38 L141_202 0.0732
K19817 L37_38 L87_88 0.0497
K19818 L37_38 L146_147 0.0596
K19819 L37_38 L136_137 0.0758
K19820 L37_38 L127_128 0.0469
K19821 L37_38 L138_139 0.0758
K19822 L37_38 L181_182 0.0412
K19823 L37_38 L28_29 0.0827
K19824 L37_38 L157_158 0.0624
K19825 L37_38 L96_97 0.0667
K19826 L37_38 L129_130 0.0678
K19827 L37_38 L21_22 0.0632
K19828 L37_38 L117_118 0.0457
K19829 L37_38 L56_57 0.0539
K19830 L37_38 L116_117 0.0388
K19831 L37_38 L154_155 0.0449
K19832 L37_38 L7_8 0.042
K19833 L37_38 L82_83 0.0553
K19834 L37_38 L14_15 0.045
K19835 L37_38 L125_187 0.049
K19836 L37_38 L58_59 0.0402
K19837 L37_38 L70_71 0.0386
K19838 L37_38 L68_69 0.0584
K19839 L37_38 L89_102 0.0463
K19840 L37_38 L50_51 0.0377
K19841 L37_38 L90_91 0.079
K19842 L37_38 L139_140 0.0736
K19843 L37_38 L161_162 0.0817
K19844 L37_38 L111_112 0.0376
K19845 L37_38 L162_163 0.0811
K19846 L37_38 L137_138 0.0766
K19847 L37_38 L179_180 0.0417
K19848 L37_38 L12_13 0.0456
K19849 L37_38 L142_143 0.0673
K19850 L37_38 L123_124 0.0569
K19851 L37_38 L191_192 0.0363
K19852 L37_38 L18_19 0.0496
K19853 L37_38 L156_157 0.0627
K19854 L37_38 L54_55 0.0389
K19855 L37_38 L201_202 0.0575
K19856 L124_125 L167_168 0.0833
K19857 L124_125 L74_90 0.0368
K19858 L124_125 L199_200 0.0395
K19859 L124_125 L115_179 0.0921
K19860 L124_125 L196_197 0.0464
K19861 L124_125 L1_2 0.0719
K19862 L124_125 L23_24 0.1293
K19863 L124_125 L158_159 0.1163
K19864 L124_125 L163_164 0.1037
K19865 L124_125 L91_92 0.0357
K19866 L124_125 L160_161 0.1377
K19867 L124_125 L126_127 0.0618
K19868 L124_125 L204_205 0.0419
K19869 L124_125 L153_154 0.0255
K19870 L124_125 L4_5 0.0511
K19871 L124_125 L41_42 0.0494
K19872 L124_125 L200_201 0.0441
K19873 L124_125 L36_37 0.0669
K19874 L124_125 L131_132 0.0498
K19875 L124_125 L100_101 0.0314
K19876 L124_125 L92_93 0.035
K19877 L124_125 L148_149 0.032
K19878 L124_125 L165_166 0.0912
K19879 L124_125 L102_103 0.0257
K19880 L124_125 L106_107 0.0601
K19881 L124_125 L64_65 0.1674
K19882 L124_125 L193_194 0.0495
K19883 L124_125 L21_65 0.2623
K19884 L124_125 L9_10 0.0623
K19885 L124_125 L134_135 0.0469
K19886 L124_125 L171_172 0.0661
K19887 L124_125 L104_105 0.025
K19888 L124_125 L151_210 0.0413
K19889 L124_125 L112_113 0.0952
K19890 L124_125 L183_184 0.0851
K19891 L124_125 L11_57 0.2659
K19892 L124_125 L38_39 0.0636
K19893 L124_125 L27_28 0.1213
K19894 L124_125 L78_79 0.0488
K19895 L124_125 L44_45 0.0466
K19896 L124_125 L47_48 0.0858
K19897 L124_125 L29_30 0.1009
K19898 L124_125 L76_77 0.0439
K19899 L124_125 L166_167 0.0876
K19900 L124_125 L191_192 0.0395
K19901 L124_125 L176_177 0.0581
K19902 L124_125 L6_53 0.2117
K19903 L124_125 L149_150 0.0315
K19904 L124_125 L2_3 0.0636
K19905 L124_125 L98_99 0.0323
K19906 L124_125 L84_98 0.0326
K19907 L124_125 L48_49 0.1387
K19908 L124_125 L113_114 0.1646
K19909 L124_125 L52_53 0.1537
K19910 L124_125 L80_81 0.0378
K19911 L124_125 L141_202 0.0491
K19912 L124_125 L87_88 0.0401
K19913 L124_125 L146_147 0.0328
K19914 L124_125 L136_137 0.037
K19915 L124_125 L127_128 0.0934
K19916 L124_125 L138_139 0.0359
K19917 L124_125 L181_182 0.0634
K19918 L124_125 L28_29 0.1109
K19919 L124_125 L157_158 0.1374
K19920 L124_125 L96_97 0.0331
K19921 L124_125 L129_130 0.3407
K19922 L124_125 L21_22 0.1766
K19923 L124_125 L117_118 0.0993
K19924 L124_125 L51_52 0.0931
K19925 L124_125 L56_57 0.1743
K19926 L124_125 L116_117 0.066
K19927 L124_125 L154_155 0.0251
K19928 L124_125 L7_8 0.078
K19929 L124_125 L82_83 0.0448
K19930 L124_125 L14_15 0.0643
K19931 L124_125 L184_185 0.0741
K19932 L124_125 L70_71 0.041
K19933 L124_125 L68_69 0.0492
K19934 L124_125 L89_102 0.0259
K19935 L124_125 L8_9 0.0693
K19936 L124_125 L50_51 0.0642
K19937 L124_125 L90_91 0.0363
K19938 L124_125 L139_140 0.0352
K19939 L124_125 L161_162 0.1263
K19940 L124_125 L111_112 0.0648
K19941 L124_125 L162_163 0.1147
K19942 L124_125 L137_138 0.0365
K19943 L124_125 L179_180 0.0803
K19944 L124_125 L12_13 0.0822
K19945 L124_125 L142_143 0.0344
K19946 L124_125 L39_40 0.0615
K19947 L124_125 L156_157 0.1656
K19948 L124_125 L54_55 0.0653
K19949 L124_125 L201_202 0.0477
K19950 L11_57 L167_168 0.0749
K19951 L11_57 L74_90 0.0347
K19952 L11_57 L199_200 0.0378
K19953 L11_57 L115_179 0.095
K19954 L11_57 L196_197 0.0439
K19955 L11_57 L1_2 0.0811
K19956 L11_57 L23_24 0.1225
K19957 L11_57 L158_159 0.1032
K19958 L11_57 L163_164 0.0923
K19959 L11_57 L91_92 0.0339
K19960 L11_57 L160_161 0.1139
K19961 L11_57 L126_127 0.0602
K19962 L11_57 L204_205 0.0399
K19963 L11_57 L153_154 0.0241
K19964 L11_57 L4_5 0.054
K19965 L11_57 L41_42 0.0465
K19966 L11_57 L200_201 0.0418
K19967 L11_57 L36_37 0.0622
K19968 L11_57 L131_132 0.0461
K19969 L11_57 L100_101 0.0299
K19970 L11_57 L92_93 0.0333
K19971 L11_57 L148_149 0.0302
K19972 L11_57 L19_20 0.0996
K19973 L11_57 L187_188 0.133
K19974 L11_57 L165_166 0.0804
K19975 L11_57 L102_103 0.0244
K19976 L11_57 L106_107 0.0607
K19977 L11_57 L64_65 0.1593
K19978 L11_57 L193_194 0.0462
K19979 L11_57 L21_65 0.2387
K19980 L11_57 L121_122 0.0653
K19981 L11_57 L9_10 0.0656
K19982 L11_57 L134_135 0.0438
K19983 L11_57 L171_172 0.0605
K19984 L11_57 L104_105 0.0239
K19985 L11_57 L151_210 0.039
K19986 L11_57 L138_139 0.0337
K19987 L11_57 L112_113 0.0969
K19988 L11_57 L59_60 0.0993
K19989 L11_57 L129_130 0.2081
K19990 L11_57 L38_39 0.0595
K19991 L11_57 L27_28 0.1105
K19992 L11_57 L96_97 0.0315
K19993 L11_57 L78_79 0.0462
K19994 L11_57 L44_45 0.0441
K19995 L11_57 L47_48 0.0917
K19996 L11_57 L29_30 0.0944
K19997 L11_57 L76_77 0.0419
K19998 L11_57 L166_167 0.0779
K19999 L11_57 L16_17 0.1855
K20000 L11_57 L176_177 0.0594
K20001 L11_57 L149_150 0.0298
K20002 L11_57 L2_3 0.0696
K20003 L11_57 L98_99 0.0307
K20004 L11_57 L6_53 0.3334
K20005 L11_57 L84_98 0.031
K20006 L11_57 L48_49 0.1727
K20007 L11_57 L113_114 0.1743
K20008 L11_57 L52_53 0.1933
K20009 L11_57 L80_81 0.0365
K20010 L11_57 L141_202 0.046
K20011 L11_57 L87_88 0.0383
K20012 L11_57 L146_147 0.0308
K20013 L11_57 L136_137 0.0346
K20014 L11_57 L127_128 0.0878
K20015 L11_57 L181_182 0.0643
K20016 L11_57 L28_29 0.1024
K20017 L11_57 L157_158 0.1168
K20018 L11_57 L21_22 0.1609
K20019 L11_57 L51_52 0.0993
K20020 L11_57 L154_155 0.0238
K20021 L11_57 L7_8 0.0851
K20022 L11_57 L82_83 0.0427
K20023 L11_57 L58_59 0.066
K20024 L11_57 L125_187 0.1583
K20025 L11_57 L70_71 0.0395
K20026 L11_57 L68_69 0.0465
K20027 L11_57 L89_102 0.0246
K20028 L11_57 L8_9 0.0741
K20029 L11_57 L50_51 0.066
K20030 L11_57 L90_91 0.0344
K20031 L11_57 L139_140 0.0331
K20032 L11_57 L161_162 0.1072
K20033 L11_57 L111_112 0.0653
K20034 L11_57 L162_163 0.0998
K20035 L11_57 L137_138 0.0342
K20036 L11_57 L179_180 0.0822
K20037 L11_57 L142_143 0.0323
K20038 L11_57 L123_124 0.1743
K20039 L11_57 L191_192 0.0378
K20040 L11_57 L39_40 0.0578
K20041 L11_57 L156_157 0.1324
K20042 L11_57 L18_19 0.1196
K20043 L11_57 L201_202 0.0448
K20044 L51_52 L167_168 0.0475
K20045 L51_52 L74_90 0.0282
K20046 L51_52 L199_200 0.0425
K20047 L51_52 L196_197 0.046
K20048 L51_52 L23_24 0.0518
K20049 L51_52 L158_159 0.048
K20050 L51_52 L163_164 0.05
K20051 L51_52 L91_92 0.0267
K20052 L51_52 L160_161 0.0601
K20053 L51_52 L126_127 0.13
K20054 L51_52 L204_205 0.0412
K20055 L51_52 L153_154 0.0199
K20056 L51_52 L4_5 0.0284
K20057 L51_52 L41_42 0.0366
K20058 L51_52 L200_201 0.0435
K20059 L51_52 L131_132 0.0364
K20060 L51_52 L100_101 0.0242
K20061 L51_52 L92_93 0.026
K20062 L51_52 L1_2 0.0347
K20063 L51_52 L148_149 0.0247
K20064 L51_52 L19_20 0.041
K20065 L51_52 L187_188 0.0474
K20066 L51_52 L165_166 0.0523
K20067 L51_52 L102_103 0.0204
K20068 L51_52 L106_107 0.1765
K20069 L51_52 L64_65 0.1369
K20070 L51_52 L193_194 0.0436
K20071 L51_52 L21_65 0.0854
K20072 L51_52 L121_122 0.1537
K20073 L51_52 L134_135 0.0332
K20074 L51_52 L171_172 0.0438
K20075 L51_52 L104_105 0.0195
K20076 L51_52 L151_210 0.0344
K20077 L51_52 L183_184 0.0482
K20078 L51_52 L59_60 0.2392
K20079 L51_52 L38_39 0.0423
K20080 L51_52 L27_28 0.0568
K20081 L51_52 L96_97 0.0251
K20082 L51_52 L78_79 0.04
K20083 L51_52 L44_45 0.0333
K20084 L51_52 L47_48 0.4331
K20085 L51_52 L29_30 0.0503
K20086 L51_52 L76_77 0.0437
K20087 L51_52 L166_167 0.0498
K20088 L51_52 L16_17 0.0521
K20089 L51_52 L176_177 0.03
K20090 L51_52 L149_150 0.0241
K20091 L51_52 L2_3 0.0323
K20092 L51_52 L98_99 0.0254
K20093 L51_52 L84_98 0.026
K20094 L51_52 L48_49 0.2045
K20095 L51_52 L80_81 0.0405
K20096 L51_52 L141_202 0.0399
K20097 L51_52 L87_88 0.0364
K20098 L51_52 L146_147 0.0259
K20099 L51_52 L136_137 0.0281
K20100 L51_52 L127_128 0.1684
K20101 L51_52 L138_139 0.0266
K20102 L51_52 L28_29 0.0534
K20103 L51_52 L157_158 0.0514
K20104 L51_52 L129_130 0.0837
K20105 L51_52 L21_22 0.0604
K20106 L51_52 L117_118 0.2659
K20107 L51_52 L56_57 0.1933
K20108 L51_52 L116_117 0.1743
K20109 L51_52 L154_155 0.0195
K20110 L51_52 L82_83 0.0405
K20111 L51_52 L14_15 0.0416
K20112 L51_52 L184_185 0.0445
K20113 L51_52 L125_187 0.0515
K20114 L51_52 L58_59 0.1646
K20115 L51_52 L70_71 0.045
K20116 L51_52 L68_69 0.0438
K20117 L51_52 L89_102 0.0209
K20118 L51_52 L36_37 0.0457
K20119 L51_52 L90_91 0.0275
K20120 L51_52 L139_140 0.0259
K20121 L51_52 L161_162 0.0564
K20122 L51_52 L162_163 0.053
K20123 L51_52 L137_138 0.0274
K20124 L51_52 L12_13 0.0488
K20125 L51_52 L142_143 0.0263
K20126 L51_52 L123_124 0.1537
K20127 L51_52 L191_192 0.0436
K20128 L51_52 L39_40 0.0407
K20129 L51_52 L18_19 0.0442
K20130 L51_52 L156_157 0.0553
K20131 L51_52 L54_55 0.1933
K20132 L51_52 L201_202 0.0425
K20133 L51_55 L181_185 0.0313
K20134 L51_55 L140_145 0.0193
K20135 L51_55 L1_6 0.0506
K20136 L51_55 L35_40 0.0318
K20137 L51_55 L73_78 0.0439
K20138 L51_55 L163_168 0.0376
K20139 L51_55 L91_95 0.0247
K20140 L51_55 L130_160 0.042
K20141 L51_55 L4_9 0.0313
K20142 L51_55 L202_206 0.042
K20143 L51_55 L109_114 0.0734
K20144 L51_55 L57_61 0.0741
K20145 L51_55 L164_169 0.0335
K20146 L51_55 L9_14 0.0314
K20147 L51_55 L53_57 0.0744
K20148 L51_55 L69_73 0.0457
K20149 L51_55 L145_150 0.0189
K20150 L51_55 L30_35 0.0336
K20151 L51_55 L131_136 0.0358
K20152 L51_55 L46_50 0.1506
K20153 L51_55 L92_96 0.0239
K20154 L51_55 L19_24 0.0312
K20155 L51_55 L120_125 0.0503
K20156 L51_55 L60_64 0.1103
K20157 L51_55 L193_197 0.0513
K20158 L51_55 L7_12 0.0351
K20159 L51_55 L137_142 0.0254
K20160 L51_55 L167_172 0.0369
K20161 L51_55 L121_126 0.1322
K20162 L51_55 L110_115 0.0503
K20163 L51_55 L141_146 0.0336
K20164 L51_55 L33_38 0.0371
K20165 L51_55 L124_129 0.0726
K20166 L51_55 L78_83 0.0421
K20167 L51_55 L134_139 0.0245
K20168 L51_55 L40_45 0.0298
K20169 L51_55 L183_187 0.0349
K20170 L51_55 L5_10 0.025
K20171 L51_55 L15_20 0.025
K20172 L51_55 L58_62 0.1402
K20173 L51_55 L29_34 0.0377
K20174 L51_55 L179_183 0.0349
K20175 L51_55 L158_189 0.0311
K20176 L51_55 L206_210 0.0404
K20177 L51_55 L41_74 0.0359
K20178 L51_55 L131_170 0.0337
K20179 L51_55 L191_195 0.0453
K20180 L51_55 L66_70 0.0455
K20181 L51_55 L98_102 0.024
K20182 L51_55 L27_32 0.0416
K20183 L51_55 L147_152 0.024
K20184 L51_55 L178_182 0.0249
K20185 L51_55 L180_184 0.033
K20186 L51_55 L3_8 0.0331
K20187 L51_55 L157_162 0.0413
K20188 L51_55 L149_154 0.0227
K20189 L51_55 L2_7 0.0351
K20190 L51_55 L38_43 0.0344
K20191 L51_55 L113_118 0.1114
K20192 L51_55 L108_113 0.1104
K20193 L51_55 L135_174 0.0297
K20194 L51_55 L160_165 0.0397
K20195 L51_55 L52_56 0.1145
K20196 L51_55 L115_120 0.0504
K20197 L51_55 L80_85 0.0385
K20198 L51_55 L10_15 0.025
K20199 L51_55 L16_21 0.0503
K20200 L51_55 L158_163 0.0392
K20201 L51_55 L96_100 0.0233
K20202 L51_55 L49_53 0.0741
K20203 L51_55 L186_190 0.0249
K20204 L51_55 L82_87 0.0444
K20205 L51_55 L125_130 0.05
K20206 L51_55 L184_188 0.0329
K20207 L51_55 L159_164 0.0349
K20208 L51_55 L84_89 0.0326
K20209 L51_55 L25_30 0.035
K20210 L51_55 L14_19 0.0313
K20211 L51_55 L44_92 0.0246
K20212 L51_55 L21_26 0.0422
K20213 L51_55 L74_79 0.0348
K20214 L51_55 L165_170 0.0368
K20215 L51_55 L199_203 0.0405
K20216 L51_55 L75_80 0.0406
K20217 L51_55 L70_75 0.043
K20218 L51_55 L50_54 0.1548
K20219 L51_55 L79_84 0.0336
K20220 L51_55 L56_60 0.1134
K20221 L51_55 L93_97 0.0194
K20222 L51_55 L90_94 0.0255
K20223 L51_55 L134_173 0.0331
K20224 L51_55 L139_144 0.0239
K20225 L51_55 L177_181 0.0312
K20226 L51_55 L111_116 0.1437
K20227 L51_55 L162_167 0.0394
K20228 L51_55 L43_91 0.0254
K20229 L51_55 L142_147 0.0247
K20230 L51_55 L135_140 0.0198
K20231 L51_55 L39_44 0.0331
K20232 L51_55 L123_128 0.1076
K20233 L51_55 L12_17 0.0351
K20234 L51_55 L54_58 0.1506
K20235 L51_55 L146_151 0.0325
K20236 L51_55 L61_65 0.0733
K20237 L51_55 L77_82 0.0466
K20238 L27_28 L167_168 0.1203
K20239 L27_28 L74_90 0.0419
K20240 L27_28 L199_200 0.0328
K20241 L27_28 L115_179 0.0758
K20242 L27_28 L196_197 0.039
K20243 L27_28 L1_2 0.0624
K20244 L27_28 L23_24 0.1502
K20245 L27_28 L158_159 0.1299
K20246 L27_28 L91_92 0.0419
K20247 L27_28 L126_127 0.0445
K20248 L27_28 L204_205 0.0364
K20249 L27_28 L153_154 0.0285
K20250 L27_28 L4_5 0.0606
K20251 L27_28 L41_42 0.0577
K20252 L27_28 L200_201 0.0377
K20253 L27_28 L50_51 0.0449
K20254 L27_28 L131_132 0.057
K20255 L27_28 L100_101 0.0361
K20256 L27_28 L92_93 0.0415
K20257 L27_28 L148_149 0.0361
K20258 L27_28 L19_20 0.1032
K20259 L27_28 L187_188 0.1055
K20260 L27_28 L165_166 0.1203
K20261 L27_28 L102_103 0.0287
K20262 L27_28 L106_107 0.0414
K20263 L27_28 L64_65 0.0857
K20264 L27_28 L8_9 0.0781
K20265 L27_28 L193_194 0.0439
K20266 L27_28 L21_65 0.1415
K20267 L27_28 L121_122 0.0467
K20268 L27_28 L9_10 0.0757
K20269 L27_28 L134_135 0.0564
K20270 L27_28 L171_172 0.0817
K20271 L27_28 L104_105 0.0285
K20272 L27_28 L151_210 0.0415
K20273 L27_28 L112_113 0.0564
K20274 L27_28 L183_184 0.0888
K20275 L27_28 L59_60 0.0611
K20276 L27_28 L38_39 0.0827
K20277 L27_28 L78_79 0.0494
K20278 L27_28 L44_45 0.057
K20279 L27_28 L47_48 0.0525
K20280 L27_28 L76_77 0.0379
K20281 L27_28 L166_167 0.1221
K20282 L27_28 L16_17 0.1098
K20283 L27_28 L176_177 0.0607
K20284 L27_28 L6_53 0.0978
K20285 L27_28 L149_150 0.0359
K20286 L27_28 L2_3 0.063
K20287 L27_28 L98_99 0.0364
K20288 L27_28 L84_98 0.0363
K20289 L27_28 L48_49 0.0685
K20290 L27_28 L113_114 0.0737
K20291 L27_28 L52_53 0.0747
K20292 L27_28 L80_81 0.032
K20293 L27_28 L141_202 0.0491
K20294 L27_28 L87_88 0.0376
K20295 L27_28 L146_147 0.0361
K20296 L27_28 L136_137 0.0416
K20297 L27_28 L127_128 0.0585
K20298 L27_28 L138_139 0.0416
K20299 L27_28 L181_182 0.0736
K20300 L27_28 L157_158 0.1389
K20301 L27_28 L96_97 0.0386
K20302 L27_28 L129_130 0.1333
K20303 L27_28 L21_22 0.1502
K20304 L27_28 L117_118 0.0585
K20305 L27_28 L56_57 0.0799
K20306 L27_28 L116_117 0.0457
K20307 L27_28 L154_155 0.0283
K20308 L27_28 L7_8 0.079
K20309 L27_28 L82_83 0.0417
K20310 L27_28 L14_15 0.0875
K20311 L27_28 L184_185 0.0876
K20312 L27_28 L125_187 0.1035
K20313 L27_28 L58_59 0.0469
K20314 L27_28 L70_71 0.0337
K20315 L27_28 L68_69 0.0441
K20316 L27_28 L89_102 0.0286
K20317 L27_28 L36_37 0.0827
K20318 L27_28 L90_91 0.042
K20319 L27_28 L139_140 0.0412
K20320 L27_28 L111_112 0.0447
K20321 L27_28 L137_138 0.0417
K20322 L27_28 L179_180 0.0766
K20323 L27_28 L12_13 0.0927
K20324 L27_28 L142_143 0.0387
K20325 L27_28 L123_124 0.0838
K20326 L27_28 L191_192 0.032
K20327 L27_28 L39_40 0.0811
K20328 L27_28 L18_19 0.1098
K20329 L27_28 L156_157 0.1425
K20330 L27_28 L54_55 0.046
K20331 L27_28 L201_202 0.0434
K20332 L67_71 L181_185 0.0245
K20333 L67_71 L140_145 0.0249
K20334 L67_71 L1_6 0.0348
K20335 L67_71 L35_40 0.0336
K20336 L67_71 L73_78 0.0741
K20337 L67_71 L163_168 0.0354
K20338 L67_71 L91_95 0.0331
K20339 L67_71 L130_160 0.0337
K20340 L67_71 L4_9 0.0239
K20341 L67_71 L202_206 0.0726
K20342 L67_71 L109_114 0.0437
K20343 L67_71 L57_61 0.0476
K20344 L67_71 L164_169 0.0317
K20345 L67_71 L9_14 0.0246
K20346 L67_71 L53_57 0.0457
K20347 L67_71 L69_73 0.0744
K20348 L67_71 L145_150 0.0248
K20349 L67_71 L30_35 0.0318
K20350 L67_71 L131_136 0.0504
K20351 L67_71 L46_50 0.043
K20352 L67_71 L92_96 0.0313
K20353 L67_71 L19_24 0.0258
K20354 L67_71 L120_125 0.037
K20355 L67_71 L60_64 0.0574
K20356 L67_71 L193_197 0.1114
K20357 L67_71 L7_12 0.0262
K20358 L67_71 L137_142 0.0349
K20359 L67_71 L167_172 0.0394
K20360 L67_71 L121_126 0.0513
K20361 L67_71 L110_115 0.0347
K20362 L67_71 L141_146 0.05
K20363 L67_71 L33_38 0.0395
K20364 L67_71 L124_129 0.0494
K20365 L67_71 L78_83 0.0733
K20366 L67_71 L134_139 0.0313
K20367 L67_71 L40_45 0.035
K20368 L67_71 L183_187 0.0269
K20369 L67_71 L5_10 0.0194
K20370 L67_71 L15_20 0.0204
K20371 L67_71 L58_62 0.0517
K20372 L67_71 L29_34 0.0356
K20373 L67_71 L179_183 0.0262
K20374 L67_71 L158_189 0.0258
K20375 L67_71 L206_210 0.0713
K20376 L67_71 L41_74 0.0507
K20377 L67_71 L131_170 0.042
K20378 L67_71 L191_195 0.1437
K20379 L67_71 L66_70 0.1548
K20380 L67_71 L98_102 0.0346
K20381 L67_71 L27_32 0.0387
K20382 L67_71 L147_152 0.0344
K20383 L67_71 L178_182 0.0193
K20384 L67_71 L180_184 0.0253
K20385 L67_71 L3_8 0.0247
K20386 L67_71 L157_162 0.0343
K20387 L67_71 L149_154 0.0309
K20388 L67_71 L2_7 0.0255
K20389 L67_71 L38_43 0.0414
K20390 L67_71 L113_118 0.0513
K20391 L67_71 L108_113 0.0487
K20392 L67_71 L135_174 0.0349
K20393 L67_71 L160_165 0.0368
K20394 L67_71 L52_56 0.0515
K20395 L67_71 L115_120 0.0358
K20396 L67_71 L80_85 0.1273
K20397 L67_71 L10_15 0.0199
K20398 L67_71 L16_21 0.0384
K20399 L67_71 L158_163 0.0331
K20400 L67_71 L96_100 0.0312
K20401 L67_71 L49_53 0.0439
K20402 L67_71 L186_190 0.0203
K20403 L67_71 L82_87 0.1057
K20404 L67_71 L125_130 0.0383
K20405 L67_71 L184_188 0.026
K20406 L67_71 L159_164 0.0297
K20407 L67_71 L84_89 0.0498
K20408 L67_71 L25_30 0.0298
K20409 L67_71 L14_19 0.0252
K20410 L67_71 L44_92 0.0314
K20411 L67_71 L21_26 0.0339
K20412 L67_71 L74_79 0.0506
K20413 L67_71 L165_170 0.0397
K20414 L67_71 L199_203 0.1322
K20415 L67_71 L75_80 0.1402
K20416 L67_71 L70_75 0.1506
K20417 L67_71 L50_54 0.0455
K20418 L67_71 L79_84 0.0503
K20419 L67_71 L56_60 0.0543
K20420 L67_71 L93_97 0.025
K20421 L67_71 L90_94 0.0351
K20422 L67_71 L134_173 0.0392
K20423 L67_71 L139_144 0.0312
K20424 L67_71 L177_181 0.0239
K20425 L67_71 L111_116 0.0453
K20426 L67_71 L162_167 0.0369
K20427 L67_71 L43_91 0.0331
K20428 L67_71 L142_147 0.0347
K20429 L67_71 L135_140 0.0249
K20430 L67_71 L39_44 0.0393
K20431 L67_71 L123_128 0.057
K20432 L67_71 L12_17 0.027
K20433 L67_71 L54_58 0.0484
K20434 L67_71 L146_151 0.0495
K20435 L67_71 L61_65 0.0496
K20436 L67_71 L77_82 0.1103
K20437 L138_139 L167_168 0.0548
K20438 L138_139 L199_200 0.0289
K20439 L138_139 L115_179 0.0235
K20440 L138_139 L1_2 0.0191
K20441 L138_139 L23_24 0.0335
K20442 L138_139 L158_159 0.0337
K20443 L138_139 L163_164 0.0419
K20444 L138_139 L160_161 0.0415
K20445 L138_139 L126_127 0.0245
K20446 L138_139 L204_205 0.0359
K20447 L138_139 L153_154 0.0891
K20448 L138_139 L4_5 0.0192
K20449 L138_139 L41_42 0.1128
K20450 L138_139 L201_202 0.0488
K20451 L138_139 L191_192 0.0319
K20452 L138_139 L200_201 0.0363
K20453 L138_139 L36_37 0.0736
K20454 L138_139 L131_132 0.1231
K20455 L138_139 L100_101 0.1127
K20456 L138_139 L148_149 0.1354
K20457 L138_139 L19_20 0.0266
K20458 L138_139 L187_188 0.0268
K20459 L138_139 L165_166 0.0537
K20460 L138_139 L102_103 0.0789
K20461 L138_139 L106_107 0.022
K20462 L138_139 L64_65 0.0323
K20463 L138_139 L8_9 0.0236
K20464 L138_139 L193_194 0.0623
K20465 L138_139 L21_65 0.036
K20466 L138_139 L121_122 0.0253
K20467 L138_139 L9_10 0.0235
K20468 L138_139 L134_135 0.1375
K20469 L138_139 L171_172 0.0781
K20470 L138_139 L104_105 0.0789
K20471 L138_139 L151_210 0.0636
K20472 L138_139 L112_113 0.0267
K20473 L138_139 L183_184 0.0251
K20474 L138_139 L59_60 0.0288
K20475 L138_139 L38_39 0.0766
K20476 L138_139 L78_79 0.0723
K20477 L138_139 L44_45 0.1234
K20478 L138_139 L47_48 0.0246
K20479 L138_139 L29_30 0.0416
K20480 L138_139 L76_77 0.0361
K20481 L138_139 L166_167 0.0545
K20482 L138_139 L16_17 0.0265
K20483 L138_139 L176_177 0.0193
K20484 L138_139 L6_53 0.0319
K20485 L138_139 L149_150 0.1284
K20486 L138_139 L2_3 0.0192
K20487 L138_139 L98_99 0.1127
K20488 L138_139 L84_98 0.1015
K20489 L138_139 L48_49 0.0272
K20490 L138_139 L113_114 0.0296
K20491 L138_139 L52_53 0.0295
K20492 L138_139 L80_81 0.0286
K20493 L138_139 L141_202 0.0741
K20494 L138_139 L87_88 0.0434
K20495 L138_139 L146_147 0.1124
K20496 L138_139 L127_128 0.0283
K20497 L138_139 L181_182 0.0237
K20498 L138_139 L28_29 0.0417
K20499 L138_139 L157_158 0.0338
K20500 L138_139 L96_97 0.1438
K20501 L138_139 L129_130 0.0363
K20502 L138_139 L21_22 0.0332
K20503 L138_139 L117_118 0.0278
K20504 L138_139 L56_57 0.031
K20505 L138_139 L116_117 0.0245
K20506 L138_139 L154_155 0.0861
K20507 L138_139 L7_8 0.0235
K20508 L138_139 L82_83 0.0474
K20509 L138_139 L14_15 0.025
K20510 L138_139 L184_185 0.0252
K20511 L138_139 L125_187 0.0266
K20512 L138_139 L58_59 0.0252
K20513 L138_139 L68_69 0.061
K20514 L138_139 L89_102 0.073
K20515 L138_139 L50_51 0.0238
K20516 L138_139 L161_162 0.0419
K20517 L138_139 L111_112 0.0238
K20518 L138_139 L162_163 0.042
K20519 L138_139 L179_180 0.0237
K20520 L138_139 L12_13 0.025
K20521 L138_139 L142_143 0.1832
K20522 L138_139 L123_124 0.0327
K20523 L138_139 L39_40 0.0758
K20524 L138_139 L18_19 0.0267
K20525 L138_139 L156_157 0.0337
K20526 L138_139 L54_55 0.0245
K20527 L166_167 L74_90 0.0538
K20528 L166_167 L199_200 0.0355
K20529 L166_167 L115_179 0.0545
K20530 L166_167 L196_197 0.0434
K20531 L166_167 L1_2 0.0435
K20532 L166_167 L23_24 0.0865
K20533 L166_167 L158_159 0.0864
K20534 L166_167 L163_164 0.12
K20535 L166_167 L91_92 0.0538
K20536 L166_167 L160_161 0.1258
K20537 L166_167 L126_127 0.0421
K20538 L166_167 L204_205 0.0406
K20539 L166_167 L153_154 0.0354
K20540 L166_167 L4_5 0.0429
K20541 L166_167 L41_42 0.0767
K20542 L166_167 L200_201 0.0419
K20543 L166_167 L36_37 0.1203
K20544 L166_167 L131_132 0.0782
K20545 L166_167 L100_101 0.0445
K20546 L166_167 L92_93 0.053
K20547 L166_167 L148_149 0.0454
K20548 L166_167 L19_20 0.0653
K20549 L166_167 L102_103 0.0352
K20550 L166_167 L106_107 0.0383
K20551 L166_167 L64_65 0.0698
K20552 L166_167 L8_9 0.0538
K20553 L166_167 L193_194 0.0509
K20554 L166_167 L21_65 0.0915
K20555 L166_167 L121_122 0.0438
K20556 L166_167 L9_10 0.053
K20557 L166_167 L187_188 0.0688
K20558 L166_167 L134_135 0.0766
K20559 L166_167 L171_172 0.1279
K20560 L166_167 L104_105 0.0348
K20561 L166_167 L151_210 0.0497
K20562 L166_167 L112_113 0.0501
K20563 L166_167 L183_184 0.061
K20564 L166_167 L59_60 0.0542
K20565 L166_167 L38_39 0.1203
K20566 L166_167 L78_79 0.0592
K20567 L166_167 L44_45 0.0751
K20568 L166_167 L47_48 0.0459
K20569 L166_167 L29_30 0.1153
K20570 L166_167 L76_77 0.0418
K20571 L166_167 L16_17 0.0668
K20572 L166_167 L176_177 0.0441
K20573 L166_167 L6_53 0.0711
K20574 L166_167 L149_150 0.045
K20575 L166_167 L2_3 0.0437
K20576 L166_167 L98_99 0.0451
K20577 L166_167 L84_98 0.045
K20578 L166_167 L48_49 0.0556
K20579 L166_167 L113_114 0.0611
K20580 L166_167 L52_53 0.0606
K20581 L166_167 L80_81 0.0345
K20582 L166_167 L141_202 0.0598
K20583 L166_167 L87_88 0.0429
K20584 L166_167 L146_147 0.0454
K20585 L166_167 L136_137 0.0545
K20586 L166_167 L127_128 0.0535
K20587 L166_167 L181_182 0.0537
K20588 L166_167 L28_29 0.1203
K20589 L166_167 L157_158 0.0888
K20590 L166_167 L96_97 0.0484
K20591 L166_167 L129_130 0.0939
K20592 L166_167 L21_22 0.0865
K20593 L166_167 L117_118 0.0523
K20594 L166_167 L56_57 0.0646
K20595 L166_167 L116_117 0.0426
K20596 L166_167 L154_155 0.0351
K20597 L166_167 L7_8 0.054
K20598 L166_167 L82_83 0.0476
K20599 L166_167 L14_15 0.0585
K20600 L166_167 L184_185 0.0606
K20601 L166_167 L125_187 0.0683
K20602 L166_167 L58_59 0.0436
K20603 L166_167 L70_71 0.0362
K20604 L166_167 L68_69 0.0505
K20605 L166_167 L89_102 0.0351
K20606 L166_167 L50_51 0.0412
K20607 L166_167 L90_91 0.054
K20608 L166_167 L139_140 0.0537
K20609 L166_167 L161_162 0.1279
K20610 L166_167 L111_112 0.0414
K20611 L166_167 L162_163 0.1258
K20612 L166_167 L137_138 0.0548
K20613 L166_167 L179_180 0.0548
K20614 L166_167 L12_13 0.0599
K20615 L166_167 L142_143 0.0498
K20616 L166_167 L123_124 0.0698
K20617 L166_167 L191_192 0.0344
K20618 L166_167 L39_40 0.1153
K20619 L166_167 L18_19 0.0668
K20620 L166_167 L156_157 0.0897
K20621 L166_167 L54_55 0.0424
K20622 L166_167 L201_202 0.0502
K20623 L206_210 L140_145 0.0417
K20624 L206_210 L1_6 0.0376
K20625 L206_210 L35_40 0.0454
K20626 L206_210 L184_188 0.0301
K20627 L206_210 L163_168 0.0448
K20628 L206_210 L91_95 0.0581
K20629 L206_210 L130_160 0.0391
K20630 L206_210 L4_9 0.027
K20631 L206_210 L181_185 0.0282
K20632 L206_210 L164_169 0.0402
K20633 L206_210 L9_14 0.0281
K20634 L206_210 L200_204 0.0741
K20635 L206_210 L145_150 0.0421
K20636 L206_210 L30_35 0.04
K20637 L206_210 L131_136 0.1002
K20638 L206_210 L46_50 0.0312
K20639 L206_210 L196_200 0.0733
K20640 L206_210 L92_96 0.0531
K20641 L206_210 L19_24 0.0305
K20642 L206_210 L120_125 0.0415
K20643 L206_210 L60_64 0.0487
K20644 L206_210 L193_197 0.1057
K20645 L206_210 L7_12 0.0294
K20646 L206_210 L137_142 0.0654
K20647 L206_210 L167_172 0.054
K20648 L206_210 L121_126 0.035
K20649 L206_210 L110_115 0.0377
K20650 L206_210 L113_118 0.0444
K20651 L206_210 L134_139 0.0526
K20652 L206_210 L141_146 0.1086
K20653 L206_210 L33_38 0.0536
K20654 L206_210 L112_117 0.0405
K20655 L206_210 L40_45 0.0512
K20656 L206_210 L183_187 0.0309
K20657 L206_210 L59_63 0.0437
K20658 L206_210 L5_10 0.022
K20659 L206_210 L15_20 0.0237
K20660 L206_210 L58_62 0.0349
K20661 L206_210 L29_34 0.0446
K20662 L206_210 L179_183 0.0295
K20663 L206_210 L41_74 0.0977
K20664 L206_210 L131_170 0.0654
K20665 L206_210 L191_195 0.0545
K20666 L206_210 L66_70 0.0541
K20667 L206_210 L98_102 0.0659
K20668 L206_210 L27_32 0.048
K20669 L206_210 L142_147 0.0667
K20670 L206_210 L147_152 0.0671
K20671 L206_210 L178_182 0.022
K20672 L206_210 L180_184 0.0288
K20673 L206_210 L3_8 0.0276
K20674 L206_210 L157_162 0.0404
K20675 L206_210 L149_154 0.0546
K20676 L206_210 L2_7 0.0282
K20677 L206_210 L117_122 0.0421
K20678 L206_210 L158_189 0.0306
K20679 L206_210 L38_43 0.0621
K20680 L206_210 L135_174 0.0516
K20681 L206_210 L160_165 0.0458
K20682 L206_210 L52_56 0.0443
K20683 L206_210 L115_120 0.0395
K20684 L206_210 L80_85 0.0555
K20685 L206_210 L10_15 0.0228
K20686 L206_210 L16_21 0.0435
K20687 L206_210 L158_163 0.0393
K20688 L206_210 L96_100 0.0537
K20689 L206_210 L165_170 0.0544
K20690 L206_210 L186_190 0.0238
K20691 L206_210 L82_87 0.1114
K20692 L206_210 L125_130 0.0437
K20693 L206_210 L108_113 0.0425
K20694 L206_210 L159_164 0.0355
K20695 L206_210 L84_89 0.1064
K20696 L206_210 L204_208 0.0744
K20697 L206_210 L25_30 0.0354
K20698 L206_210 L14_19 0.0292
K20699 L206_210 L44_92 0.052
K20700 L206_210 L21_26 0.0389
K20701 L206_210 L74_79 0.1022
K20702 L206_210 L199_203 0.0558
K20703 L206_210 L75_80 0.0554
K20704 L206_210 L70_75 0.0549
K20705 L206_210 L50_54 0.0324
K20706 L206_210 L79_84 0.1053
K20707 L206_210 L56_60 0.0464
K20708 L206_210 L93_97 0.0412
K20709 L206_210 L90_94 0.0643
K20710 L206_210 L134_173 0.0587
K20711 L206_210 L139_144 0.0537
K20712 L206_210 L177_181 0.0271
K20713 L206_210 L111_116 0.0325
K20714 L206_210 L162_167 0.0465
K20715 L206_210 L43_91 0.0568
K20716 L206_210 L122_127 0.0439
K20717 L206_210 L135_140 0.0409
K20718 L206_210 L39_44 0.0582
K20719 L206_210 L123_128 0.0489
K20720 L206_210 L12_17 0.0308
K20721 L206_210 L54_58 0.0336
K20722 L206_210 L146_151 0.1098
K20723 L206_210 L77_82 0.1104
K20724 L176_177 L167_168 0.0443
K20725 L176_177 L74_90 0.0191
K20726 L176_177 L199_200 0.0175
K20727 L176_177 L115_179 0.1437
K20728 L176_177 L196_197 0.0201
K20729 L176_177 L23_24 0.081
K20730 L176_177 L158_159 0.0843
K20731 L176_177 L163_164 0.0624
K20732 L176_177 L91_92 0.0192
K20733 L176_177 L126_127 0.0219
K20734 L176_177 L204_205 0.0189
K20735 L176_177 L153_154 0.0138
K20736 L176_177 L41_42 0.0254
K20737 L176_177 L200_201 0.0195
K20738 L176_177 L36_37 0.0335
K20739 L176_177 L131_132 0.0255
K20740 L176_177 L100_101 0.0172
K20741 L176_177 L92_93 0.0192
K20742 L176_177 L148_149 0.0173
K20743 L176_177 L19_20 0.0879
K20744 L176_177 L187_188 0.0983
K20745 L176_177 L102_103 0.0138
K20746 L176_177 L160_161 0.0606
K20747 L176_177 L64_65 0.0357
K20748 L176_177 L165_166 0.0434
K20749 L176_177 L193_194 0.0216
K20750 L176_177 L21_65 0.0508
K20751 L176_177 L121_122 0.0237
K20752 L176_177 L9_10 0.1426
K20753 L176_177 L134_135 0.0257
K20754 L176_177 L171_172 0.0341
K20755 L176_177 L104_105 0.0138
K20756 L176_177 L151_210 0.0204
K20757 L176_177 L112_113 0.0302
K20758 L176_177 L183_184 0.1362
K20759 L176_177 L59_60 0.0295
K20760 L176_177 L38_39 0.0339
K20761 L176_177 L96_97 0.0182
K20762 L176_177 L78_79 0.0236
K20763 L176_177 L44_45 0.0255
K20764 L176_177 L29_30 0.0607
K20765 L176_177 L76_77 0.0195
K20766 L176_177 L16_17 0.0801
K20767 L176_177 L6_53 0.0612
K20768 L176_177 L149_150 0.0173
K20769 L176_177 L98_99 0.0172
K20770 L176_177 L84_98 0.0172
K20771 L176_177 L113_114 0.0408
K20772 L176_177 L52_53 0.0403
K20773 L176_177 L80_81 0.017
K20774 L176_177 L141_202 0.0236
K20775 L176_177 L87_88 0.0188
K20776 L176_177 L146_147 0.0172
K20777 L176_177 L136_137 0.0192
K20778 L176_177 L127_128 0.0273
K20779 L176_177 L181_182 0.2134
K20780 L176_177 L28_29 0.0613
K20781 L176_177 L157_158 0.0863
K20782 L176_177 L129_130 0.0519
K20783 L176_177 L21_22 0.0752
K20784 L176_177 L117_118 0.03
K20785 L176_177 L56_57 0.0398
K20786 L176_177 L116_117 0.0239
K20787 L176_177 L154_155 0.0138
K20788 L176_177 L7_8 0.1426
K20789 L176_177 L82_83 0.0208
K20790 L176_177 L14_15 0.1117
K20791 L176_177 L184_185 0.1487
K20792 L176_177 L125_187 0.0877
K20793 L176_177 L58_59 0.0236
K20794 L176_177 L70_71 0.0179
K20795 L176_177 L68_69 0.0216
K20796 L176_177 L89_102 0.0137
K20797 L176_177 L8_9 0.1566
K20798 L176_177 L50_51 0.0239
K20799 L176_177 L90_91 0.0192
K20800 L176_177 L139_140 0.0193
K20801 L176_177 L161_162 0.0624
K20802 L176_177 L111_112 0.024
K20803 L176_177 L162_163 0.063
K20804 L176_177 L137_138 0.0193
K20805 L176_177 L179_180 0.2134
K20806 L176_177 L12_13 0.1117
K20807 L176_177 L142_143 0.0183
K20808 L176_177 L123_124 0.0394
K20809 L176_177 L191_192 0.0171
K20810 L176_177 L39_40 0.0338
K20811 L176_177 L18_19 0.0911
K20812 L176_177 L156_157 0.0843
K20813 L176_177 L54_55 0.0238
K20814 L176_177 L201_202 0.0216
K20815 L147_152 L181_185 0.0221
K20816 L147_152 L140_145 0.0787
K20817 L147_152 L1_6 0.0266
K20818 L147_152 L35_40 0.0443
K20819 L147_152 L73_78 0.0643
K20820 L147_152 L184_188 0.0235
K20821 L147_152 L163_168 0.0389
K20822 L147_152 L91_95 0.1226
K20823 L147_152 L130_160 0.0341
K20824 L147_152 L4_9 0.0209
K20825 L147_152 L202_206 0.0667
K20826 L147_152 L109_114 0.0282
K20827 L147_152 L57_61 0.0308
K20828 L147_152 L164_169 0.0354
K20829 L147_152 L53_57 0.0294
K20830 L147_152 L69_73 0.0624
K20831 L147_152 L200_204 0.0351
K20832 L147_152 L145_150 0.0861
K20833 L147_152 L30_35 0.0351
K20834 L147_152 L131_136 0.1012
K20835 L147_152 L46_50 0.0186
K20836 L147_152 L196_200 0.0349
K20837 L147_152 L92_96 0.1015
K20838 L147_152 L19_24 0.0246
K20839 L147_152 L120_125 0.0297
K20840 L147_152 L60_64 0.0287
K20841 L147_152 L193_197 0.0448
K20842 L147_152 L167_172 0.051
K20843 L147_152 L121_126 0.0203
K20844 L147_152 L110_115 0.0267
K20845 L147_152 L113_118 0.0268
K20846 L147_152 L141_146 0.1224
K20847 L147_152 L9_14 0.022
K20848 L147_152 L33_38 0.0503
K20849 L147_152 L134_139 0.0953
K20850 L147_152 L124_129 0.0324
K20851 L147_152 L78_83 0.0655
K20852 L147_152 L112_117 0.024
K20853 L147_152 L40_45 0.0592
K20854 L147_152 L59_63 0.0254
K20855 L147_152 L5_10 0.0172
K20856 L147_152 L15_20 0.0191
K20857 L147_152 L58_62 0.0203
K20858 L147_152 L29_34 0.0385
K20859 L147_152 L41_74 0.0959
K20860 L147_152 L131_170 0.0951
K20861 L147_152 L191_195 0.0268
K20862 L147_152 L178_182 0.0172
K20863 L147_152 L180_184 0.0222
K20864 L147_152 L3_8 0.021
K20865 L147_152 L157_162 0.0321
K20866 L147_152 L149_154 0.1354
K20867 L147_152 L66_70 0.0267
K20868 L147_152 L117_122 0.0247
K20869 L147_152 L158_189 0.0247
K20870 L147_152 L38_43 0.0699
K20871 L147_152 L135_174 0.0606
K20872 L147_152 L160_165 0.0433
K20873 L147_152 L52_56 0.0267
K20874 L147_152 L115_120 0.0281
K20875 L147_152 L80_85 0.0271
K20876 L147_152 L10_15 0.0181
K20877 L147_152 L16_21 0.0313
K20878 L147_152 L158_163 0.0318
K20879 L147_152 L96_100 0.1127
K20880 L147_152 L49_53 0.0282
K20881 L147_152 L186_190 0.0192
K20882 L147_152 L82_87 0.0457
K20883 L147_152 L125_130 0.0314
K20884 L147_152 L108_113 0.0258
K20885 L147_152 L159_164 0.0291
K20886 L147_152 L84_89 0.1161
K20887 L147_152 L204_208 0.0351
K20888 L147_152 L25_30 0.0289
K20889 L147_152 L14_19 0.0232
K20890 L147_152 L44_92 0.0884
K20891 L147_152 L21_26 0.0338
K20892 L147_152 L74_79 0.1056
K20893 L147_152 L165_170 0.0596
K20894 L147_152 L199_203 0.0271
K20895 L147_152 L75_80 0.027
K20896 L147_152 L70_75 0.0269
K20897 L147_152 L50_54 0.0192
K20898 L147_152 L79_84 0.1131
K20899 L147_152 L56_60 0.0277
K20900 L147_152 L93_97 0.073
K20901 L147_152 L134_173 0.0685
K20902 L147_152 L139_144 0.1124
K20903 L147_152 L177_181 0.0209
K20904 L147_152 L111_116 0.0192
K20905 L147_152 L162_167 0.0394
K20906 L147_152 L43_91 0.1015
K20907 L147_152 L122_127 0.0255
K20908 L147_152 L135_140 0.0696
K20909 L147_152 L39_44 0.0668
K20910 L147_152 L123_128 0.0288
K20911 L147_152 L54_58 0.0197
K20912 L147_152 L146_151 0.1262
K20913 L147_152 L61_65 0.0322
K20914 L147_152 L77_82 0.0455
K20915 L180_184 L181_185 0.2054
K20916 L180_184 L140_145 0.0206
K20917 L180_184 L1_6 0.0941
K20918 L180_184 L35_40 0.0457
K20919 L180_184 L73_78 0.0314
K20920 L180_184 L163_168 0.0718
K20921 L180_184 L130_160 0.1607
K20922 L180_184 L4_9 0.1438
K20923 L180_184 L202_206 0.0301
K20924 L180_184 L109_114 0.0599
K20925 L180_184 L57_61 0.059
K20926 L180_184 L164_169 0.0641
K20927 L180_184 L53_57 0.0593
K20928 L180_184 L69_73 0.0328
K20929 L180_184 L200_204 0.024
K20930 L180_184 L145_150 0.0194
K20931 L180_184 L30_35 0.0625
K20932 L180_184 L131_136 0.0327
K20933 L180_184 L46_50 0.0256
K20934 L180_184 L196_200 0.0247
K20935 L180_184 L92_96 0.0248
K20936 L180_184 L19_24 0.1226
K20937 L180_184 L120_125 0.0991
K20938 L180_184 L160_165 0.0887
K20939 L180_184 L60_64 0.042
K20940 L180_184 L193_197 0.029
K20941 L180_184 L7_12 0.1536
K20942 L180_184 L137_142 0.025
K20943 L180_184 L121_126 0.0256
K20944 L180_184 L110_115 0.0991
K20945 L180_184 L113_118 0.0427
K20946 L180_184 L141_146 0.0292
K20947 L180_184 L9_14 0.1536
K20948 L180_184 L134_139 0.0266
K20949 L180_184 L124_129 0.059
K20950 L180_184 L78_83 0.03
K20951 L180_184 L112_117 0.0331
K20952 L180_184 L40_45 0.0357
K20953 L180_184 L183_187 0.1832
K20954 L180_184 L59_63 0.0328
K20955 L180_184 L5_10 0.0988
K20956 L180_184 L15_20 0.0988
K20957 L180_184 L58_62 0.0255
K20958 L180_184 L29_34 0.0699
K20959 L180_184 L179_183 0.2054
K20960 L180_184 L158_189 0.1439
K20961 L180_184 L41_74 0.0326
K20962 L180_184 L131_170 0.0427
K20963 L180_184 L191_195 0.0202
K20964 L180_184 L66_70 0.0201
K20965 L180_184 L98_102 0.0221
K20966 L180_184 L27_32 0.093
K20967 L180_184 L142_147 0.0235
K20968 L180_184 L178_182 0.1144
K20969 L180_184 L149_154 0.0222
K20970 L180_184 L2_7 0.1438
K20971 L180_184 L117_122 0.0331
K20972 L180_184 L135_174 0.036
K20973 L180_184 L52_56 0.0424
K20974 L180_184 L115_120 0.1011
K20975 L180_184 L80_85 0.0186
K20976 L180_184 L10_15 0.1033
K20977 L180_184 L16_21 0.0897
K20978 L180_184 L158_163 0.1187
K20979 L180_184 L96_100 0.0234
K20980 L180_184 L49_53 0.059
K20981 L180_184 L186_190 0.1144
K20982 L180_184 L82_87 0.026
K20983 L180_184 L125_130 0.0939
K20984 L180_184 L108_113 0.0426
K20985 L180_184 L159_164 0.1
K20986 L180_184 L84_89 0.0276
K20987 L180_184 L204_208 0.0234
K20988 L180_184 L25_30 0.094
K20989 L180_184 L14_19 0.1438
K20990 L180_184 L44_92 0.0265
K20991 L180_184 L21_26 0.1381
K20992 L180_184 L74_79 0.0307
K20993 L180_184 L165_170 0.058
K20994 L180_184 L199_203 0.0192
K20995 L180_184 L75_80 0.0191
K20996 L180_184 L70_75 0.0196
K20997 L180_184 L50_54 0.0256
K20998 L180_184 L79_84 0.0291
K20999 L180_184 L56_60 0.0423
K21000 L180_184 L93_97 0.0204
K21001 L180_184 L90_94 0.0248
K21002 L180_184 L134_173 0.0394
K21003 L180_184 L139_144 0.025
K21004 L180_184 L177_181 0.1832
K21005 L180_184 L111_116 0.0257
K21006 L180_184 L122_127 0.0329
K21007 L180_184 L135_140 0.0219
K21008 L180_184 L39_44 0.0391
K21009 L180_184 L123_128 0.0423
K21010 L180_184 L12_17 0.1438
K21011 L180_184 L54_58 0.0256
K21012 L180_184 L146_151 0.0277
K21013 L180_184 L61_65 0.0581
K21014 L180_184 L77_82 0.0269
K21015 L157_162 L181_185 0.1879
K21016 L157_162 L140_145 0.0349
K21017 L157_162 L1_6 0.0902
K21018 L157_162 L35_40 0.0917
K21019 L157_162 L73_78 0.0441
K21020 L157_162 L163_168 0.1944
K21021 L157_162 L130_160 0.2473
K21022 L157_162 L4_9 0.1319
K21023 L157_162 L202_206 0.0423
K21024 L157_162 L109_114 0.0686
K21025 L157_162 L57_61 0.0726
K21026 L157_162 L164_169 0.1538
K21027 L157_162 L53_57 0.0704
K21028 L157_162 L69_73 0.0463
K21029 L157_162 L200_204 0.0326
K21030 L157_162 L145_150 0.0323
K21031 L157_162 L30_35 0.1403
K21032 L157_162 L131_136 0.0477
K21033 L157_162 L46_50 0.0318
K21034 L157_162 L196_200 0.0335
K21035 L157_162 L92_96 0.0422
K21036 L157_162 L19_24 0.1886
K21037 L157_162 L120_125 0.1112
K21038 L157_162 L160_165 0.17
K21039 L157_162 L60_64 0.0538
K21040 L157_162 L193_197 0.0399
K21041 L157_162 L7_12 0.1101
K21042 L157_162 L137_142 0.0366
K21043 L157_162 L121_126 0.0328
K21044 L157_162 L110_115 0.0927
K21045 L157_162 L113_118 0.0526
K21046 L157_162 L141_146 0.0421
K21047 L157_162 L9_14 0.1572
K21048 L157_162 L134_139 0.0465
K21049 L157_162 L124_129 0.0754
K21050 L157_162 L78_83 0.0421
K21051 L157_162 L112_117 0.0414
K21052 L157_162 L40_45 0.0648
K21053 L157_162 L183_187 0.1482
K21054 L157_162 L59_63 0.042
K21055 L157_162 L5_10 0.0979
K21056 L157_162 L15_20 0.124
K21057 L157_162 L58_62 0.0327
K21058 L157_162 L29_34 0.1706
K21059 L157_162 L179_183 0.1187
K21060 L157_162 L158_189 0.2444
K21061 L157_162 L41_74 0.0474
K21062 L157_162 L131_170 0.067
K21063 L157_162 L191_195 0.0272
K21064 L157_162 L66_70 0.0272
K21065 L157_162 L98_102 0.0319
K21066 L157_162 L27_32 0.1706
K21067 L157_162 L142_147 0.0342
K21068 L157_162 L178_182 0.1068
K21069 L157_162 L149_154 0.0366
K21070 L157_162 L2_7 0.093
K21071 L157_162 L117_122 0.0419
K21072 L157_162 L135_174 0.0659
K21073 L157_162 L52_56 0.0522
K21074 L157_162 L115_120 0.1019
K21075 L157_162 L80_85 0.0252
K21076 L157_162 L10_15 0.1123
K21077 L157_162 L16_21 0.1143
K21078 L157_162 L158_163 0.2991
K21079 L157_162 L96_100 0.0391
K21080 L157_162 L49_53 0.0678
K21081 L157_162 L186_190 0.143
K21082 L157_162 L82_87 0.0358
K21083 L157_162 L125_130 0.1197
K21084 L157_162 L108_113 0.0515
K21085 L157_162 L159_164 0.2076
K21086 L157_162 L84_89 0.0395
K21087 L157_162 L204_208 0.0317
K21088 L157_162 L25_30 0.1794
K21089 L157_162 L14_19 0.1795
K21090 L157_162 L44_92 0.0459
K21091 L157_162 L21_26 0.2027
K21092 L157_162 L74_79 0.0445
K21093 L157_162 L165_170 0.0983
K21094 L157_162 L199_203 0.0259
K21095 L157_162 L75_80 0.0258
K21096 L157_162 L70_75 0.0265
K21097 L157_162 L50_54 0.0322
K21098 L157_162 L79_84 0.0418
K21099 L157_162 L56_60 0.0531
K21100 L157_162 L93_97 0.0346
K21101 L157_162 L90_94 0.0364
K21102 L157_162 L134_173 0.073
K21103 L157_162 L139_144 0.0427
K21104 L157_162 L177_181 0.1482
K21105 L157_162 L111_116 0.0323
K21106 L157_162 L122_127 0.0422
K21107 L157_162 L135_140 0.0379
K21108 L157_162 L39_44 0.0717
K21109 L157_162 L123_128 0.0541
K21110 L157_162 L12_17 0.1319
K21111 L157_162 L54_58 0.0325
K21112 L157_162 L146_151 0.0397
K21113 L157_162 L61_65 0.0744
K21114 L157_162 L77_82 0.0371
K21115 L2_3 L167_168 0.0435
K21116 L2_3 L74_90 0.0193
K21117 L2_3 L199_200 0.0179
K21118 L2_3 L115_179 0.1426
K21119 L2_3 L196_197 0.0207
K21120 L2_3 L23_24 0.0843
K21121 L2_3 L158_159 0.0752
K21122 L2_3 L163_164 0.0591
K21123 L2_3 L91_92 0.0193
K21124 L2_3 L126_127 0.023
K21125 L2_3 L204_205 0.0193
K21126 L2_3 L153_154 0.0138
K21127 L2_3 L41_42 0.0257
K21128 L2_3 L200_201 0.02
K21129 L2_3 L36_37 0.0341
K21130 L2_3 L131_132 0.0255
K21131 L2_3 L100_101 0.0172
K21132 L2_3 L92_93 0.0192
K21133 L2_3 L148_149 0.0172
K21134 L2_3 L19_20 0.0877
K21135 L2_3 L187_188 0.0911
K21136 L2_3 L102_103 0.0138
K21137 L2_3 L160_161 0.0607
K21138 L2_3 L64_65 0.0391
K21139 L2_3 L165_166 0.0435
K21140 L2_3 L193_194 0.0222
K21141 L2_3 L21_65 0.0579
K21142 L2_3 L121_122 0.0249
K21143 L2_3 L9_10 0.1437
K21144 L2_3 L134_135 0.0254
K21145 L2_3 L171_172 0.0339
K21146 L2_3 L104_105 0.0137
K21147 L2_3 L151_210 0.0206
K21148 L2_3 L112_113 0.0321
K21149 L2_3 L183_184 0.1183
K21150 L2_3 L59_60 0.0316
K21151 L2_3 L38_39 0.0341
K21152 L2_3 L96_97 0.0182
K21153 L2_3 L78_79 0.0241
K21154 L2_3 L44_45 0.0255
K21155 L2_3 L29_30 0.0606
K21156 L2_3 L76_77 0.02
K21157 L2_3 L16_17 0.0983
K21158 L2_3 L6_53 0.0727
K21159 L2_3 L149_150 0.0172
K21160 L2_3 L98_99 0.0173
K21161 L2_3 L84_98 0.0173
K21162 L2_3 L113_114 0.0441
K21163 L2_3 L52_53 0.0447
K21164 L2_3 L80_81 0.0175
K21165 L2_3 L141_202 0.024
K21166 L2_3 L87_88 0.0193
K21167 L2_3 L146_147 0.0172
K21168 L2_3 L136_137 0.0192
K21169 L2_3 L127_128 0.0289
K21170 L2_3 L181_182 0.1153
K21171 L2_3 L28_29 0.0624
K21172 L2_3 L157_158 0.0794
K21173 L2_3 L129_130 0.0564
K21174 L2_3 L21_22 0.0843
K21175 L2_3 L117_118 0.0318
K21176 L2_3 L56_57 0.044
K21177 L2_3 L116_117 0.0251
K21178 L2_3 L154_155 0.0137
K21179 L2_3 L7_8 0.2697
K21180 L2_3 L82_83 0.0213
K21181 L2_3 L14_15 0.1116
K21182 L2_3 L184_185 0.1117
K21183 L2_3 L125_187 0.0879
K21184 L2_3 L58_59 0.025
K21185 L2_3 L70_71 0.0185
K21186 L2_3 L68_69 0.0223
K21187 L2_3 L89_102 0.0138
K21188 L2_3 L8_9 0.2134
K21189 L2_3 L50_51 0.0253
K21190 L2_3 L90_91 0.0193
K21191 L2_3 L139_140 0.0191
K21192 L2_3 L161_162 0.0613
K21193 L2_3 L111_112 0.0252
K21194 L2_3 L162_163 0.0607
K21195 L2_3 L137_138 0.0192
K21196 L2_3 L179_180 0.1566
K21197 L2_3 L12_13 0.1487
K21198 L2_3 L142_143 0.0182
K21199 L2_3 L123_124 0.0424
K21200 L2_3 L191_192 0.0175
K21201 L2_3 L39_40 0.0338
K21202 L2_3 L18_19 0.0983
K21203 L2_3 L156_157 0.081
K21204 L2_3 L54_55 0.0252
K21205 L2_3 L201_202 0.0221
K21206 L2_7 L181_185 0.1127
K21207 L2_7 L140_145 0.0191
K21208 L2_7 L1_6 0.1262
K21209 L2_7 L35_40 0.0412
K21210 L2_7 L73_78 0.0309
K21211 L2_7 L184_188 0.1226
K21212 L2_7 L163_168 0.0598
K21213 L2_7 L91_95 0.0235
K21214 L2_7 L130_160 0.1339
K21215 L2_7 L4_9 0.1354
K21216 L2_7 L202_206 0.0294
K21217 L2_7 L109_114 0.0659
K21218 L2_7 L57_61 0.0654
K21219 L2_7 L164_169 0.0534
K21220 L2_7 L53_57 0.0667
K21221 L2_7 L69_73 0.0324
K21222 L2_7 L200_204 0.024
K21223 L2_7 L145_150 0.0181
K21224 L2_7 L30_35 0.0544
K21225 L2_7 L131_136 0.0313
K21226 L2_7 L46_50 0.0272
K21227 L2_7 L196_200 0.0247
K21228 L2_7 L92_96 0.0233
K21229 L2_7 L19_24 0.0953
K21230 L2_7 L120_125 0.1056
K21231 L2_7 L60_64 0.0448
K21232 L2_7 L193_197 0.0287
K21233 L2_7 L167_172 0.0459
K21234 L2_7 L121_126 0.0267
K21235 L2_7 L110_115 0.1161
K21236 L2_7 L113_118 0.0455
K21237 L2_7 L141_146 0.028
K21238 L2_7 L9_14 0.1284
K21239 L2_7 L33_38 0.0465
K21240 L2_7 L134_139 0.0246
K21241 L2_7 L124_129 0.0624
K21242 L2_7 L78_83 0.0295
K21243 L2_7 L112_117 0.0349
K21244 L2_7 L40_45 0.033
K21245 L2_7 L59_63 0.0346
K21246 L2_7 L5_10 0.0891
K21247 L2_7 L15_20 0.0787
K21248 L2_7 L58_62 0.0268
K21249 L2_7 L29_34 0.061
K21250 L2_7 L41_74 0.0314
K21251 L2_7 L131_170 0.0393
K21252 L2_7 L191_195 0.0203
K21253 L2_7 L178_182 0.0811
K21254 L2_7 L3_8 0.2054
K21255 L2_7 L149_154 0.0209
K21256 L2_7 L66_70 0.0203
K21257 L2_7 L117_122 0.0347
K21258 L2_7 L158_189 0.0884
K21259 L2_7 L38_43 0.0366
K21260 L2_7 L135_174 0.0328
K21261 L2_7 L160_165 0.0763
K21262 L2_7 L52_56 0.0459
K21263 L2_7 L115_120 0.1131
K21264 L2_7 L80_85 0.0187
K21265 L2_7 L10_15 0.0861
K21266 L2_7 L16_21 0.1012
K21267 L2_7 L158_163 0.086
K21268 L2_7 L96_100 0.0221
K21269 L2_7 L49_53 0.0671
K21270 L2_7 L186_190 0.073
K21271 L2_7 L82_87 0.0258
K21272 L2_7 L125_130 0.0959
K21273 L2_7 L108_113 0.0457
K21274 L2_7 L159_164 0.0742
K21275 L2_7 L84_89 0.0267
K21276 L2_7 L204_208 0.0233
K21277 L2_7 L25_30 0.077
K21278 L2_7 L14_19 0.1124
K21279 L2_7 L44_92 0.0247
K21280 L2_7 L21_26 0.156
K21281 L2_7 L74_79 0.0297
K21282 L2_7 L165_170 0.052
K21283 L2_7 L199_203 0.0192
K21284 L2_7 L75_80 0.0192
K21285 L2_7 L70_75 0.0197
K21286 L2_7 L50_54 0.0271
K21287 L2_7 L79_84 0.0281
K21288 L2_7 L56_60 0.0455
K21289 L2_7 L93_97 0.0192
K21290 L2_7 L134_173 0.0359
K21291 L2_7 L139_144 0.0232
K21292 L2_7 L177_181 0.1173
K21293 L2_7 L111_116 0.027
K21294 L2_7 L162_167 0.0619
K21295 L2_7 L43_91 0.025
K21296 L2_7 L122_127 0.0344
K21297 L2_7 L135_140 0.0202
K21298 L2_7 L39_44 0.0362
K21299 L2_7 L123_128 0.0445
K21300 L2_7 L54_58 0.027
K21301 L2_7 L146_151 0.0266
K21302 L2_7 L61_65 0.0634
K21303 L2_7 L77_82 0.0268
K21304 L184_185 L167_168 0.061
K21305 L184_185 L74_90 0.0248
K21306 L184_185 L199_200 0.0218
K21307 L184_185 L115_179 0.1439
K21308 L184_185 L196_197 0.0253
K21309 L184_185 L1_2 0.0969
K21310 L184_185 L23_24 0.1276
K21311 L184_185 L158_159 0.1375
K21312 L184_185 L163_164 0.0913
K21313 L184_185 L91_92 0.025
K21314 L184_185 L160_161 0.0875
K21315 L184_185 L126_127 0.0268
K21316 L184_185 L204_205 0.0237
K21317 L184_185 L153_154 0.0178
K21318 L184_185 L4_5 0.1117
K21319 L184_185 L41_42 0.0332
K21320 L184_185 L200_201 0.0245
K21321 L184_185 L36_37 0.0445
K21322 L184_185 L131_132 0.0334
K21323 L184_185 L100_101 0.0222
K21324 L184_185 L92_93 0.025
K21325 L184_185 L148_149 0.0224
K21326 L184_185 L19_20 0.1438
K21327 L184_185 L187_188 0.1832
K21328 L184_185 L165_166 0.0595
K21329 L184_185 L102_103 0.0177
K21330 L184_185 L106_107 0.0317
K21331 L184_185 L64_65 0.0444
K21332 L184_185 L193_194 0.0275
K21333 L184_185 L21_65 0.0654
K21334 L184_185 L121_122 0.0289
K21335 L184_185 L9_10 0.1438
K21336 L184_185 L134_135 0.0337
K21337 L184_185 L171_172 0.0454
K21338 L184_185 L104_105 0.0177
K21339 L184_185 L151_210 0.026
K21340 L184_185 L112_113 0.0449
K21341 L184_185 L59_60 0.0361
K21342 L184_185 L129_130 0.067
K21343 L184_185 L38_39 0.0451
K21344 L184_185 L96_97 0.0235
K21345 L184_185 L78_79 0.0302
K21346 L184_185 L44_45 0.0335
K21347 L184_185 L47_48 0.0413
K21348 L184_185 L29_30 0.0876
K21349 L184_185 L76_77 0.0245
K21350 L184_185 L16_17 0.1226
K21351 L184_185 L149_150 0.0223
K21352 L184_185 L98_99 0.0222
K21353 L184_185 L6_53 0.1117
K21354 L184_185 L84_98 0.0221
K21355 L184_185 L48_49 0.0596
K21356 L184_185 L113_114 0.0656
K21357 L184_185 L52_53 0.0643
K21358 L184_185 L80_81 0.0212
K21359 L184_185 L141_202 0.0303
K21360 L184_185 L87_88 0.0238
K21361 L184_185 L146_147 0.0222
K21362 L184_185 L136_137 0.025
K21363 L184_185 L127_128 0.0336
K21364 L184_185 L181_182 0.1832
K21365 L184_185 L28_29 0.0888
K21366 L184_185 L157_158 0.1436
K21367 L184_185 L21_22 0.1128
K21368 L184_185 L154_155 0.0178
K21369 L184_185 L7_8 0.1438
K21370 L184_185 L82_83 0.0263
K21371 L184_185 L58_59 0.0287
K21372 L184_185 L125_187 0.1439
K21373 L184_185 L70_71 0.0223
K21374 L184_185 L68_69 0.0274
K21375 L184_185 L89_102 0.0176
K21376 L184_185 L8_9 0.1536
K21377 L184_185 L50_51 0.0339
K21378 L184_185 L90_91 0.025
K21379 L184_185 L139_140 0.0251
K21380 L184_185 L161_162 0.0913
K21381 L184_185 L111_112 0.0341
K21382 L184_185 L162_163 0.0927
K21383 L184_185 L137_138 0.0251
K21384 L184_185 L179_180 0.1832
K21385 L184_185 L142_143 0.0237
K21386 L184_185 L123_124 0.0488
K21387 L184_185 L191_192 0.0213
K21388 L184_185 L39_40 0.045
K21389 L184_185 L156_157 0.1375
K21390 L184_185 L18_19 0.1536
K21391 L184_185 L201_202 0.0275
K21392 L84_98 L167_168 0.0445
K21393 L84_98 L74_90 0.1354
K21394 L84_98 L199_200 0.0385
K21395 L84_98 L115_179 0.0211
K21396 L84_98 L196_197 0.0515
K21397 L84_98 L1_2 0.0173
K21398 L84_98 L23_24 0.0294
K21399 L84_98 L158_159 0.029
K21400 L84_98 L163_164 0.0355
K21401 L84_98 L91_92 0.1124
K21402 L84_98 L160_161 0.0362
K21403 L84_98 L126_127 0.0245
K21404 L84_98 L153_154 0.1062
K21405 L84_98 L4_5 0.0171
K21406 L84_98 L41_42 0.0898
K21407 L84_98 L200_201 0.0527
K21408 L84_98 L36_37 0.061
K21409 L84_98 L131_132 0.0857
K21410 L84_98 L92_93 0.0953
K21411 L84_98 L19_20 0.0233
K21412 L84_98 L187_188 0.0235
K21413 L84_98 L102_103 0.1673
K21414 L84_98 L106_107 0.0218
K21415 L84_98 L64_65 0.0308
K21416 L84_98 L8_9 0.0211
K21417 L84_98 L193_194 0.0716
K21418 L84_98 L21_65 0.0329
K21419 L84_98 L121_122 0.0252
K21420 L84_98 L9_10 0.0209
K21421 L84_98 L134_135 0.0757
K21422 L84_98 L171_172 0.0596
K21423 L84_98 L104_105 0.0968
K21424 L84_98 L151_210 0.09
K21425 L84_98 L112_113 0.0259
K21426 L84_98 L183_184 0.0222
K21427 L84_98 L59_60 0.0282
K21428 L84_98 L38_39 0.0595
K21429 L84_98 L96_97 0.1124
K21430 L84_98 L78_79 0.1855
K21431 L84_98 L44_45 0.0785
K21432 L84_98 L47_48 0.024
K21433 L84_98 L29_30 0.0357
K21434 L84_98 L76_77 0.0533
K21435 L84_98 L16_17 0.0237
K21436 L84_98 L6_53 0.0294
K21437 L84_98 L113_114 0.028
K21438 L84_98 L48_49 0.0258
K21439 L84_98 L52_53 0.028
K21440 L84_98 L141_202 0.1583
K21441 L84_98 L87_88 0.0552
K21442 L84_98 L136_137 0.1173
K21443 L84_98 L127_128 0.0277
K21444 L84_98 L181_182 0.0209
K21445 L84_98 L28_29 0.0361
K21446 L84_98 L157_158 0.0293
K21447 L84_98 L129_130 0.0327
K21448 L84_98 L21_22 0.0297
K21449 L84_98 L117_118 0.027
K21450 L84_98 L56_57 0.0294
K21451 L84_98 L116_117 0.0243
K21452 L84_98 L7_8 0.0212
K21453 L84_98 L154_155 0.0867
K21454 L84_98 L14_15 0.0221
K21455 L84_98 L125_187 0.0236
K21456 L84_98 L58_59 0.0252
K21457 L84_98 L70_71 0.0383
K21458 L84_98 L68_69 0.0737
K21459 L84_98 L89_102 0.1916
K21460 L84_98 L50_51 0.0236
K21461 L84_98 L165_166 0.0451
K21462 L84_98 L90_91 0.1284
K21463 L84_98 L139_140 0.0884
K21464 L84_98 L161_162 0.0361
K21465 L84_98 L111_112 0.0235
K21466 L84_98 L162_163 0.0359
K21467 L84_98 L137_138 0.1127
K21468 L84_98 L179_180 0.0211
K21469 L84_98 L12_13 0.0223
K21470 L84_98 L142_143 0.1438
K21471 L84_98 L123_124 0.0308
K21472 L84_98 L191_192 0.0353
K21473 L84_98 L39_40 0.0578
K21474 L84_98 L18_19 0.0235
K21475 L84_98 L156_157 0.0294
K21476 L84_98 L54_55 0.0244
K21477 L84_98 L201_202 0.0822
K21478 L48_49 L167_168 0.0531
K21479 L48_49 L74_90 0.0285
K21480 L48_49 L199_200 0.0367
K21481 L48_49 L115_179 0.079
K21482 L48_49 L196_197 0.0412
K21483 L48_49 L23_24 0.0661
K21484 L48_49 L158_159 0.0598
K21485 L48_49 L163_164 0.0591
K21486 L48_49 L91_92 0.0273
K21487 L48_49 L126_127 0.077
K21488 L48_49 L204_205 0.0372
K21489 L48_49 L153_154 0.02
K21490 L48_49 L41_42 0.0374
K21491 L48_49 L200_201 0.0391
K21492 L48_49 L36_37 0.0482
K21493 L48_49 L131_132 0.0372
K21494 L48_49 L100_101 0.0245
K21495 L48_49 L92_93 0.0267
K21496 L48_49 L148_149 0.0249
K21497 L48_49 L19_20 0.053
K21498 L48_49 L187_188 0.0639
K21499 L48_49 L102_103 0.0204
K21500 L48_49 L160_161 0.0722
K21501 L48_49 L64_65 0.1605
K21502 L48_49 L165_166 0.0581
K21503 L48_49 L193_194 0.0412
K21504 L48_49 L21_65 0.123
K21505 L48_49 L121_122 0.0858
K21506 L48_49 L9_10 0.0557
K21507 L48_49 L134_135 0.0345
K21508 L48_49 L171_172 0.0464
K21509 L48_49 L104_105 0.0197
K21510 L48_49 L151_210 0.0334
K21511 L48_49 L112_113 0.1765
K21512 L48_49 L183_184 0.0668
K21513 L48_49 L59_60 0.1475
K21514 L48_49 L38_39 0.0452
K21515 L48_49 L96_97 0.0255
K21516 L48_49 L78_79 0.0393
K21517 L48_49 L44_45 0.0347
K21518 L48_49 L29_30 0.0597
K21519 L48_49 L76_77 0.0393
K21520 L48_49 L16_17 0.0737
K21521 L48_49 L6_53 0.2045
K21522 L48_49 L149_150 0.0244
K21523 L48_49 L98_99 0.0254
K21524 L48_49 L113_114 0.2931
K21525 L48_49 L52_53 0.4331
K21526 L48_49 L80_81 0.0352
K21527 L48_49 L141_202 0.0391
K21528 L48_49 L87_88 0.0342
K21529 L48_49 L146_147 0.0258
K21530 L48_49 L136_137 0.0284
K21531 L48_49 L127_128 0.1173
K21532 L48_49 L181_182 0.0548
K21533 L48_49 L28_29 0.0639
K21534 L48_49 L157_158 0.0651
K21535 L48_49 L129_130 0.1173
K21536 L48_49 L21_22 0.0801
K21537 L48_49 L117_118 0.1576
K21538 L48_49 L56_57 0.2809
K21539 L48_49 L116_117 0.0896
K21540 L48_49 L154_155 0.0196
K21541 L48_49 L7_8 0.0708
K21542 L48_49 L82_83 0.0381
K21543 L48_49 L14_15 0.0546
K21544 L48_49 L125_187 0.0716
K21545 L48_49 L58_59 0.0877
K21546 L48_49 L70_71 0.0386
K21547 L48_49 L68_69 0.0414
K21548 L48_49 L89_102 0.0207
K21549 L48_49 L8_9 0.0623
K21550 L48_49 L50_51 0.0947
K21551 L48_49 L90_91 0.0279
K21552 L48_49 L139_140 0.0266
K21553 L48_49 L161_162 0.0675
K21554 L48_49 L111_112 0.0923
K21555 L48_49 L162_163 0.0632
K21556 L48_49 L137_138 0.0278
K21557 L48_49 L179_180 0.0689
K21558 L48_49 L12_13 0.0685
K21559 L48_49 L142_143 0.0265
K21560 L48_49 L123_124 0.1866
K21561 L48_49 L191_192 0.0372
K21562 L48_49 L39_40 0.0436
K21563 L48_49 L18_19 0.0585
K21564 L48_49 L156_157 0.0712
K21565 L48_49 L54_55 0.0917
K21566 L48_49 L201_202 0.04
K21567 L184_188 L181_185 0.1832
K21568 L184_188 L140_145 0.0219
K21569 L184_188 L1_6 0.0897
K21570 L184_188 L35_40 0.0502
K21571 L184_188 L73_78 0.0328
K21572 L184_188 L163_168 0.083
K21573 L184_188 L130_160 0.1889
K21574 L184_188 L4_9 0.1226
K21575 L184_188 L202_206 0.0315
K21576 L184_188 L109_114 0.059
K21577 L184_188 L57_61 0.0593
K21578 L184_188 L164_169 0.0732
K21579 L184_188 L53_57 0.059
K21580 L184_188 L69_73 0.0344
K21581 L184_188 L200_204 0.0247
K21582 L184_188 L145_150 0.0206
K21583 L184_188 L30_35 0.0708
K21584 L184_188 L131_136 0.0348
K21585 L184_188 L46_50 0.0255
K21586 L184_188 L196_200 0.0254
K21587 L184_188 L92_96 0.0265
K21588 L184_188 L19_24 0.1438
K21589 L184_188 L120_125 0.1011
K21590 L184_188 L160_165 0.1065
K21591 L184_188 L60_64 0.0423
K21592 L184_188 L193_197 0.03
K21593 L184_188 L7_12 0.1438
K21594 L184_188 L137_142 0.0266
K21595 L184_188 L121_126 0.0257
K21596 L184_188 L110_115 0.0939
K21597 L184_188 L113_118 0.0426
K21598 L184_188 L141_146 0.0309
K21599 L184_188 L9_14 0.1438
K21600 L184_188 L134_139 0.0285
K21601 L184_188 L124_129 0.0599
K21602 L184_188 L78_83 0.0314
K21603 L184_188 L112_117 0.0331
K21604 L184_188 L40_45 0.0385
K21605 L184_188 L183_187 0.2054
K21606 L184_188 L59_63 0.0329
K21607 L184_188 L5_10 0.088
K21608 L184_188 L15_20 0.1033
K21609 L184_188 L58_62 0.0256
K21610 L184_188 L29_34 0.08
K21611 L184_188 L179_183 0.1832
K21612 L184_188 L158_189 0.1832
K21613 L184_188 L41_74 0.0346
K21614 L184_188 L131_170 0.0468
K21615 L184_188 L191_195 0.0207
K21616 L184_188 L66_70 0.0207
K21617 L184_188 L98_102 0.0234
K21618 L184_188 L27_32 0.1101
K21619 L184_188 L142_147 0.025
K21620 L184_188 L178_182 0.0985
K21621 L184_188 L149_154 0.0235
K21622 L184_188 L117_122 0.0331
K21623 L184_188 L135_174 0.0389
K21624 L184_188 L52_56 0.0423
K21625 L184_188 L115_120 0.0991
K21626 L184_188 L80_85 0.0191
K21627 L184_188 L10_15 0.0988
K21628 L184_188 L16_21 0.0941
K21629 L184_188 L158_163 0.1482
K21630 L184_188 L96_100 0.0248
K21631 L184_188 L49_53 0.0581
K21632 L184_188 L186_190 0.1216
K21633 L184_188 L82_87 0.0269
K21634 L184_188 L125_130 0.0991
K21635 L184_188 L108_113 0.0423
K21636 L184_188 L159_164 0.119
K21637 L184_188 L84_89 0.0291
K21638 L184_188 L204_208 0.024
K21639 L184_188 L25_30 0.1091
K21640 L184_188 L14_19 0.1536
K21641 L184_188 L44_92 0.0283
K21642 L184_188 L21_26 0.1557
K21643 L184_188 L74_79 0.0326
K21644 L184_188 L165_170 0.0657
K21645 L184_188 L199_203 0.0197
K21646 L184_188 L75_80 0.0196
K21647 L184_188 L70_75 0.0201
K21648 L184_188 L50_54 0.0256
K21649 L184_188 L79_84 0.0307
K21650 L184_188 L56_60 0.0424
K21651 L184_188 L93_97 0.0218
K21652 L184_188 L90_94 0.0265
K21653 L184_188 L134_173 0.0427
K21654 L184_188 L139_144 0.0266
K21655 L184_188 L177_181 0.1439
K21656 L184_188 L111_116 0.0257
K21657 L184_188 L122_127 0.0331
K21658 L184_188 L135_140 0.0234
K21659 L184_188 L39_44 0.0422
K21660 L184_188 L123_128 0.0426
K21661 L184_188 L12_17 0.1536
K21662 L184_188 L54_58 0.0256
K21663 L184_188 L146_151 0.0292
K21664 L184_188 L61_65 0.059
K21665 L184_188 L77_82 0.0279
K21666 L52_53 L167_168 0.0577
K21667 L52_53 L74_90 0.0309
K21668 L52_53 L199_200 0.0399
K21669 L52_53 L196_197 0.0448
K21670 L52_53 L23_24 0.0718
K21671 L52_53 L158_159 0.0648
K21672 L52_53 L163_164 0.0642
K21673 L52_53 L91_92 0.0296
K21674 L52_53 L160_161 0.079
K21675 L52_53 L126_127 0.0837
K21676 L52_53 L204_205 0.0404
K21677 L52_53 L153_154 0.0216
K21678 L52_53 L4_5 0.0375
K21679 L52_53 L41_42 0.0407
K21680 L52_53 L200_201 0.0425
K21681 L52_53 L131_132 0.0405
K21682 L52_53 L100_101 0.0265
K21683 L52_53 L92_93 0.0289
K21684 L52_53 L1_2 0.0495
K21685 L52_53 L148_149 0.027
K21686 L52_53 L19_20 0.0573
K21687 L52_53 L187_188 0.0693
K21688 L52_53 L165_166 0.0634
K21689 L52_53 L102_103 0.0221
K21690 L52_53 L106_107 0.0923
K21691 L52_53 L64_65 0.1829
K21692 L52_53 L193_194 0.0448
K21693 L52_53 L21_65 0.1369
K21694 L52_53 L121_122 0.0931
K21695 L52_53 L134_135 0.0375
K21696 L52_53 L171_172 0.0505
K21697 L52_53 L104_105 0.0213
K21698 L52_53 L151_210 0.0363
K21699 L52_53 L183_184 0.0723
K21700 L52_53 L59_60 0.1646
K21701 L52_53 L38_39 0.0491
K21702 L52_53 L96_97 0.0277
K21703 L52_53 L78_79 0.0427
K21704 L52_53 L44_45 0.0377
K21705 L52_53 L47_48 0.2045
K21706 L52_53 L29_30 0.0649
K21707 L52_53 L76_77 0.0427
K21708 L52_53 L16_17 0.0803
K21709 L52_53 L149_150 0.0264
K21710 L52_53 L98_99 0.0276
K21711 L52_53 L80_81 0.0382
K21712 L52_53 L141_202 0.0425
K21713 L52_53 L87_88 0.0371
K21714 L52_53 L146_147 0.028
K21715 L52_53 L136_137 0.0308
K21716 L52_53 L127_128 0.13
K21717 L52_53 L28_29 0.0696
K21718 L52_53 L157_158 0.0707
K21719 L52_53 L129_130 0.13
K21720 L52_53 L21_22 0.0876
K21721 L52_53 L117_118 0.1743
K21722 L52_53 L56_57 0.3334
K21723 L52_53 L116_117 0.0969
K21724 L52_53 L154_155 0.0212
K21725 L52_53 L82_83 0.0414
K21726 L52_53 L14_15 0.0589
K21727 L52_53 L125_187 0.078
K21728 L52_53 L58_59 0.0952
K21729 L52_53 L70_71 0.0419
K21730 L52_53 L68_69 0.0451
K21731 L52_53 L89_102 0.0224
K21732 L52_53 L36_37 0.0525
K21733 L52_53 L90_91 0.0303
K21734 L52_53 L139_140 0.0288
K21735 L52_53 L161_162 0.0737
K21736 L52_53 L162_163 0.0687
K21737 L52_53 L137_138 0.0302
K21738 L52_53 L12_13 0.0741
K21739 L52_53 L142_143 0.0288
K21740 L52_53 L123_124 0.2117
K21741 L52_53 L191_192 0.0404
K21742 L52_53 L39_40 0.0474
K21743 L52_53 L18_19 0.0634
K21744 L52_53 L156_157 0.0776
K21745 L52_53 L54_55 0.0993
K21746 L52_53 L201_202 0.0435
K21747 L160_165 L181_185 0.081
K21748 L160_165 L140_145 0.0404
K21749 L160_165 L35_40 0.1068
K21750 L160_165 L73_78 0.0509
K21751 L160_165 L163_168 0.1786
K21752 L160_165 L91_95 0.051
K21753 L160_165 L4_9 0.0685
K21754 L160_165 L202_206 0.0484
K21755 L160_165 L109_114 0.0615
K21756 L160_165 L57_61 0.0685
K21757 L160_165 L164_169 0.1357
K21758 L160_165 L158_189 0.1087
K21759 L160_165 L53_57 0.0646
K21760 L160_165 L69_73 0.054
K21761 L160_165 L200_204 0.0349
K21762 L160_165 L145_150 0.0369
K21763 L160_165 L30_35 0.1257
K21764 L160_165 L46_50 0.0303
K21765 L160_165 L196_200 0.0359
K21766 L160_165 L92_96 0.0494
K21767 L160_165 L19_24 0.1012
K21768 L160_165 L60_64 0.053
K21769 L160_165 L193_197 0.0446
K21770 L160_165 L7_12 0.0898
K21771 L160_165 L137_142 0.053
K21772 L160_165 L167_172 0.17
K21773 L160_165 L121_126 0.0322
K21774 L160_165 L113_118 0.0501
K21775 L160_165 L134_139 0.0557
K21776 L160_165 L33_38 0.1517
K21777 L160_165 L124_129 0.0735
K21778 L160_165 L78_83 0.0481
K21779 L160_165 L112_117 0.0399
K21780 L160_165 L40_45 0.0772
K21781 L160_165 L183_187 0.1185
K21782 L160_165 L59_63 0.0413
K21783 L160_165 L5_10 0.0537
K21784 L160_165 L15_20 0.0672
K21785 L160_165 L58_62 0.0321
K21786 L160_165 L29_34 0.1599
K21787 L160_165 L179_183 0.0951
K21788 L160_165 L191_195 0.029
K21789 L160_165 L66_70 0.0289
K21790 L160_165 L98_102 0.0428
K21791 L160_165 L27_32 0.2588
K21792 L160_165 L142_147 0.0477
K21793 L160_165 L178_182 0.0552
K21794 L160_165 L3_8 0.0729
K21795 L160_165 L149_154 0.0418
K21796 L160_165 L117_122 0.0407
K21797 L160_165 L38_43 0.0946
K21798 L160_165 L108_113 0.0482
K21799 L160_165 L135_174 0.0795
K21800 L160_165 L52_56 0.0497
K21801 L160_165 L80_85 0.0267
K21802 L160_165 L10_15 0.0601
K21803 L160_165 L158_163 0.1398
K21804 L160_165 L96_100 0.045
K21805 L160_165 L49_53 0.0608
K21806 L160_165 L186_190 0.0703
K21807 L160_165 L82_87 0.0393
K21808 L160_165 L159_164 0.1129
K21809 L160_165 L9_14 0.0777
K21810 L160_165 L204_208 0.0339
K21811 L160_165 L25_30 0.1068
K21812 L160_165 L14_19 0.0887
K21813 L160_165 L44_92 0.0546
K21814 L160_165 L199_203 0.0276
K21815 L160_165 L75_80 0.0275
K21816 L160_165 L70_75 0.0282
K21817 L160_165 L50_54 0.031
K21818 L160_165 L56_60 0.0514
K21819 L160_165 L93_97 0.0398
K21820 L160_165 L90_94 0.052
K21821 L160_165 L134_173 0.0915
K21822 L160_165 L139_144 0.0502
K21823 L160_165 L177_181 0.0707
K21824 L160_165 L111_116 0.0311
K21825 L160_165 L162_167 0.2473
K21826 L160_165 L43_91 0.0568
K21827 L160_165 L122_127 0.0415
K21828 L160_165 L135_140 0.0445
K21829 L160_165 L39_44 0.0885
K21830 L160_165 L123_128 0.0534
K21831 L160_165 L54_58 0.0316
K21832 L160_165 L61_65 0.0724
K21833 L160_165 L12_17 0.1083
K21834 L160_165 L77_82 0.0409
K21835 L52_56 L181_185 0.0396
K21836 L52_56 L140_145 0.0219
K21837 L52_56 L1_6 0.069
K21838 L52_56 L35_40 0.0378
K21839 L52_56 L73_78 0.0489
K21840 L52_56 L163_168 0.0459
K21841 L52_56 L91_95 0.028
K21842 L52_56 L130_160 0.0544
K21843 L52_56 L4_9 0.0398
K21844 L52_56 L202_206 0.0464
K21845 L52_56 L109_114 0.1104
K21846 L52_56 L57_61 0.1134
K21847 L52_56 L164_169 0.0407
K21848 L52_56 L204_208 0.0443
K21849 L52_56 L53_57 0.1145
K21850 L52_56 L69_73 0.0515
K21851 L52_56 L200_204 0.0464
K21852 L52_56 L145_150 0.0212
K21853 L52_56 L30_35 0.0409
K21854 L52_56 L131_136 0.0408
K21855 L52_56 L46_50 0.0812
K21856 L52_56 L196_200 0.0487
K21857 L52_56 L92_96 0.0271
K21858 L52_56 L19_24 0.0395
K21859 L52_56 L120_125 0.0681
K21860 L52_56 L7_12 0.0461
K21861 L52_56 L137_142 0.0287
K21862 L52_56 L167_172 0.0442
K21863 L52_56 L121_126 0.0782
K21864 L52_56 L110_115 0.0681
K21865 L52_56 L134_139 0.0279
K21866 L52_56 L141_146 0.0375
K21867 L52_56 L9_14 0.0398
K21868 L52_56 L33_38 0.0444
K21869 L52_56 L124_129 0.1076
K21870 L52_56 L78_83 0.0466
K21871 L52_56 L112_117 0.1114
K21872 L52_56 L40_45 0.0345
K21873 L52_56 L183_187 0.0455
K21874 L52_56 L59_63 0.1103
K21875 L52_56 L5_10 0.0313
K21876 L52_56 L15_20 0.0313
K21877 L52_56 L58_62 0.0796
K21878 L52_56 L29_34 0.0462
K21879 L52_56 L179_183 0.0457
K21880 L52_56 L158_189 0.0392
K21881 L52_56 L41_74 0.041
K21882 L52_56 L131_170 0.0393
K21883 L52_56 L191_195 0.041
K21884 L52_56 L66_70 0.0412
K21885 L52_56 L98_102 0.0268
K21886 L52_56 L27_32 0.0518
K21887 L52_56 L142_147 0.0277
K21888 L52_56 L178_182 0.0312
K21889 L52_56 L3_8 0.0426
K21890 L52_56 L149_154 0.0253
K21891 L52_56 L117_122 0.1104
K21892 L52_56 L38_43 0.0399
K21893 L52_56 L135_174 0.0344
K21894 L52_56 L115_120 0.0684
K21895 L52_56 L80_85 0.0358
K21896 L52_56 L10_15 0.0314
K21897 L52_56 L16_21 0.0681
K21898 L52_56 L158_163 0.049
K21899 L52_56 L96_100 0.0262
K21900 L52_56 L49_53 0.1134
K21901 L52_56 L186_190 0.0312
K21902 L52_56 L125_130 0.0673
K21903 L52_56 L159_164 0.0432
K21904 L52_56 L25_30 0.0434
K21905 L52_56 L14_19 0.0398
K21906 L52_56 L44_92 0.028
K21907 L52_56 L21_26 0.0549
K21908 L52_56 L84_89 0.0362
K21909 L52_56 L74_79 0.0393
K21910 L52_56 L165_170 0.0443
K21911 L52_56 L199_203 0.0373
K21912 L52_56 L75_80 0.0375
K21913 L52_56 L70_75 0.0393
K21914 L52_56 L50_54 0.0818
K21915 L52_56 L79_84 0.0377
K21916 L52_56 L93_97 0.0219
K21917 L52_56 L90_94 0.0288
K21918 L52_56 L134_173 0.0383
K21919 L52_56 L139_144 0.027
K21920 L52_56 L177_181 0.0395
K21921 L52_56 L111_116 0.0802
K21922 L52_56 L162_167 0.0486
K21923 L52_56 L43_91 0.029
K21924 L52_56 L122_127 0.1076
K21925 L52_56 L135_140 0.0226
K21926 L52_56 L39_44 0.0384
K21927 L52_56 L12_17 0.0459
K21928 L52_56 L54_58 0.0812
K21929 L52_56 L146_151 0.0361
K21930 L52_56 L61_65 0.1103
K21931 L141_202 L167_168 0.0574
K21932 L141_202 L74_90 0.095
K21933 L141_202 L115_179 0.0299
K21934 L141_202 L196_197 0.0993
K21935 L141_202 L1_2 0.0244
K21936 L141_202 L23_24 0.0395
K21937 L141_202 L158_159 0.0387
K21938 L141_202 L163_164 0.0466
K21939 L141_202 L91_92 0.0723
K21940 L141_202 L160_161 0.0507
K21941 L141_202 L126_127 0.0387
K21942 L141_202 L204_205 0.0993
K21943 L141_202 L153_154 0.0912
K21944 L141_202 L4_5 0.0231
K21945 L141_202 L41_42 0.0946
K21946 L141_202 L191_192 0.0613
K21947 L141_202 L36_37 0.0776
K21948 L141_202 L131_132 0.0975
K21949 L141_202 L100_101 0.095
K21950 L141_202 L92_93 0.0643
K21951 L141_202 L148_149 0.1196
K21952 L141_202 L19_20 0.031
K21953 L141_202 L187_188 0.0326
K21954 L141_202 L165_166 0.0621
K21955 L141_202 L102_103 0.0998
K21956 L141_202 L106_107 0.0337
K21957 L141_202 L64_65 0.0477
K21958 L141_202 L8_9 0.0288
K21959 L141_202 L193_194 0.1727
K21960 L141_202 L21_65 0.0493
K21961 L141_202 L121_122 0.0395
K21962 L141_202 L9_10 0.0282
K21963 L141_202 L134_135 0.0718
K21964 L141_202 L171_172 0.0743
K21965 L141_202 L104_105 0.0748
K21966 L141_202 L151_210 0.2387
K21967 L141_202 L98_99 0.133
K21968 L141_202 L112_113 0.04
K21969 L141_202 L183_184 0.0309
K21970 L141_202 L59_60 0.0439
K21971 L141_202 L38_39 0.069
K21972 L141_202 L44_45 0.0707
K21973 L141_202 L47_48 0.0367
K21974 L141_202 L29_30 0.0463
K21975 L141_202 L16_17 0.0331
K21976 L141_202 L6_53 0.0435
K21977 L141_202 L149_150 0.0996
K21978 L141_202 L113_114 0.0427
K21979 L141_202 L80_81 0.0653
K21980 L141_202 L87_88 0.1479
K21981 L141_202 L146_147 0.1855
K21982 L141_202 L136_137 0.0996
K21983 L141_202 L127_128 0.0438
K21984 L141_202 L181_182 0.0283
K21985 L141_202 L28_29 0.0478
K21986 L141_202 L157_158 0.0397
K21987 L141_202 L161_162 0.0494
K21988 L141_202 L129_130 0.0496
K21989 L141_202 L21_22 0.0414
K21990 L141_202 L117_118 0.0419
K21991 L141_202 L56_57 0.0448
K21992 L141_202 L116_117 0.0379
K21993 L141_202 L154_155 0.0779
K21994 L141_202 L7_8 0.0293
K21995 L141_202 L82_83 0.1743
K21996 L141_202 L14_15 0.0295
K21997 L141_202 L125_187 0.0333
K21998 L141_202 L58_59 0.0393
K21999 L141_202 L70_71 0.0653
K22000 L141_202 L68_69 0.1576
K22001 L141_202 L89_102 0.1147
K22002 L141_202 L50_51 0.0364
K22003 L141_202 L90_91 0.0822
K22004 L141_202 L139_140 0.0656
K22005 L141_202 L111_112 0.0365
K22006 L141_202 L162_163 0.048
K22007 L141_202 L137_138 0.0851
K22008 L141_202 L179_180 0.0294
K22009 L141_202 L12_13 0.0308
K22010 L141_202 L123_124 0.0477
K22011 L141_202 L39_40 0.0649
K22012 L141_202 L18_19 0.0317
K22013 L141_202 L156_157 0.0407
K22014 L141_202 L54_55 0.0378
K22015 L102_103 L167_168 0.0351
K22016 L102_103 L74_90 0.0861
K22017 L102_103 L115_179 0.0168
K22018 L102_103 L196_197 0.0385
K22019 L102_103 L1_2 0.0138
K22020 L102_103 L23_24 0.0235
K22021 L102_103 L158_159 0.0232
K22022 L102_103 L163_164 0.0283
K22023 L102_103 L91_92 0.0861
K22024 L102_103 L160_161 0.0285
K22025 L102_103 L126_127 0.0192
K22026 L102_103 L204_205 0.0401
K22027 L102_103 L4_5 0.0137
K22028 L102_103 L41_42 0.0644
K22029 L102_103 L200_201 0.0394
K22030 L102_103 L36_37 0.0463
K22031 L102_103 L131_132 0.0622
K22032 L102_103 L100_101 0.1268
K22033 L102_103 L92_93 0.0787
K22034 L102_103 L148_149 0.1266
K22035 L102_103 L19_20 0.0187
K22036 L102_103 L187_188 0.0187
K22037 L102_103 L165_166 0.0351
K22038 L102_103 L106_107 0.0172
K22039 L102_103 L8_9 0.0169
K22040 L102_103 L193_194 0.0508
K22041 L102_103 L21_65 0.0258
K22042 L102_103 L121_122 0.0198
K22043 L102_103 L9_10 0.0168
K22044 L102_103 L134_135 0.06
K22045 L102_103 L171_172 0.0459
K22046 L102_103 L112_113 0.0204
K22047 L102_103 L183_184 0.0177
K22048 L102_103 L59_60 0.0221
K22049 L102_103 L38_39 0.0463
K22050 L102_103 L78_79 0.108
K22051 L102_103 L44_45 0.0621
K22052 L102_103 L47_48 0.0189
K22053 L102_103 L29_30 0.0285
K22054 L102_103 L76_77 0.0399
K22055 L102_103 L16_17 0.0188
K22056 L102_103 L181_182 0.0167
K22057 L102_103 L6_53 0.0233
K22058 L102_103 L149_150 0.1062
K22059 L102_103 L98_99 0.1916
K22060 L102_103 L113_114 0.022
K22061 L102_103 L80_81 0.0301
K22062 L102_103 L146_147 0.1266
K22063 L102_103 L136_137 0.0789
K22064 L102_103 L127_128 0.0216
K22065 L102_103 L28_29 0.0286
K22066 L102_103 L157_158 0.0233
K22067 L102_103 L96_97 0.0985
K22068 L102_103 L129_130 0.0256
K22069 L102_103 L64_65 0.024
K22070 L102_103 L117_118 0.0212
K22071 L102_103 L56_57 0.0231
K22072 L102_103 L116_117 0.0192
K22073 L102_103 L21_22 0.0235
K22074 L102_103 L7_8 0.0169
K22075 L102_103 L82_83 0.062
K22076 L102_103 L14_15 0.0177
K22077 L102_103 L199_200 0.0297
K22078 L102_103 L125_187 0.0187
K22079 L102_103 L58_59 0.0198
K22080 L102_103 L70_71 0.0294
K22081 L102_103 L68_69 0.0519
K22082 L102_103 L50_51 0.0186
K22083 L102_103 L90_91 0.0891
K22084 L102_103 L139_140 0.073
K22085 L102_103 L161_162 0.0285
K22086 L102_103 L111_112 0.0186
K22087 L102_103 L162_163 0.0285
K22088 L102_103 L137_138 0.0811
K22089 L102_103 L179_180 0.0168
K22090 L102_103 L12_13 0.0178
K22091 L102_103 L142_143 0.1033
K22092 L102_103 L123_124 0.0241
K22093 L102_103 L191_192 0.0272
K22094 L102_103 L39_40 0.0456
K22095 L102_103 L18_19 0.0188
K22096 L102_103 L156_157 0.0234
K22097 L102_103 L54_55 0.0192
K22098 L102_103 L201_202 0.0581
K22099 L140_145 L181_185 0.0207
K22100 L140_145 L1_6 0.0234
K22101 L140_145 L73_78 0.0418
K22102 L140_145 L163_168 0.0471
K22103 L140_145 L91_95 0.1033
K22104 L140_145 L130_160 0.0314
K22105 L140_145 L4_9 0.0194
K22106 L140_145 L109_114 0.0238
K22107 L140_145 L57_61 0.0257
K22108 L140_145 L53_57 0.0247
K22109 L140_145 L69_73 0.0417
K22110 L140_145 L200_204 0.025
K22111 L140_145 L131_136 0.0615
K22112 L140_145 L46_50 0.0151
K22113 L140_145 L196_200 0.025
K22114 L140_145 L92_96 0.1363
K22115 L140_145 L19_24 0.0235
K22116 L140_145 L120_125 0.026
K22117 L140_145 L60_64 0.0233
K22118 L140_145 L193_197 0.0313
K22119 L140_145 L7_12 0.0202
K22120 L140_145 L137_142 0.0891
K22121 L140_145 L167_172 0.0657
K22122 L140_145 L121_126 0.0162
K22123 L140_145 L110_115 0.0234
K22124 L140_145 L113_118 0.0219
K22125 L140_145 L134_139 0.1673
K22126 L140_145 L141_146 0.0615
K22127 L140_145 L9_14 0.0206
K22128 L140_145 L33_38 0.0635
K22129 L140_145 L124_129 0.0269
K22130 L140_145 L78_83 0.0417
K22131 L140_145 L112_117 0.0194
K22132 L140_145 L183_187 0.0216
K22133 L140_145 L59_63 0.0203
K22134 L140_145 L58_62 0.0161
K22135 L140_145 L29_34 0.0463
K22136 L140_145 L179_183 0.0203
K22137 L140_145 L41_74 0.0598
K22138 L140_145 L131_170 0.0791
K22139 L140_145 L191_195 0.0195
K22140 L140_145 L66_70 0.0194
K22141 L140_145 L98_102 0.073
K22142 L140_145 L27_32 0.0435
K22143 L140_145 L142_147 0.0861
K22144 L140_145 L3_8 0.0193
K22145 L140_145 L149_154 0.1268
K22146 L140_145 L117_122 0.0199
K22147 L140_145 L158_189 0.0237
K22148 L140_145 L38_43 0.0979
K22149 L140_145 L108_113 0.0213
K22150 L140_145 L115_120 0.0247
K22151 L140_145 L80_85 0.0194
K22152 L140_145 L16_21 0.0274
K22153 L140_145 L158_163 0.0355
K22154 L140_145 L96_100 0.1266
K22155 L140_145 L49_53 0.0237
K22156 L140_145 L82_87 0.031
K22157 L140_145 L125_130 0.0275
K22158 L140_145 L84_89 0.0581
K22159 L140_145 L204_208 0.0249
K22160 L140_145 L202_206 0.0421
K22161 L140_145 L14_19 0.022
K22162 L140_145 L44_92 0.1266
K22163 L140_145 L21_26 0.0311
K22164 L140_145 L74_79 0.0604
K22165 L140_145 L165_170 0.0552
K22166 L140_145 L199_203 0.0195
K22167 L140_145 L75_80 0.0194
K22168 L140_145 L70_75 0.0195
K22169 L140_145 L50_54 0.0154
K22170 L140_145 L79_84 0.0598
K22171 L140_145 L56_60 0.0226
K22172 L140_145 L90_94 0.0811
K22173 L140_145 L134_173 0.1284
K22174 L140_145 L139_144 0.1916
K22175 L140_145 L177_181 0.0195
K22176 L140_145 L111_116 0.0155
K22177 L140_145 L162_167 0.0458
K22178 L140_145 L43_91 0.0988
K22179 L140_145 L122_127 0.0204
K22180 L140_145 L39_44 0.1131
K22181 L140_145 L123_128 0.0234
K22182 L140_145 L12_17 0.0215
K22183 L140_145 L54_58 0.0158
K22184 L140_145 L146_151 0.0597
K22185 L140_145 L61_65 0.0268
K22186 L140_145 L77_82 0.0312
K22187 L106_107 L167_168 0.0366
K22188 L106_107 L74_90 0.0233
K22189 L106_107 L199_200 0.0402
K22190 L106_107 L115_179 0.0363
K22191 L106_107 L196_197 0.0414
K22192 L106_107 L23_24 0.0371
K22193 L106_107 L158_159 0.0353
K22194 L106_107 L163_164 0.0376
K22195 L106_107 L91_92 0.022
K22196 L106_107 L126_127 0.1605
K22197 L106_107 L204_205 0.0373
K22198 L106_107 L153_154 0.0168
K22199 L106_107 L41_42 0.0297
K22200 L106_107 L200_201 0.0393
K22201 L106_107 L36_37 0.0361
K22202 L106_107 L131_132 0.0298
K22203 L106_107 L100_101 0.0202
K22204 L106_107 L92_93 0.0214
K22205 L106_107 L148_149 0.0207
K22206 L106_107 L19_20 0.0295
K22207 L106_107 L187_188 0.0334
K22208 L106_107 L160_161 0.044
K22209 L106_107 L64_65 0.077
K22210 L106_107 L165_166 0.0401
K22211 L106_107 L193_194 0.0373
K22212 L106_107 L21_65 0.0545
K22213 L106_107 L121_122 0.2072
K22214 L106_107 L9_10 0.0299
K22215 L106_107 L134_135 0.0271
K22216 L106_107 L171_172 0.0349
K22217 L106_107 L104_105 0.0164
K22218 L106_107 L151_210 0.0294
K22219 L106_107 L112_113 0.2045
K22220 L106_107 L183_184 0.0337
K22221 L106_107 L59_60 0.1387
K22222 L106_107 L38_39 0.0335
K22223 L106_107 L96_97 0.0208
K22224 L106_107 L78_79 0.0336
K22225 L106_107 L44_45 0.0271
K22226 L106_107 L29_30 0.0374
K22227 L106_107 L76_77 0.0391
K22228 L106_107 L16_17 0.0353
K22229 L106_107 L6_53 0.0615
K22230 L106_107 L149_150 0.0202
K22231 L106_107 L98_99 0.0212
K22232 L106_107 L113_114 0.0947
K22233 L106_107 L80_81 0.038
K22234 L106_107 L87_88 0.0317
K22235 L106_107 L146_147 0.0218
K22236 L106_107 L136_137 0.0233
K22237 L106_107 L127_128 0.123
K22238 L106_107 L181_182 0.0301
K22239 L106_107 L28_29 0.0393
K22240 L106_107 L157_158 0.0373
K22241 L106_107 L129_130 0.055
K22242 L106_107 L21_22 0.0417
K22243 L106_107 L117_118 0.1727
K22244 L106_107 L56_57 0.0896
K22245 L106_107 L116_117 0.2809
K22246 L106_107 L154_155 0.0164
K22247 L106_107 L7_8 0.0338
K22248 L106_107 L82_83 0.0351
K22249 L106_107 L14_15 0.0298
K22250 L106_107 L125_187 0.0356
K22251 L106_107 L58_59 0.1866
K22252 L106_107 L70_71 0.0423
K22253 L106_107 L68_69 0.0372
K22254 L106_107 L89_102 0.0176
K22255 L106_107 L8_9 0.0318
K22256 L106_107 L50_51 0.2931
K22257 L106_107 L90_91 0.0226
K22258 L106_107 L139_140 0.0214
K22259 L106_107 L161_162 0.0416
K22260 L106_107 L111_112 0.4331
K22261 L106_107 L162_163 0.0395
K22262 L106_107 L137_138 0.0227
K22263 L106_107 L179_180 0.034
K22264 L106_107 L12_13 0.0335
K22265 L106_107 L142_143 0.022
K22266 L106_107 L123_124 0.0877
K22267 L106_107 L191_192 0.0414
K22268 L106_107 L39_40 0.0323
K22269 L106_107 L18_19 0.0312
K22270 L106_107 L156_157 0.0395
K22271 L106_107 L54_55 0.2334
K22272 L106_107 L201_202 0.0369
K22273 L108_113 L181_185 0.0398
K22274 L108_113 L1_6 0.0684
K22275 L108_113 L35_40 0.0365
K22276 L108_113 L73_78 0.0464
K22277 L108_113 L163_168 0.0449
K22278 L108_113 L91_95 0.0269
K22279 L108_113 L130_160 0.0534
K22280 L108_113 L4_9 0.0396
K22281 L108_113 L202_206 0.0444
K22282 L108_113 L109_114 0.1145
K22283 L108_113 L57_61 0.1076
K22284 L108_113 L164_169 0.0399
K22285 L108_113 L204_208 0.0425
K22286 L108_113 L53_57 0.1104
K22287 L108_113 L69_73 0.0487
K22288 L108_113 L200_204 0.0444
K22289 L108_113 L145_150 0.0206
K22290 L108_113 L30_35 0.0397
K22291 L108_113 L131_136 0.0393
K22292 L108_113 L46_50 0.0802
K22293 L108_113 L196_200 0.0466
K22294 L108_113 L92_96 0.0261
K22295 L108_113 L19_24 0.0388
K22296 L108_113 L120_125 0.0681
K22297 L108_113 L7_12 0.0455
K22298 L108_113 L137_142 0.0278
K22299 L108_113 L167_172 0.0429
K22300 L108_113 L121_126 0.0772
K22301 L108_113 L110_115 0.0692
K22302 L108_113 L134_139 0.0271
K22303 L108_113 L141_146 0.0362
K22304 L108_113 L9_14 0.0395
K22305 L108_113 L33_38 0.0427
K22306 L108_113 L124_129 0.1057
K22307 L108_113 L78_83 0.0443
K22308 L108_113 L112_117 0.1134
K22309 L108_113 L40_45 0.0333
K22310 L108_113 L183_187 0.0455
K22311 L108_113 L59_63 0.1034
K22312 L108_113 L5_10 0.0312
K22313 L108_113 L15_20 0.031
K22314 L108_113 L58_62 0.0759
K22315 L108_113 L29_34 0.0447
K22316 L108_113 L179_183 0.0459
K22317 L108_113 L158_189 0.0391
K22318 L108_113 L41_74 0.0391
K22319 L108_113 L131_170 0.0379
K22320 L108_113 L191_195 0.0393
K22321 L108_113 L66_70 0.0391
K22322 L108_113 L98_102 0.0257
K22323 L108_113 L27_32 0.0498
K22324 L108_113 L142_147 0.0268
K22325 L108_113 L178_182 0.0314
K22326 L108_113 L3_8 0.0424
K22327 L108_113 L149_154 0.0246
K22328 L108_113 L117_122 0.1103
K22329 L108_113 L38_43 0.0384
K22330 L108_113 L135_174 0.0334
K22331 L108_113 L115_120 0.069
K22332 L108_113 L80_85 0.0342
K22333 L108_113 L10_15 0.0312
K22334 L108_113 L16_21 0.066
K22335 L108_113 L158_163 0.0484
K22336 L108_113 L96_100 0.0253
K22337 L108_113 L49_53 0.1114
K22338 L108_113 L186_190 0.0312
K22339 L108_113 L125_130 0.0668
K22340 L108_113 L159_164 0.0427
K22341 L108_113 L25_30 0.0425
K22342 L108_113 L14_19 0.0392
K22343 L108_113 L44_92 0.027
K22344 L108_113 L21_26 0.053
K22345 L108_113 L84_89 0.0347
K22346 L108_113 L74_79 0.0375
K22347 L108_113 L165_170 0.0428
K22348 L108_113 L199_203 0.0358
K22349 L108_113 L75_80 0.0357
K22350 L108_113 L70_75 0.0373
K22351 L108_113 L50_54 0.0797
K22352 L108_113 L79_84 0.0361
K22353 L108_113 L93_97 0.0212
K22354 L108_113 L90_94 0.0277
K22355 L108_113 L134_173 0.0372
K22356 L108_113 L139_144 0.0262
K22357 L108_113 L177_181 0.0398
K22358 L108_113 L111_116 0.0812
K22359 L108_113 L162_167 0.0474
K22360 L108_113 L43_91 0.0279
K22361 L108_113 L122_127 0.1057
K22362 L108_113 L135_140 0.0219
K22363 L108_113 L39_44 0.0371
K22364 L108_113 L12_17 0.0451
K22365 L108_113 L54_58 0.0782
K22366 L108_113 L146_151 0.0348
K22367 L108_113 L61_65 0.1034
K22368 L56_57 L167_168 0.0612
K22369 L56_57 L74_90 0.0326
K22370 L56_57 L199_200 0.0418
K22371 L56_57 L115_179 0.0579
K22372 L56_57 L196_197 0.0474
K22373 L56_57 L1_2 0.0485
K22374 L56_57 L23_24 0.0753
K22375 L56_57 L158_159 0.0673
K22376 L56_57 L163_164 0.0674
K22377 L56_57 L91_92 0.0311
K22378 L56_57 L160_161 0.0852
K22379 L56_57 L126_127 0.0878
K22380 L56_57 L204_205 0.0425
K22381 L56_57 L153_154 0.0226
K22382 L56_57 L4_5 0.0371
K22383 L56_57 L41_42 0.0431
K22384 L56_57 L200_201 0.0448
K22385 L56_57 L36_37 0.0559
K22386 L56_57 L131_132 0.0428
K22387 L56_57 L100_101 0.0277
K22388 L56_57 L92_93 0.0303
K22389 L56_57 L148_149 0.0282
K22390 L56_57 L19_20 0.0589
K22391 L56_57 L187_188 0.0723
K22392 L56_57 L165_166 0.0681
K22393 L56_57 L64_65 0.2387
K22394 L56_57 L193_194 0.0477
K22395 L56_57 L21_65 0.1593
K22396 L56_57 L121_122 0.0969
K22397 L56_57 L9_10 0.0449
K22398 L56_57 L134_135 0.0393
K22399 L56_57 L171_172 0.0536
K22400 L56_57 L104_105 0.0222
K22401 L56_57 L151_210 0.0381
K22402 L56_57 L112_113 0.1743
K22403 L56_57 L59_60 0.1933
K22404 L56_57 L129_130 0.1479
K22405 L56_57 L38_39 0.0519
K22406 L56_57 L96_97 0.0289
K22407 L56_57 L78_79 0.045
K22408 L56_57 L44_45 0.0395
K22409 L56_57 L47_48 0.1727
K22410 L56_57 L29_30 0.0682
K22411 L56_57 L76_77 0.045
K22412 L56_57 L16_17 0.0851
K22413 L56_57 L149_150 0.0276
K22414 L56_57 L98_99 0.0289
K22415 L56_57 L6_53 0.1933
K22416 L56_57 L113_114 0.2659
K22417 L56_57 L80_81 0.04
K22418 L56_57 L87_88 0.0391
K22419 L56_57 L146_147 0.0293
K22420 L56_57 L136_137 0.0325
K22421 L56_57 L127_128 0.1479
K22422 L56_57 L181_182 0.0445
K22423 L56_57 L28_29 0.0737
K22424 L56_57 L157_158 0.074
K22425 L56_57 L21_22 0.0942
K22426 L56_57 L154_155 0.0221
K22427 L56_57 L7_8 0.0533
K22428 L56_57 L82_83 0.0437
K22429 L56_57 L58_59 0.0993
K22430 L56_57 L125_187 0.0822
K22431 L56_57 L70_71 0.0441
K22432 L56_57 L68_69 0.048
K22433 L56_57 L89_102 0.0235
K22434 L56_57 L8_9 0.0488
K22435 L56_57 L50_51 0.0993
K22436 L56_57 L90_91 0.0319
K22437 L56_57 L139_140 0.0302
K22438 L56_57 L161_162 0.0786
K22439 L56_57 L111_112 0.0969
K22440 L56_57 L162_163 0.0727
K22441 L56_57 L137_138 0.0317
K22442 L56_57 L179_180 0.0527
K22443 L56_57 L142_143 0.0302
K22444 L56_57 L123_124 0.2659
K22445 L56_57 L191_192 0.0425
K22446 L56_57 L39_40 0.0499
K22447 L56_57 L156_157 0.082
K22448 L56_57 L18_19 0.0656
K22449 L56_57 L201_202 0.046
K22450 L60_64 L181_185 0.0392
K22451 L60_64 L1_6 0.0668
K22452 L60_64 L35_40 0.0399
K22453 L60_64 L73_78 0.0543
K22454 L60_64 L163_168 0.0481
K22455 L60_64 L91_95 0.03
K22456 L60_64 L130_160 0.0565
K22457 L60_64 L4_9 0.0391
K22458 L60_64 L202_206 0.0513
K22459 L60_64 L109_114 0.1034
K22460 L60_64 L57_61 0.1134
K22461 L60_64 L164_169 0.0425
K22462 L60_64 L204_208 0.0487
K22463 L60_64 L53_57 0.1103
K22464 L60_64 L69_73 0.0574
K22465 L60_64 L200_204 0.0513
K22466 L60_64 L145_150 0.0226
K22467 L60_64 L30_35 0.0427
K22468 L60_64 L131_136 0.0445
K22469 L60_64 L46_50 0.0772
K22470 L60_64 L196_200 0.054
K22471 L60_64 L92_96 0.029
K22472 L60_64 L19_24 0.0398
K22473 L60_64 L120_125 0.0681
K22474 L60_64 L7_12 0.0455
K22475 L60_64 L137_142 0.031
K22476 L60_64 L167_172 0.0471
K22477 L60_64 L121_126 0.0802
K22478 L60_64 L110_115 0.066
K22479 L60_64 L134_139 0.0299
K22480 L60_64 L141_146 0.0408
K22481 L60_64 L9_14 0.0395
K22482 L60_64 L33_38 0.0474
K22483 L60_64 L124_129 0.1114
K22484 L60_64 L78_83 0.0515
K22485 L60_64 L112_117 0.1076
K22486 L60_64 L40_45 0.0367
K22487 L60_64 L183_187 0.0455
K22488 L60_64 L59_63 0.1145
K22489 L60_64 L5_10 0.0308
K22490 L60_64 L15_20 0.0313
K22491 L60_64 L58_62 0.0818
K22492 L60_64 L29_34 0.0484
K22493 L60_64 L179_183 0.0451
K22494 L60_64 L158_189 0.0396
K22495 L60_64 L41_74 0.0447
K22496 L60_64 L131_170 0.0426
K22497 L60_64 L191_195 0.0454
K22498 L60_64 L66_70 0.0456
K22499 L60_64 L98_102 0.0288
K22500 L60_64 L27_32 0.055
K22501 L60_64 L142_147 0.0298
K22502 L60_64 L178_182 0.0307
K22503 L60_64 L3_8 0.0418
K22504 L60_64 L149_154 0.027
K22505 L60_64 L117_122 0.1104
K22506 L60_64 L38_43 0.0429
K22507 L60_64 L135_174 0.0365
K22508 L60_64 L115_120 0.0673
K22509 L60_64 L80_85 0.0393
K22510 L60_64 L10_15 0.0312
K22511 L60_64 L16_21 0.0692
K22512 L60_64 L158_163 0.0503
K22513 L60_64 L96_100 0.028
K22514 L60_64 L49_53 0.1057
K22515 L60_64 L186_190 0.0312
K22516 L60_64 L125_130 0.0684
K22517 L60_64 L159_164 0.0442
K22518 L60_64 L25_30 0.0445
K22519 L60_64 L14_19 0.0398
K22520 L60_64 L44_92 0.03
K22521 L60_64 L21_26 0.057
K22522 L60_64 L84_89 0.0393
K22523 L60_64 L74_79 0.0428
K22524 L60_64 L165_170 0.0479
K22525 L60_64 L199_203 0.041
K22526 L60_64 L75_80 0.0412
K22527 L60_64 L70_75 0.0433
K22528 L60_64 L50_54 0.0796
K22529 L60_64 L79_84 0.041
K22530 L60_64 L93_97 0.0234
K22531 L60_64 L90_94 0.0311
K22532 L60_64 L134_173 0.0409
K22533 L60_64 L139_144 0.0289
K22534 L60_64 L177_181 0.0388
K22535 L60_64 L111_116 0.0782
K22536 L60_64 L162_167 0.0511
K22537 L60_64 L43_91 0.0311
K22538 L60_64 L122_127 0.1114
K22539 L60_64 L135_140 0.0241
K22540 L60_64 L39_44 0.041
K22541 L60_64 L12_17 0.0459
K22542 L60_64 L54_58 0.0812
K22543 L60_64 L146_151 0.0391
K22544 L60_64 L61_65 0.1145
K22545 L25_30 L181_185 0.1041
K22546 L25_30 L1_6 0.0719
K22547 L25_30 L73_78 0.0385
K22548 L25_30 L163_168 0.1634
K22549 L25_30 L91_95 0.0335
K22550 L25_30 L130_160 0.1257
K22551 L25_30 L4_9 0.0922
K22552 L25_30 L109_114 0.0549
K22553 L25_30 L57_61 0.0584
K22554 L25_30 L53_57 0.057
K22555 L25_30 L69_73 0.0402
K22556 L25_30 L200_204 0.0283
K22557 L25_30 L131_136 0.0416
K22558 L25_30 L46_50 0.0271
K22559 L25_30 L196_200 0.029
K22560 L25_30 L92_96 0.0339
K22561 L25_30 L19_24 0.1862
K22562 L25_30 L120_125 0.0792
K22563 L25_30 L193_197 0.0344
K22564 L25_30 L7_12 0.0877
K22565 L25_30 L137_142 0.0328
K22566 L25_30 L167_172 0.0917
K22567 L25_30 L121_126 0.0277
K22568 L25_30 L110_115 0.0705
K22569 L25_30 L113_118 0.0432
K22570 L25_30 L134_139 0.0362
K22571 L25_30 L141_146 0.0371
K22572 L25_30 L9_14 0.1128
K22573 L25_30 L33_38 0.095
K22574 L25_30 L124_129 0.0588
K22575 L25_30 L78_83 0.037
K22576 L25_30 L112_117 0.0349
K22577 L25_30 L183_187 0.0938
K22578 L25_30 L59_63 0.0355
K22579 L25_30 L58_62 0.0278
K22580 L25_30 L29_34 0.189
K22581 L25_30 L179_183 0.0836
K22582 L25_30 L41_74 0.0418
K22583 L25_30 L131_170 0.0571
K22584 L25_30 L191_195 0.0236
K22585 L25_30 L66_70 0.0236
K22586 L25_30 L98_102 0.0291
K22587 L25_30 L27_32 0.1278
K22588 L25_30 L142_147 0.0307
K22589 L25_30 L3_8 0.0849
K22590 L25_30 L149_154 0.0295
K22591 L25_30 L117_122 0.0352
K22592 L25_30 L158_189 0.1522
K22593 L25_30 L38_43 0.0659
K22594 L25_30 L115_120 0.075
K22595 L25_30 L80_85 0.0221
K22596 L25_30 L16_21 0.0849
K22597 L25_30 L158_163 0.2296
K22598 L25_30 L96_100 0.0317
K22599 L25_30 L49_53 0.0554
K22600 L25_30 L82_87 0.0314
K22601 L25_30 L125_130 0.0826
K22602 L25_30 L84_89 0.0353
K22603 L25_30 L204_208 0.0276
K22604 L25_30 L202_206 0.0368
K22605 L25_30 L14_19 0.1431
K22606 L25_30 L44_92 0.0365
K22607 L25_30 L21_26 0.1357
K22608 L25_30 L74_79 0.0394
K22609 L25_30 L165_170 0.0772
K22610 L25_30 L199_203 0.0226
K22611 L25_30 L75_80 0.0226
K22612 L25_30 L70_75 0.0231
K22613 L25_30 L50_54 0.0274
K22614 L25_30 L79_84 0.0373
K22615 L25_30 L56_60 0.044
K22616 L25_30 L90_94 0.033
K22617 L25_30 L134_173 0.0666
K22618 L25_30 L139_144 0.0337
K22619 L25_30 L177_181 0.0874
K22620 L25_30 L111_116 0.0273
K22621 L25_30 L162_167 0.1403
K22622 L25_30 L43_91 0.036
K22623 L25_30 L122_127 0.0354
K22624 L25_30 L39_44 0.0678
K22625 L25_30 L123_128 0.0442
K22626 L25_30 L12_17 0.0997
K22627 L25_30 L54_58 0.0276
K22628 L25_30 L146_151 0.0352
K22629 L25_30 L61_65 0.0594
K22630 L25_30 L77_82 0.0324
K22631 L14_19 L1_6 0.0802
K22632 L14_19 L35_40 0.0525
K22633 L14_19 L73_78 0.032
K22634 L14_19 L91_95 0.0266
K22635 L14_19 L130_160 0.1234
K22636 L14_19 L202_206 0.0305
K22637 L14_19 L109_114 0.0531
K22638 L14_19 L57_61 0.0546
K22639 L14_19 L164_169 0.0748
K22640 L14_19 L53_57 0.0544
K22641 L14_19 L69_73 0.0334
K22642 L14_19 L200_204 0.0239
K22643 L14_19 L145_150 0.0206
K22644 L14_19 L30_35 0.0777
K22645 L14_19 L131_136 0.0337
K22646 L14_19 L46_50 0.0243
K22647 L14_19 L196_200 0.0245
K22648 L14_19 L120_125 0.0813
K22649 L14_19 L193_197 0.0289
K22650 L14_19 L7_12 0.1284
K22651 L14_19 L137_142 0.0262
K22652 L14_19 L167_172 0.0699
K22653 L14_19 L121_126 0.0243
K22654 L14_19 L110_115 0.0775
K22655 L14_19 L141_146 0.0301
K22656 L14_19 L122_127 0.0312
K22657 L14_19 L33_38 0.0718
K22658 L14_19 L124_129 0.0537
K22659 L14_19 L78_83 0.0306
K22660 L14_19 L112_117 0.0312
K22661 L14_19 L40_45 0.0395
K22662 L14_19 L183_187 0.1173
K22663 L14_19 L59_63 0.0313
K22664 L14_19 L5_10 0.1268
K22665 L14_19 L15_20 0.1916
K22666 L14_19 L58_62 0.0244
K22667 L14_19 L179_183 0.1127
K22668 L14_19 L41_74 0.0339
K22669 L14_19 L131_170 0.045
K22670 L14_19 L191_195 0.02
K22671 L14_19 L98_102 0.0233
K22672 L14_19 L27_32 0.1049
K22673 L14_19 L178_182 0.1062
K22674 L14_19 L3_8 0.1439
K22675 L14_19 L66_70 0.02
K22676 L14_19 L117_122 0.0313
K22677 L14_19 L38_43 0.051
K22678 L14_19 L135_174 0.0391
K22679 L14_19 L115_120 0.0803
K22680 L14_19 L80_85 0.0186
K22681 L14_19 L10_15 0.1673
K22682 L14_19 L16_21 0.0833
K22683 L14_19 L113_118 0.0395
K22684 L14_19 L49_53 0.0537
K22685 L14_19 L186_190 0.1363
K22686 L14_19 L125_130 0.0803
K22687 L14_19 L159_164 0.126
K22688 L14_19 L84_89 0.0287
K22689 L14_19 L204_208 0.0233
K22690 L14_19 L82_87 0.0262
K22691 L14_19 L21_26 0.1376
K22692 L14_19 L74_79 0.032
K22693 L14_19 L165_170 0.0609
K22694 L14_19 L199_203 0.019
K22695 L14_19 L75_80 0.0191
K22696 L14_19 L70_75 0.0196
K22697 L14_19 L50_54 0.0244
K22698 L14_19 L79_84 0.0303
K22699 L14_19 L56_60 0.0398
K22700 L14_19 L93_97 0.0221
K22701 L14_19 L90_94 0.0263
K22702 L14_19 L111_116 0.0243
K22703 L14_19 L162_167 0.1101
K22704 L14_19 L43_91 0.0285
K22705 L14_19 L142_147 0.0246
K22706 L14_19 L135_140 0.0235
K22707 L14_19 L123_128 0.0395
K22708 L14_19 L12_17 0.1354
K22709 L14_19 L54_58 0.0245
K22710 L14_19 L146_151 0.0286
K22711 L14_19 L61_65 0.0544
K22712 L14_19 L77_82 0.0271
K22713 L64_65 L167_168 0.065
K22714 L64_65 L74_90 0.0345
K22715 L64_65 L115_179 0.0513
K22716 L64_65 L196_197 0.0508
K22717 L64_65 L1_2 0.0427
K22718 L64_65 L163_164 0.0692
K22719 L64_65 L91_92 0.0325
K22720 L64_65 L160_161 0.0935
K22721 L64_65 L146_147 0.0307
K22722 L64_65 L204_205 0.0449
K22723 L64_65 L153_154 0.0233
K22724 L64_65 L4_5 0.0334
K22725 L64_65 L41_42 0.046
K22726 L64_65 L200_201 0.0477
K22727 L64_65 L36_37 0.0608
K22728 L64_65 L131_132 0.0457
K22729 L64_65 L100_101 0.0286
K22730 L64_65 L92_93 0.0314
K22731 L64_65 L148_149 0.0292
K22732 L64_65 L19_20 0.042
K22733 L64_65 L187_188 0.0493
K22734 L64_65 L165_166 0.075
K22735 L64_65 L8_9 0.0438
K22736 L64_65 L193_194 0.052
K22737 L64_65 L121_122 0.0911
K22738 L64_65 L134_135 0.041
K22739 L64_65 L171_172 0.0574
K22740 L64_65 L104_105 0.0229
K22741 L64_65 L151_210 0.0401
K22742 L64_65 L112_113 0.13
K22743 L64_65 L183_184 0.0483
K22744 L64_65 L59_60 0.1877
K22745 L64_65 L38_39 0.0551
K22746 L64_65 L96_97 0.03
K22747 L64_65 L78_79 0.0479
K22748 L64_65 L44_45 0.0412
K22749 L64_65 L47_48 0.123
K22750 L64_65 L29_30 0.0702
K22751 L64_65 L76_77 0.0479
K22752 L64_65 L16_17 0.0552
K22753 L64_65 L6_53 0.1369
K22754 L64_65 L149_150 0.0284
K22755 L64_65 L98_99 0.0301
K22756 L64_65 L113_114 0.1684
K22757 L64_65 L80_81 0.0416
K22758 L64_65 L87_88 0.0414
K22759 L64_65 L136_137 0.0343
K22760 L64_65 L181_182 0.0402
K22761 L64_65 L28_29 0.0772
K22762 L64_65 L9_10 0.0406
K22763 L64_65 L117_118 0.1479
K22764 L64_65 L116_117 0.0878
K22765 L64_65 L154_155 0.0228
K22766 L64_65 L7_8 0.0476
K22767 L64_65 L82_83 0.0465
K22768 L64_65 L14_15 0.0414
K22769 L64_65 L199_200 0.0436
K22770 L64_65 L125_187 0.0543
K22771 L64_65 L58_59 0.0934
K22772 L64_65 L70_71 0.0462
K22773 L64_65 L68_69 0.0524
K22774 L64_65 L89_102 0.0245
K22775 L64_65 L50_51 0.0854
K22776 L64_65 L90_91 0.0335
K22777 L64_65 L139_140 0.0313
K22778 L64_65 L161_162 0.0839
K22779 L64_65 L111_112 0.0837
K22780 L64_65 L162_163 0.0759
K22781 L64_65 L137_138 0.0333
K22782 L64_65 L179_180 0.047
K22783 L64_65 L12_13 0.0489
K22784 L64_65 L142_143 0.0316
K22785 L64_65 L123_124 0.2623
K22786 L64_65 L191_192 0.0446
K22787 L64_65 L39_40 0.0523
K22788 L64_65 L18_19 0.0456
K22789 L64_65 L54_55 0.0898
K22790 L64_65 L201_202 0.0493
K22791 L154_155 L167_168 0.0354
K22792 L154_155 L74_90 0.0657
K22793 L154_155 L115_179 0.0167
K22794 L154_155 L196_197 0.0335
K22795 L154_155 L1_2 0.0136
K22796 L154_155 L23_24 0.0233
K22797 L154_155 L158_159 0.0235
K22798 L154_155 L163_164 0.0287
K22799 L154_155 L91_92 0.0789
K22800 L154_155 L160_161 0.0282
K22801 L154_155 L126_127 0.0181
K22802 L154_155 L204_205 0.0346
K22803 L154_155 L4_5 0.0138
K22804 L154_155 L41_42 0.057
K22805 L154_155 L200_201 0.0341
K22806 L154_155 L36_37 0.0438
K22807 L154_155 L131_132 0.0587
K22808 L154_155 L100_101 0.1363
K22809 L154_155 L92_93 0.0811
K22810 L154_155 L148_149 0.1673
K22811 L154_155 L19_20 0.0187
K22812 L154_155 L187_188 0.0187
K22813 L154_155 L165_166 0.0345
K22814 L154_155 L8_9 0.0168
K22815 L154_155 L193_194 0.0427
K22816 L154_155 L21_65 0.0249
K22817 L154_155 L121_122 0.0187
K22818 L154_155 L9_10 0.0168
K22819 L154_155 L134_135 0.0652
K22820 L154_155 L171_172 0.0456
K22821 L154_155 L112_113 0.0195
K22822 L154_155 L183_184 0.0177
K22823 L154_155 L59_60 0.0209
K22824 L154_155 L38_39 0.0456
K22825 L154_155 L78_79 0.0748
K22826 L154_155 L44_45 0.0629
K22827 L154_155 L47_48 0.018
K22828 L154_155 L29_30 0.0285
K22829 L154_155 L76_77 0.0339
K22830 L154_155 L16_17 0.0185
K22831 L154_155 L181_182 0.0169
K22832 L154_155 L6_53 0.0227
K22833 L154_155 L149_150 0.1916
K22834 L154_155 L98_99 0.1062
K22835 L154_155 L113_114 0.0213
K22836 L154_155 L80_81 0.0265
K22837 L154_155 L146_147 0.0968
K22838 L154_155 L136_137 0.0696
K22839 L154_155 L127_128 0.0204
K22840 L154_155 L28_29 0.0285
K22841 L154_155 L157_158 0.0235
K22842 L154_155 L96_97 0.1033
K22843 L154_155 L129_130 0.025
K22844 L154_155 L117_118 0.0202
K22845 L154_155 L116_117 0.0182
K22846 L154_155 L21_22 0.023
K22847 L154_155 L7_8 0.0167
K22848 L154_155 L82_83 0.0483
K22849 L154_155 L14_15 0.0177
K22850 L154_155 L199_200 0.0265
K22851 L154_155 L125_187 0.0185
K22852 L154_155 L58_59 0.0187
K22853 L154_155 L70_71 0.0261
K22854 L154_155 L68_69 0.0421
K22855 L154_155 L50_51 0.0177
K22856 L154_155 L90_91 0.073
K22857 L154_155 L139_140 0.0891
K22858 L154_155 L161_162 0.0285
K22859 L154_155 L111_112 0.0177
K22860 L154_155 L162_163 0.0286
K22861 L154_155 L137_138 0.0787
K22862 L154_155 L179_180 0.0168
K22863 L154_155 L12_13 0.0176
K22864 L154_155 L142_143 0.0985
K22865 L154_155 L123_124 0.0232
K22866 L154_155 L191_192 0.0244
K22867 L154_155 L39_40 0.0459
K22868 L154_155 L18_19 0.0187
K22869 L154_155 L156_157 0.0233
K22870 L154_155 L54_55 0.0182
K22871 L154_155 L201_202 0.0478
K22872 L14_15 L167_168 0.0596
K22873 L14_15 L74_90 0.0247
K22874 L14_15 L199_200 0.0211
K22875 L14_15 L115_179 0.1015
K22876 L14_15 L196_197 0.0245
K22877 L14_15 L1_2 0.0895
K22878 L14_15 L23_24 0.1375
K22879 L14_15 L158_159 0.1276
K22880 L14_15 L163_164 0.0888
K22881 L14_15 L91_92 0.0251
K22882 L14_15 L160_161 0.0795
K22883 L14_15 L126_127 0.0254
K22884 L14_15 L204_205 0.023
K22885 L14_15 L153_154 0.0177
K22886 L14_15 L4_5 0.1487
K22887 L14_15 L41_42 0.0331
K22888 L14_15 L200_201 0.0238
K22889 L14_15 L36_37 0.0442
K22890 L14_15 L131_132 0.0328
K22891 L14_15 L100_101 0.0224
K22892 L14_15 L92_93 0.0252
K22893 L14_15 L148_149 0.0222
K22894 L14_15 L19_20 0.2054
K22895 L14_15 L187_188 0.1226
K22896 L14_15 L165_166 0.0569
K22897 L14_15 L193_194 0.0266
K22898 L14_15 L21_65 0.0597
K22899 L14_15 L121_122 0.0274
K22900 L14_15 L9_10 0.2054
K22901 L14_15 L134_135 0.0335
K22902 L14_15 L171_172 0.0445
K22903 L14_15 L104_105 0.0178
K22904 L14_15 L151_210 0.0254
K22905 L14_15 L112_113 0.0413
K22906 L14_15 L59_60 0.0341
K22907 L14_15 L129_130 0.0586
K22908 L14_15 L38_39 0.0454
K22909 L14_15 L96_97 0.0237
K22910 L14_15 L78_79 0.0296
K22911 L14_15 L44_45 0.0338
K22912 L14_15 L47_48 0.0387
K22913 L14_15 L29_30 0.0927
K22914 L14_15 L76_77 0.0238
K22915 L14_15 L16_17 0.1124
K22916 L14_15 L149_150 0.0223
K22917 L14_15 L98_99 0.0222
K22918 L14_15 L6_53 0.0996
K22919 L14_15 L113_114 0.0579
K22920 L14_15 L80_81 0.0207
K22921 L14_15 L87_88 0.0233
K22922 L14_15 L146_147 0.022
K22923 L14_15 L136_137 0.0246
K22924 L14_15 L127_128 0.0314
K22925 L14_15 L181_182 0.1536
K22926 L14_15 L28_29 0.0913
K22927 L14_15 L157_158 0.1234
K22928 L14_15 L21_22 0.1069
K22929 L14_15 L7_8 0.1439
K22930 L14_15 L82_83 0.0257
K22931 L14_15 L58_59 0.0275
K22932 L14_15 L125_187 0.1015
K22933 L14_15 L70_71 0.0217
K22934 L14_15 L68_69 0.0267
K22935 L14_15 L89_102 0.0176
K22936 L14_15 L8_9 0.1832
K22937 L14_15 L50_51 0.0321
K22938 L14_15 L90_91 0.025
K22939 L14_15 L139_140 0.025
K22940 L14_15 L161_162 0.0843
K22941 L14_15 L111_112 0.032
K22942 L14_15 L162_163 0.0876
K22943 L14_15 L137_138 0.0248
K22944 L14_15 L179_180 0.1226
K22945 L14_15 L142_143 0.0234
K22946 L14_15 L123_124 0.0445
K22947 L14_15 L191_192 0.0205
K22948 L14_15 L39_40 0.0456
K22949 L14_15 L156_157 0.1128
K22950 L14_15 L18_19 0.1832
K22951 L14_15 L201_202 0.0266
K22952 L125_187 L167_168 0.0667
K22953 L125_187 L74_90 0.0267
K22954 L125_187 L199_200 0.0238
K22955 L125_187 L115_179 0.1354
K22956 L125_187 L196_197 0.028
K22957 L125_187 L1_2 0.0911
K22958 L125_187 L23_24 0.136
K22959 L125_187 L158_159 0.1261
K22960 L125_187 L163_164 0.0947
K22961 L125_187 L91_92 0.0265
K22962 L125_187 L160_161 0.1123
K22963 L125_187 L126_127 0.03
K22964 L125_187 L204_205 0.026
K22965 L125_187 L153_154 0.0187
K22966 L125_187 L4_5 0.0706
K22967 L125_187 L41_42 0.036
K22968 L125_187 L200_201 0.0269
K22969 L125_187 L36_37 0.0492
K22970 L125_187 L131_132 0.0363
K22971 L125_187 L100_101 0.0232
K22972 L125_187 L92_93 0.0262
K22973 L125_187 L148_149 0.0235
K22974 L125_187 L165_166 0.0688
K22975 L125_187 L193_194 0.0307
K22976 L125_187 L21_65 0.09
K22977 L125_187 L9_10 0.0884
K22978 L125_187 L134_135 0.0354
K22979 L125_187 L171_172 0.0496
K22980 L125_187 L104_105 0.0185
K22981 L125_187 L151_210 0.0282
K22982 L125_187 L112_113 0.0521
K22983 L125_187 L183_184 0.1832
K22984 L125_187 L38_39 0.0484
K22985 L125_187 L78_79 0.0331
K22986 L125_187 L44_45 0.0351
K22987 L125_187 L47_48 0.0477
K22988 L125_187 L29_30 0.0907
K22989 L125_187 L76_77 0.0269
K22990 L125_187 L191_192 0.0233
K22991 L125_187 L6_53 0.1327
K22992 L125_187 L149_150 0.0233
K22993 L125_187 L98_99 0.0235
K22994 L125_187 L113_114 0.0803
K22995 L125_187 L80_81 0.0231
K22996 L125_187 L87_88 0.026
K22997 L125_187 L146_147 0.0237
K22998 L125_187 L136_137 0.0269
K22999 L125_187 L127_128 0.0389
K23000 L125_187 L181_182 0.0953
K23001 L125_187 L28_29 0.098
K23002 L125_187 L157_158 0.1555
K23003 L125_187 L96_97 0.0246
K23004 L125_187 L129_130 0.0945
K23005 L125_187 L21_22 0.1644
K23006 L125_187 L117_118 0.0533
K23007 L125_187 L116_117 0.0387
K23008 L125_187 L7_8 0.1127
K23009 L125_187 L82_83 0.0288
K23010 L125_187 L70_71 0.0244
K23011 L125_187 L68_69 0.0305
K23012 L125_187 L89_102 0.0187
K23013 L125_187 L8_9 0.1015
K23014 L125_187 L50_51 0.038
K23015 L125_187 L90_91 0.0266
K23016 L125_187 L139_140 0.0263
K23017 L125_187 L161_162 0.1098
K23018 L125_187 L111_112 0.0383
K23019 L125_187 L162_163 0.1032
K23020 L125_187 L137_138 0.0268
K23021 L125_187 L179_180 0.1284
K23022 L125_187 L12_13 0.1438
K23023 L125_187 L142_143 0.0251
K23024 L125_187 L39_40 0.0475
K23025 L125_187 L156_157 0.1891
K23026 L125_187 L54_55 0.0385
K23027 L125_187 L201_202 0.0303
K23028 L136_137 L167_168 0.0537
K23029 L136_137 L199_200 0.0321
K23030 L136_137 L115_179 0.0237
K23031 L136_137 L1_2 0.0192
K23032 L136_137 L23_24 0.0332
K23033 L136_137 L158_159 0.0331
K23034 L136_137 L163_164 0.0409
K23035 L136_137 L160_161 0.042
K23036 L136_137 L126_127 0.0263
K23037 L136_137 L204_205 0.041
K23038 L136_137 L153_154 0.0787
K23039 L136_137 L4_5 0.019
K23040 L136_137 L41_42 0.1276
K23041 L136_137 L201_202 0.0589
K23042 L136_137 L191_192 0.0363
K23043 L136_137 L200_201 0.0416
K23044 L136_137 L36_37 0.0766
K23045 L136_137 L131_132 0.1436
K23046 L136_137 L100_101 0.0884
K23047 L136_137 L148_149 0.1124
K23048 L136_137 L19_20 0.0262
K23049 L136_137 L187_188 0.0268
K23050 L136_137 L165_166 0.0548
K23051 L136_137 L8_9 0.0234
K23052 L136_137 L193_194 0.0819
K23053 L136_137 L21_65 0.0372
K23054 L136_137 L121_122 0.027
K23055 L136_137 L9_10 0.0232
K23056 L136_137 L134_135 0.1069
K23057 L136_137 L171_172 0.0781
K23058 L136_137 L104_105 0.0657
K23059 L136_137 L151_210 0.0803
K23060 L136_137 L112_113 0.0282
K23061 L136_137 L183_184 0.0251
K23062 L136_137 L59_60 0.0307
K23063 L136_137 L38_39 0.0736
K23064 L136_137 L78_79 0.095
K23065 L136_137 L44_45 0.1001
K23066 L136_137 L47_48 0.0259
K23067 L136_137 L29_30 0.0406
K23068 L136_137 L76_77 0.0413
K23069 L136_137 L16_17 0.0267
K23070 L136_137 L6_53 0.0326
K23071 L136_137 L149_150 0.0953
K23072 L136_137 L98_99 0.1127
K23073 L136_137 L113_114 0.0309
K23074 L136_137 L80_81 0.0317
K23075 L136_137 L87_88 0.0513
K23076 L136_137 L146_147 0.1354
K23077 L136_137 L127_128 0.0304
K23078 L136_137 L181_182 0.0233
K23079 L136_137 L28_29 0.0412
K23080 L136_137 L157_158 0.0334
K23081 L136_137 L96_97 0.1015
K23082 L136_137 L129_130 0.0375
K23083 L136_137 L21_22 0.0335
K23084 L136_137 L117_118 0.0295
K23085 L136_137 L116_117 0.0261
K23086 L136_137 L7_8 0.0235
K23087 L136_137 L82_83 0.0564
K23088 L136_137 L58_59 0.027
K23089 L136_137 L68_69 0.079
K23090 L136_137 L89_102 0.0811
K23091 L136_137 L50_51 0.0252
K23092 L136_137 L161_162 0.0419
K23093 L136_137 L111_112 0.0252
K23094 L136_137 L162_163 0.0415
K23095 L136_137 L179_180 0.0237
K23096 L136_137 L12_13 0.025
K23097 L136_137 L142_143 0.1832
K23098 L136_137 L123_124 0.0345
K23099 L136_137 L39_40 0.0704
K23100 L136_137 L18_19 0.0265
K23101 L136_137 L156_157 0.0337
K23102 L136_137 L54_55 0.026
K23103 L79_84 L181_185 0.0286
K23104 L79_84 L35_40 0.0542
K23105 L79_84 L73_78 0.1086
K23106 L79_84 L163_168 0.0491
K23107 L79_84 L91_95 0.0991
K23108 L79_84 L4_9 0.0273
K23109 L79_84 L202_206 0.1064
K23110 L79_84 L109_114 0.0394
K23111 L79_84 L57_61 0.0437
K23112 L79_84 L164_169 0.0441
K23113 L79_84 L158_189 0.0319
K23114 L79_84 L53_57 0.0415
K23115 L79_84 L69_73 0.1051
K23116 L79_84 L200_204 0.0504
K23117 L79_84 L145_150 0.0604
K23118 L79_84 L30_35 0.0445
K23119 L79_84 L46_50 0.0261
K23120 L79_84 L196_200 0.0503
K23121 L79_84 L92_96 0.0833
K23122 L79_84 L19_24 0.032
K23123 L79_84 L193_197 0.0673
K23124 L79_84 L7_12 0.0297
K23125 L79_84 L137_142 0.1131
K23126 L79_84 L167_172 0.0635
K23127 L79_84 L121_126 0.0285
K23128 L79_84 L113_118 0.0375
K23129 L79_84 L134_139 0.0775
K23130 L79_84 L33_38 0.0643
K23131 L79_84 L124_129 0.0458
K23132 L79_84 L78_83 0.1098
K23133 L79_84 L112_117 0.0336
K23134 L79_84 L40_45 0.0671
K23135 L79_84 L183_187 0.0313
K23136 L79_84 L59_63 0.0359
K23137 L79_84 L5_10 0.0223
K23138 L79_84 L15_20 0.0247
K23139 L79_84 L58_62 0.0286
K23140 L79_84 L29_34 0.0495
K23141 L79_84 L179_183 0.0296
K23142 L79_84 L191_195 0.0385
K23143 L79_84 L66_70 0.0387
K23144 L79_84 L98_102 0.1224
K23145 L79_84 L27_32 0.0526
K23146 L79_84 L142_147 0.1161
K23147 L79_84 L178_182 0.0222
K23148 L79_84 L3_8 0.0277
K23149 L79_84 L149_154 0.0803
K23150 L79_84 L117_122 0.0347
K23151 L79_84 L38_43 0.0842
K23152 L79_84 L135_174 0.066
K23153 L79_84 L80_85 0.0389
K23154 L79_84 L10_15 0.0234
K23155 L79_84 L158_163 0.0409
K23156 L79_84 L96_100 0.0844
K23157 L79_84 L49_53 0.0395
K23158 L79_84 L186_190 0.0246
K23159 L79_84 L82_87 0.069
K23160 L79_84 L159_164 0.0371
K23161 L79_84 L9_14 0.0287
K23162 L79_84 L204_208 0.0503
K23163 L79_84 L44_92 0.0802
K23164 L79_84 L199_203 0.0388
K23165 L79_84 L75_80 0.039
K23166 L79_84 L70_75 0.0389
K23167 L79_84 L50_54 0.0269
K23168 L79_84 L56_60 0.0393
K23169 L79_84 L93_97 0.0615
K23170 L79_84 L90_94 0.1224
K23171 L79_84 L134_173 0.0759
K23172 L79_84 L139_144 0.0803
K23173 L79_84 L177_181 0.0272
K23174 L79_84 L111_116 0.0268
K23175 L79_84 L162_167 0.0507
K23176 L79_84 L43_91 0.0939
K23177 L79_84 L122_127 0.0358
K23178 L79_84 L135_140 0.0581
K23179 L79_84 L39_44 0.0774
K23180 L79_84 L123_128 0.0408
K23181 L79_84 L54_58 0.0277
K23182 L79_84 L61_65 0.046
K23183 L79_84 L12_17 0.0314
K23184 L79_84 L77_82 0.0692
K23185 L161_162 L167_168 0.1258
K23186 L161_162 L74_90 0.0416
K23187 L161_162 L199_200 0.0329
K23188 L161_162 L115_179 0.0781
K23189 L161_162 L196_197 0.0392
K23190 L161_162 L1_2 0.0607
K23191 L161_162 L23_24 0.1389
K23192 L161_162 L158_159 0.1386
K23193 L161_162 L91_92 0.0416
K23194 L161_162 L126_127 0.0447
K23195 L161_162 L204_205 0.0366
K23196 L161_162 L153_154 0.0286
K23197 L161_162 L4_5 0.0591
K23198 L161_162 L41_42 0.057
K23199 L161_162 L200_201 0.0379
K23200 L161_162 L50_51 0.0447
K23201 L161_162 L131_132 0.0577
K23202 L161_162 L100_101 0.0359
K23203 L161_162 L92_93 0.0412
K23204 L161_162 L148_149 0.0363
K23205 L161_162 L19_20 0.098
K23206 L161_162 L187_188 0.1123
K23207 L161_162 L165_166 0.1258
K23208 L161_162 L8_9 0.0758
K23209 L161_162 L193_194 0.0441
K23210 L161_162 L21_65 0.1333
K23211 L161_162 L121_122 0.0469
K23212 L161_162 L9_10 0.0736
K23213 L161_162 L134_135 0.057
K23214 L161_162 L171_172 0.0832
K23215 L161_162 L104_105 0.0283
K23216 L161_162 L151_210 0.0417
K23217 L161_162 L112_113 0.0568
K23218 L161_162 L183_184 0.0927
K23219 L161_162 L59_60 0.0605
K23220 L161_162 L38_39 0.0811
K23221 L161_162 L78_79 0.0491
K23222 L161_162 L44_45 0.0564
K23223 L161_162 L47_48 0.0521
K23224 L161_162 L76_77 0.0377
K23225 L161_162 L16_17 0.1035
K23226 L161_162 L6_53 0.0955
K23227 L161_162 L149_150 0.0361
K23228 L161_162 L98_99 0.0362
K23229 L161_162 L113_114 0.0747
K23230 L161_162 L80_81 0.0319
K23231 L161_162 L87_88 0.0374
K23232 L161_162 L146_147 0.0363
K23233 L161_162 L127_128 0.0591
K23234 L161_162 L181_182 0.0757
K23235 L161_162 L157_158 0.1502
K23236 L161_162 L96_97 0.0383
K23237 L161_162 L129_130 0.1415
K23238 L161_162 L21_22 0.1389
K23239 L161_162 L117_118 0.059
K23240 L161_162 L116_117 0.046
K23241 L161_162 L7_8 0.0766
K23242 L161_162 L82_83 0.0415
K23243 L161_162 L58_59 0.0467
K23244 L161_162 L70_71 0.0336
K23245 L161_162 L68_69 0.0439
K23246 L161_162 L89_102 0.0285
K23247 L161_162 L36_37 0.0811
K23248 L161_162 L90_91 0.0417
K23249 L161_162 L139_140 0.0415
K23250 L161_162 L111_112 0.0449
K23251 L161_162 L137_138 0.042
K23252 L161_162 L179_180 0.079
K23253 L161_162 L12_13 0.0888
K23254 L161_162 L142_143 0.039
K23255 L161_162 L123_124 0.0853
K23256 L161_162 L191_192 0.0321
K23257 L161_162 L39_40 0.0796
K23258 L161_162 L18_19 0.1035
K23259 L161_162 L156_157 0.1549
K23260 L161_162 L54_55 0.0457
K23261 L161_162 L201_202 0.0436
K23262 L135_140 L181_185 0.0221
K23263 L135_140 L1_6 0.0246
K23264 L135_140 L73_78 0.0417
K23265 L135_140 L163_168 0.0528
K23266 L135_140 L91_95 0.0988
K23267 L135_140 L130_160 0.0339
K23268 L135_140 L4_9 0.0206
K23269 L135_140 L109_114 0.0248
K23270 L135_140 L57_61 0.0268
K23271 L135_140 L53_57 0.0257
K23272 L135_140 L69_73 0.0418
K23273 L135_140 L200_204 0.0249
K23274 L135_140 L131_136 0.0622
K23275 L135_140 L46_50 0.0154
K23276 L135_140 L196_200 0.025
K23277 L135_140 L92_96 0.1266
K23278 L135_140 L19_24 0.0252
K23279 L135_140 L120_125 0.0275
K23280 L135_140 L193_197 0.0314
K23281 L135_140 L7_12 0.0215
K23282 L135_140 L137_142 0.0861
K23283 L135_140 L167_172 0.0762
K23284 L135_140 L121_126 0.0165
K23285 L135_140 L110_115 0.0247
K23286 L135_140 L113_118 0.0227
K23287 L135_140 L134_139 0.1916
K23288 L135_140 L141_146 0.0597
K23289 L135_140 L9_14 0.022
K23290 L135_140 L33_38 0.0728
K23291 L135_140 L124_129 0.0281
K23292 L135_140 L78_83 0.0412
K23293 L135_140 L112_117 0.0199
K23294 L135_140 L183_187 0.023
K23295 L135_140 L59_63 0.0208
K23296 L135_140 L58_62 0.0165
K23297 L135_140 L29_34 0.0517
K23298 L135_140 L179_183 0.0216
K23299 L135_140 L41_74 0.0604
K23300 L135_140 L131_170 0.0877
K23301 L135_140 L191_195 0.0195
K23302 L135_140 L66_70 0.0195
K23303 L135_140 L98_102 0.0657
K23304 L135_140 L27_32 0.0479
K23305 L135_140 L142_147 0.0787
K23306 L135_140 L3_8 0.0204
K23307 L135_140 L149_154 0.0968
K23308 L135_140 L117_122 0.0204
K23309 L135_140 L158_189 0.0254
K23310 L135_140 L38_43 0.1123
K23311 L135_140 L115_120 0.026
K23312 L135_140 L80_85 0.0193
K23313 L135_140 L16_21 0.029
K23314 L135_140 L158_163 0.0386
K23315 L135_140 L96_100 0.1062
K23316 L135_140 L49_53 0.0247
K23317 L135_140 L82_87 0.0307
K23318 L135_140 L125_130 0.0292
K23319 L135_140 L84_89 0.0556
K23320 L135_140 L204_208 0.0247
K23321 L135_140 L202_206 0.0417
K23322 L135_140 L44_92 0.1363
K23323 L135_140 L21_26 0.0336
K23324 L135_140 L74_79 0.0598
K23325 L135_140 L165_170 0.0622
K23326 L135_140 L199_203 0.0194
K23327 L135_140 L75_80 0.0194
K23328 L135_140 L70_75 0.0194
K23329 L135_140 L50_54 0.0158
K23330 L135_140 L56_60 0.0233
K23331 L135_140 L90_94 0.0789
K23332 L135_140 L134_173 0.1671
K23333 L135_140 L139_144 0.1673
K23334 L135_140 L177_181 0.0207
K23335 L135_140 L111_116 0.0158
K23336 L135_140 L162_167 0.051
K23337 L135_140 L43_91 0.1033
K23338 L135_140 L122_127 0.0208
K23339 L135_140 L39_44 0.1366
K23340 L135_140 L123_128 0.0241
K23341 L135_140 L12_17 0.0229
K23342 L135_140 L54_58 0.0161
K23343 L135_140 L146_151 0.057
K23344 L135_140 L61_65 0.028
K23345 L135_140 L77_82 0.031
K23346 L18_19 L167_168 0.0673
K23347 L18_19 L74_90 0.0266
K23348 L18_19 L199_200 0.0223
K23349 L18_19 L115_179 0.1015
K23350 L18_19 L196_197 0.0261
K23351 L18_19 L1_2 0.0877
K23352 L18_19 L23_24 0.2069
K23353 L18_19 L158_159 0.1556
K23354 L18_19 L163_164 0.1035
K23355 L18_19 L91_92 0.0269
K23356 L18_19 L160_161 0.098
K23357 L18_19 L126_127 0.0268
K23358 L18_19 L204_205 0.0245
K23359 L18_19 L153_154 0.0187
K23360 L18_19 L4_5 0.0983
K23361 L18_19 L41_42 0.0359
K23362 L18_19 L200_201 0.0253
K23363 L18_19 L36_37 0.049
K23364 L18_19 L131_132 0.0356
K23365 L18_19 L100_101 0.0237
K23366 L18_19 L92_93 0.0268
K23367 L18_19 L148_149 0.0236
K23368 L18_19 L165_166 0.0653
K23369 L18_19 L193_194 0.0286
K23370 L18_19 L21_65 0.0697
K23371 L18_19 L9_10 0.1284
K23372 L18_19 L134_135 0.0359
K23373 L18_19 L171_172 0.049
K23374 L18_19 L104_105 0.0188
K23375 L18_19 L151_210 0.0271
K23376 L18_19 L112_113 0.0438
K23377 L18_19 L183_184 0.1438
K23378 L18_19 L38_39 0.0498
K23379 L18_19 L78_79 0.0319
K23380 L18_19 L44_45 0.0362
K23381 L18_19 L47_48 0.041
K23382 L18_19 L29_30 0.1098
K23383 L18_19 L76_77 0.0253
K23384 L18_19 L191_192 0.0217
K23385 L18_19 L6_53 0.1069
K23386 L18_19 L149_150 0.0235
K23387 L18_19 L98_99 0.0237
K23388 L18_19 L113_114 0.0623
K23389 L18_19 L80_81 0.0218
K23390 L18_19 L87_88 0.0248
K23391 L18_19 L146_147 0.0234
K23392 L18_19 L127_128 0.0337
K23393 L18_19 L181_182 0.1127
K23394 L18_19 L28_29 0.1123
K23395 L18_19 L157_158 0.1644
K23396 L18_19 L96_97 0.0251
K23397 L18_19 L129_130 0.068
K23398 L18_19 L21_22 0.1555
K23399 L18_19 L117_118 0.0445
K23400 L18_19 L116_117 0.0339
K23401 L18_19 L7_8 0.1284
K23402 L18_19 L82_83 0.0275
K23403 L18_19 L70_71 0.0229
K23404 L18_19 L68_69 0.0287
K23405 L18_19 L89_102 0.0187
K23406 L18_19 L8_9 0.1354
K23407 L18_19 L50_51 0.0338
K23408 L18_19 L90_91 0.0268
K23409 L18_19 L139_140 0.0266
K23410 L18_19 L111_112 0.0336
K23411 L18_19 L162_163 0.1055
K23412 L18_19 L137_138 0.0266
K23413 L18_19 L179_180 0.1127
K23414 L18_19 L12_13 0.1832
K23415 L18_19 L142_143 0.025
K23416 L18_19 L39_40 0.0496
K23417 L18_19 L156_157 0.1556
K23418 L18_19 L54_55 0.0341
K23419 L18_19 L201_202 0.0285
K23420 L54_58 L181_185 0.0243
K23421 L54_58 L1_6 0.0387
K23422 L54_58 L35_40 0.0256
K23423 L54_58 L73_78 0.0364
K23424 L54_58 L163_168 0.0299
K23425 L54_58 L91_95 0.0202
K23426 L54_58 L130_160 0.0329
K23427 L54_58 L4_9 0.0243
K23428 L54_58 L202_206 0.0349
K23429 L54_58 L109_114 0.0549
K23430 L54_58 L57_61 0.056
K23431 L54_58 L164_169 0.0267
K23432 L54_58 L53_57 0.0558
K23433 L54_58 L69_73 0.0378
K23434 L54_58 L200_204 0.0427
K23435 L54_58 L145_150 0.0154
K23436 L54_58 L30_35 0.0268
K23437 L54_58 L131_136 0.0294
K23438 L54_58 L122_127 0.1405
K23439 L54_58 L196_200 0.0453
K23440 L54_58 L92_96 0.0196
K23441 L54_58 L19_24 0.0244
K23442 L54_58 L120_125 0.0388
K23443 L54_58 L193_197 0.0431
K23444 L54_58 L7_12 0.0271
K23445 L54_58 L137_142 0.0208
K23446 L54_58 L167_172 0.0297
K23447 L54_58 L110_115 0.0385
K23448 L54_58 L113_118 0.0797
K23449 L54_58 L134_139 0.02
K23450 L54_58 L141_146 0.0276
K23451 L54_58 L9_14 0.0244
K23452 L54_58 L33_38 0.0298
K23453 L54_58 L124_129 0.0554
K23454 L54_58 L78_83 0.035
K23455 L54_58 L112_117 0.1405
K23456 L54_58 L40_45 0.0241
K23457 L54_58 L183_187 0.0271
K23458 L54_58 L59_63 0.1506
K23459 L54_58 L5_10 0.0194
K23460 L54_58 L15_20 0.0195
K23461 L54_58 L29_34 0.03
K23462 L54_58 L158_189 0.0243
K23463 L54_58 L41_74 0.0295
K23464 L54_58 L131_170 0.0275
K23465 L54_58 L98_102 0.0197
K23466 L54_58 L27_32 0.033
K23467 L54_58 L178_182 0.0194
K23468 L54_58 L3_8 0.0256
K23469 L54_58 L149_154 0.0186
K23470 L54_58 L117_122 0.1437
K23471 L54_58 L38_43 0.0279
K23472 L54_58 L135_174 0.0241
K23473 L54_58 L115_120 0.0387
K23474 L54_58 L10_15 0.0195
K23475 L54_58 L16_21 0.0389
K23476 L54_58 L158_163 0.0309
K23477 L54_58 L96_100 0.0191
K23478 L54_58 L49_53 0.0553
K23479 L54_58 L186_190 0.0195
K23480 L54_58 L82_87 0.0375
K23481 L54_58 L125_130 0.0387
K23482 L54_58 L159_164 0.0275
K23483 L54_58 L204_208 0.0405
K23484 L54_58 L44_92 0.02
K23485 L54_58 L21_26 0.033
K23486 L54_58 L84_89 0.0269
K23487 L54_58 L74_79 0.0286
K23488 L54_58 L165_170 0.0296
K23489 L54_58 L56_60 0.0818
K23490 L54_58 L93_97 0.0158
K23491 L54_58 L90_94 0.0209
K23492 L54_58 L134_173 0.0268
K23493 L54_58 L139_144 0.0195
K23494 L54_58 L177_181 0.0243
K23495 L54_58 L179_183 0.027
K23496 L54_58 L162_167 0.0314
K23497 L54_58 L43_91 0.0207
K23498 L54_58 L142_147 0.0203
K23499 L54_58 L39_44 0.0269
K23500 L54_58 L123_128 0.0797
K23501 L54_58 L12_17 0.0272
K23502 L54_58 L146_151 0.0268
K23503 L54_58 L61_65 0.0558
K23504 L54_58 L77_82 0.0393
K23505 L54_55 L167_168 0.0405
K23506 L54_55 L74_90 0.0261
K23507 L54_55 L199_200 0.046
K23508 L54_55 L115_179 0.032
K23509 L54_55 L196_197 0.0474
K23510 L54_55 L1_2 0.0266
K23511 L54_55 L23_24 0.0407
K23512 L54_55 L158_159 0.0383
K23513 L54_55 L163_164 0.0411
K23514 L54_55 L91_92 0.0245
K23515 L54_55 L160_161 0.0484
K23516 L54_55 L126_127 0.2081
K23517 L54_55 L204_205 0.0425
K23518 L54_55 L153_154 0.0187
K23519 L54_55 L4_5 0.0227
K23520 L54_55 L41_42 0.0334
K23521 L54_55 L200_201 0.0448
K23522 L54_55 L36_37 0.0406
K23523 L54_55 L131_132 0.0333
K23524 L54_55 L100_101 0.0225
K23525 L54_55 L92_93 0.0238
K23526 L54_55 L148_149 0.023
K23527 L54_55 L19_20 0.0321
K23528 L54_55 L187_188 0.0361
K23529 L54_55 L165_166 0.0445
K23530 L54_55 L193_194 0.0425
K23531 L54_55 L21_65 0.0608
K23532 L54_55 L121_122 0.2659
K23533 L54_55 L9_10 0.0275
K23534 L54_55 L134_135 0.0301
K23535 L54_55 L171_172 0.0388
K23536 L54_55 L104_105 0.0182
K23537 L54_55 L151_210 0.033
K23538 L54_55 L112_113 0.1743
K23539 L54_55 L59_60 0.1933
K23540 L54_55 L129_130 0.0602
K23541 L54_55 L38_39 0.0374
K23542 L54_55 L96_97 0.0231
K23543 L54_55 L78_79 0.0379
K23544 L54_55 L44_45 0.0301
K23545 L54_55 L47_48 0.1727
K23546 L54_55 L29_30 0.0413
K23547 L54_55 L76_77 0.045
K23548 L54_55 L16_17 0.0387
K23549 L54_55 L149_150 0.0224
K23550 L54_55 L98_99 0.0237
K23551 L54_55 L6_53 0.066
K23552 L54_55 L113_114 0.0969
K23553 L54_55 L80_81 0.0437
K23554 L54_55 L87_88 0.036
K23555 L54_55 L146_147 0.0243
K23556 L54_55 L127_128 0.1479
K23557 L54_55 L181_182 0.0274
K23558 L54_55 L28_29 0.0435
K23559 L54_55 L157_158 0.0405
K23560 L54_55 L21_22 0.0461
K23561 L54_55 L7_8 0.0304
K23562 L54_55 L82_83 0.04
K23563 L54_55 L58_59 0.3334
K23564 L54_55 L70_71 0.0491
K23565 L54_55 L68_69 0.0427
K23566 L54_55 L89_102 0.0197
K23567 L54_55 L8_9 0.0289
K23568 L54_55 L50_51 0.3334
K23569 L54_55 L90_91 0.0253
K23570 L54_55 L139_140 0.0237
K23571 L54_55 L111_112 0.2659
K23572 L54_55 L162_163 0.0433
K23573 L54_55 L137_138 0.0253
K23574 L54_55 L179_180 0.0303
K23575 L54_55 L142_143 0.0245
K23576 L54_55 L123_124 0.0969
K23577 L54_55 L191_192 0.0477
K23578 L54_55 L39_40 0.036
K23579 L54_55 L156_157 0.043
K23580 L54_55 L201_202 0.0418
K23581 L77_82 L181_185 0.0261
K23582 L77_82 L1_6 0.0362
K23583 L77_82 L35_40 0.0389
K23584 L77_82 L73_78 0.1134
K23585 L77_82 L163_168 0.0396
K23586 L77_82 L91_95 0.0426
K23587 L77_82 L130_160 0.0362
K23588 L77_82 L4_9 0.0254
K23589 L77_82 L202_206 0.1114
K23590 L77_82 L109_114 0.0443
K23591 L77_82 L57_61 0.0489
K23592 L77_82 L164_169 0.0355
K23593 L77_82 L204_208 0.1104
K23594 L77_82 L53_57 0.0466
K23595 L77_82 L69_73 0.1103
K23596 L77_82 L200_204 0.1114
K23597 L77_82 L145_150 0.0312
K23598 L77_82 L30_35 0.0356
K23599 L77_82 L131_136 0.0673
K23600 L77_82 L46_50 0.0358
K23601 L77_82 L196_200 0.1104
K23602 L77_82 L92_96 0.0398
K23603 L77_82 L19_24 0.028
K23604 L77_82 L120_125 0.0391
K23605 L77_82 L7_12 0.0278
K23606 L77_82 L137_142 0.0455
K23607 L77_82 L167_172 0.0457
K23608 L77_82 L121_126 0.041
K23609 L77_82 L110_115 0.0361
K23610 L77_82 L134_139 0.0392
K23611 L77_82 L141_146 0.0684
K23612 L77_82 L9_14 0.0262
K23613 L77_82 L33_38 0.0459
K23614 L77_82 L124_129 0.0513
K23615 L77_82 L78_83 0.1145
K23616 L77_82 L112_117 0.0464
K23617 L77_82 L40_45 0.0419
K23618 L77_82 L183_187 0.0287
K23619 L77_82 L59_63 0.0515
K23620 L77_82 L5_10 0.0206
K23621 L77_82 L15_20 0.0219
K23622 L77_82 L58_62 0.0412
K23623 L77_82 L29_34 0.0397
K23624 L77_82 L179_183 0.0277
K23625 L77_82 L158_189 0.0279
K23626 L77_82 L41_74 0.0681
K23627 L77_82 L131_170 0.0514
K23628 L77_82 L191_195 0.0782
K23629 L77_82 L66_70 0.0796
K23630 L77_82 L98_102 0.0459
K23631 L77_82 L27_32 0.0432
K23632 L77_82 L142_147 0.0457
K23633 L77_82 L178_182 0.0205
K23634 L77_82 L3_8 0.0261
K23635 L77_82 L149_154 0.0395
K23636 L77_82 L117_122 0.0487
K23637 L77_82 L38_43 0.0502
K23638 L77_82 L135_174 0.0417
K23639 L77_82 L115_120 0.0375
K23640 L77_82 L80_85 0.0812
K23641 L77_82 L10_15 0.0213
K23642 L77_82 L16_21 0.041
K23643 L77_82 L158_163 0.0359
K23644 L77_82 L96_100 0.0398
K23645 L77_82 L49_53 0.0444
K23646 L77_82 L186_190 0.0219
K23647 L77_82 L125_130 0.0408
K23648 L77_82 L159_164 0.0323
K23649 L77_82 L44_92 0.0395
K23650 L77_82 L21_26 0.0364
K23651 L77_82 L84_89 0.069
K23652 L77_82 L74_79 0.069
K23653 L77_82 L165_170 0.0461
K23654 L77_82 L199_203 0.0802
K23655 L77_82 L75_80 0.0818
K23656 L77_82 L70_75 0.0812
K23657 L77_82 L50_54 0.0375
K23658 L77_82 L93_97 0.0313
K23659 L77_82 L90_94 0.0459
K23660 L77_82 L134_173 0.0471
K23661 L77_82 L139_144 0.0395
K23662 L77_82 L177_181 0.0253
K23663 L77_82 L111_116 0.0373
K23664 L77_82 L162_167 0.0412
K23665 L77_82 L43_91 0.0423
K23666 L77_82 L122_127 0.0513
K23667 L77_82 L39_44 0.0473
K23668 L77_82 L12_17 0.0288
K23669 L77_82 L146_151 0.0681
K23670 L77_82 L61_65 0.0515
K23671 L167_168 L74_90 0.053
K23672 L167_168 L199_200 0.0341
K23673 L167_168 L115_179 0.0537
K23674 L167_168 L196_197 0.0414
K23675 L167_168 L1_2 0.0429
K23676 L167_168 L23_24 0.0873
K23677 L167_168 L158_159 0.0888
K23678 L167_168 L163_164 0.1258
K23679 L167_168 L91_92 0.054
K23680 L167_168 L160_161 0.12
K23681 L167_168 L126_127 0.04
K23682 L167_168 L204_205 0.0389
K23683 L167_168 L153_154 0.0355
K23684 L167_168 L4_5 0.0435
K23685 L167_168 L41_42 0.0751
K23686 L167_168 L200_201 0.0402
K23687 L167_168 L36_37 0.1153
K23688 L167_168 L131_132 0.0766
K23689 L167_168 L100_101 0.045
K23690 L167_168 L92_93 0.0538
K23691 L167_168 L148_149 0.0456
K23692 L167_168 L19_20 0.0668
K23693 L167_168 L8_9 0.054
K23694 L167_168 L193_194 0.0483
K23695 L167_168 L21_65 0.0861
K23696 L167_168 L121_122 0.0417
K23697 L167_168 L9_10 0.0538
K23698 L167_168 L187_188 0.0683
K23699 L167_168 L134_135 0.0782
K23700 L167_168 L171_172 0.1258
K23701 L167_168 L104_105 0.0351
K23702 L167_168 L151_210 0.0481
K23703 L167_168 L112_113 0.0477
K23704 L167_168 L183_184 0.0606
K23705 L167_168 L59_60 0.0512
K23706 L167_168 L38_39 0.1221
K23707 L167_168 L78_79 0.0569
K23708 L167_168 L44_45 0.0767
K23709 L167_168 L47_48 0.0438
K23710 L167_168 L29_30 0.1203
K23711 L167_168 L76_77 0.04
K23712 L167_168 L16_17 0.0653
K23713 L167_168 L6_53 0.0688
K23714 L167_168 L149_150 0.0454
K23715 L167_168 L98_99 0.045
K23716 L167_168 L113_114 0.0582
K23717 L167_168 L80_81 0.0332
K23718 L167_168 L87_88 0.0412
K23719 L167_168 L146_147 0.045
K23720 L167_168 L127_128 0.0502
K23721 L167_168 L181_182 0.0545
K23722 L167_168 L28_29 0.1221
K23723 L167_168 L157_158 0.0897
K23724 L167_168 L96_97 0.049
K23725 L167_168 L129_130 0.0881
K23726 L167_168 L21_22 0.0843
K23727 L167_168 L117_118 0.0496
K23728 L167_168 L116_117 0.0406
K23729 L167_168 L7_8 0.0538
K23730 L167_168 L82_83 0.0457
K23731 L167_168 L58_59 0.0415
K23732 L167_168 L70_71 0.0347
K23733 L167_168 L68_69 0.048
K23734 L167_168 L89_102 0.0348
K23735 L167_168 L50_51 0.0394
K23736 L167_168 L90_91 0.0538
K23737 L167_168 L139_140 0.0545
K23738 L167_168 L111_112 0.0396
K23739 L167_168 L162_163 0.1279
K23740 L167_168 L137_138 0.0545
K23741 L167_168 L179_180 0.0545
K23742 L167_168 L12_13 0.0596
K23743 L167_168 L142_143 0.0496
K23744 L167_168 L123_124 0.0656
K23745 L167_168 L191_192 0.033
K23746 L167_168 L39_40 0.1203
K23747 L167_168 L156_157 0.0888
K23748 L167_168 L201_202 0.048
K23749 L74_90 L199_200 0.032
K23750 L74_90 L115_179 0.0236
K23751 L74_90 L1_2 0.0193
K23752 L74_90 L23_24 0.0334
K23753 L74_90 L158_159 0.0328
K23754 L74_90 L163_164 0.0406
K23755 L74_90 L160_161 0.0417
K23756 L74_90 L126_127 0.0262
K23757 L74_90 L204_205 0.0407
K23758 L74_90 L153_154 0.073
K23759 L74_90 L4_5 0.0191
K23760 L74_90 L41_42 0.1436
K23761 L74_90 L201_202 0.0579
K23762 L74_90 L191_192 0.0361
K23763 L74_90 L200_201 0.0413
K23764 L74_90 L36_37 0.079
K23765 L74_90 L131_132 0.1276
K23766 L74_90 L100_101 0.0953
K23767 L74_90 L148_149 0.1015
K23768 L74_90 L19_20 0.0263
K23769 L74_90 L187_188 0.0266
K23770 L74_90 L165_166 0.054
K23771 L74_90 L8_9 0.0235
K23772 L74_90 L193_194 0.079
K23773 L74_90 L21_65 0.0375
K23774 L74_90 L121_122 0.027
K23775 L74_90 L9_10 0.0233
K23776 L74_90 L134_135 0.1001
K23777 L74_90 L171_172 0.0758
K23778 L74_90 L104_105 0.0696
K23779 L74_90 L151_210 0.0776
K23780 L74_90 L112_113 0.0281
K23781 L74_90 L183_184 0.025
K23782 L74_90 L59_60 0.0308
K23783 L74_90 L38_39 0.0757
K23784 L74_90 L78_79 0.0996
K23785 L74_90 L44_45 0.1069
K23786 L74_90 L47_48 0.026
K23787 L74_90 L29_30 0.0409
K23788 L74_90 L76_77 0.0416
K23789 L74_90 L16_17 0.0269
K23790 L74_90 L6_53 0.0328
K23791 L74_90 L149_150 0.0884
K23792 L74_90 L98_99 0.1284
K23793 L74_90 L113_114 0.0308
K23794 L74_90 L80_81 0.0319
K23795 L74_90 L87_88 0.052
K23796 L74_90 L146_147 0.1173
K23797 L74_90 L127_128 0.0302
K23798 L74_90 L181_182 0.0232
K23799 L74_90 L28_29 0.0415
K23800 L74_90 L157_158 0.0332
K23801 L74_90 L96_97 0.1124
K23802 L74_90 L129_130 0.0372
K23803 L74_90 L21_22 0.0338
K23804 L74_90 L117_118 0.0293
K23805 L74_90 L116_117 0.026
K23806 L74_90 L7_8 0.0237
K23807 L74_90 L82_83 0.0573
K23808 L74_90 L58_59 0.027
K23809 L74_90 L68_69 0.0819
K23810 L74_90 L89_102 0.0891
K23811 L74_90 L50_51 0.0252
K23812 L74_90 L111_112 0.0252
K23813 L74_90 L162_163 0.0412
K23814 L74_90 L179_180 0.0235
K23815 L74_90 L12_13 0.0251
K23816 L74_90 L142_143 0.1438
K23817 L74_90 L123_124 0.0343
K23818 L74_90 L39_40 0.0722
K23819 L74_90 L156_157 0.0335
K23820 L164_169 L181_185 0.067
K23821 L164_169 L1_6 0.0574
K23822 L164_169 L73_78 0.0436
K23823 L164_169 L163_168 0.305
K23824 L164_169 L91_95 0.0418
K23825 L164_169 L130_160 0.1129
K23826 L164_169 L4_9 0.0576
K23827 L164_169 L109_114 0.0497
K23828 L164_169 L57_61 0.0531
K23829 L164_169 L53_57 0.0512
K23830 L164_169 L69_73 0.0454
K23831 L164_169 L200_204 0.0305
K23832 L164_169 L131_136 0.0506
K23833 L164_169 L46_50 0.026
K23834 L164_169 L196_200 0.0312
K23835 L164_169 L92_96 0.0426
K23836 L164_169 L19_24 0.0874
K23837 L164_169 L120_125 0.0671
K23838 L164_169 L193_197 0.0378
K23839 L164_169 L7_12 0.0592
K23840 L164_169 L137_142 0.0412
K23841 L164_169 L167_172 0.1538
K23842 L164_169 L121_126 0.0271
K23843 L164_169 L110_115 0.0582
K23844 L164_169 L113_118 0.0409
K23845 L164_169 L134_139 0.0473
K23846 L164_169 L141_146 0.0445
K23847 L164_169 L9_14 0.0651
K23848 L164_169 L33_38 0.1403
K23849 L164_169 L124_129 0.0554
K23850 L164_169 L78_83 0.0418
K23851 L164_169 L112_117 0.0336
K23852 L164_169 L183_187 0.068
K23853 L164_169 L59_63 0.0345
K23854 L164_169 L58_62 0.027
K23855 L164_169 L29_34 0.2296
K23856 L164_169 L179_183 0.0606
K23857 L164_169 L41_74 0.0501
K23858 L164_169 L131_170 0.0795
K23859 L164_169 L191_195 0.0251
K23860 L164_169 L66_70 0.0251
K23861 L164_169 L98_102 0.0351
K23862 L164_169 L27_32 0.1436
K23863 L164_169 L142_147 0.0381
K23864 L164_169 L3_8 0.0557
K23865 L164_169 L149_154 0.0365
K23866 L164_169 L117_122 0.0342
K23867 L164_169 L158_189 0.0922
K23868 L164_169 L38_43 0.0917
K23869 L164_169 L115_120 0.0625
K23870 L164_169 L80_85 0.0236
K23871 L164_169 L16_21 0.0705
K23872 L164_169 L158_163 0.189
K23873 L164_169 L96_100 0.0391
K23874 L164_169 L49_53 0.0493
K23875 L164_169 L82_87 0.0344
K23876 L164_169 L125_130 0.0719
K23877 L164_169 L84_89 0.0416
K23878 L164_169 L204_208 0.0298
K23879 L164_169 L202_206 0.042
K23880 L164_169 L44_92 0.0466
K23881 L164_169 L21_26 0.1068
K23882 L164_169 L74_79 0.047
K23883 L164_169 L165_170 0.1129
K23884 L164_169 L199_203 0.0241
K23885 L164_169 L75_80 0.0241
K23886 L164_169 L70_75 0.0246
K23887 L164_169 L50_54 0.0263
K23888 L164_169 L56_60 0.0417
K23889 L164_169 L90_94 0.0408
K23890 L164_169 L134_173 0.1013
K23891 L164_169 L139_144 0.0431
K23892 L164_169 L177_181 0.0589
K23893 L164_169 L111_116 0.0264
K23894 L164_169 L162_167 0.2076
K23895 L164_169 L43_91 0.0457
K23896 L164_169 L122_127 0.0346
K23897 L164_169 L39_44 0.0972
K23898 L164_169 L123_128 0.0427
K23899 L164_169 L12_17 0.0661
K23900 L164_169 L146_151 0.0418
K23901 L164_169 L61_65 0.0549
K23902 L1_6 L181_185 0.0803
K23903 L1_6 L35_40 0.0474
K23904 L1_6 L73_78 0.0415
K23905 L1_6 L163_168 0.0651
K23906 L1_6 L91_95 0.0292
K23907 L1_6 L4_9 0.0844
K23908 L1_6 L202_206 0.0394
K23909 L1_6 L109_114 0.1064
K23910 L1_6 L57_61 0.1051
K23911 L1_6 L158_189 0.0735
K23912 L1_6 L53_57 0.1086
K23913 L1_6 L69_73 0.0437
K23914 L1_6 L200_204 0.0325
K23915 L1_6 L145_150 0.0222
K23916 L1_6 L30_35 0.0582
K23917 L1_6 L46_50 0.039
K23918 L1_6 L196_200 0.0336
K23919 L1_6 L92_96 0.0287
K23920 L1_6 L19_24 0.0757
K23921 L1_6 L193_197 0.0391
K23922 L1_6 L7_12 0.1224
K23923 L1_6 L137_142 0.0296
K23924 L1_6 L167_172 0.0544
K23925 L1_6 L121_126 0.0381
K23926 L1_6 L113_118 0.0681
K23927 L1_6 L134_139 0.0301
K23928 L1_6 L33_38 0.0549
K23929 L1_6 L124_129 0.0977
K23930 L1_6 L78_83 0.0395
K23931 L1_6 L112_117 0.0503
K23932 L1_6 L40_45 0.0394
K23933 L1_6 L183_187 0.1056
K23934 L1_6 L59_63 0.0498
K23935 L1_6 L5_10 0.0622
K23936 L1_6 L15_20 0.0597
K23937 L1_6 L58_62 0.0383
K23938 L1_6 L29_34 0.066
K23939 L1_6 L179_183 0.1131
K23940 L1_6 L191_195 0.0276
K23941 L1_6 L66_70 0.0277
K23942 L1_6 L98_102 0.0267
K23943 L1_6 L27_32 0.0741
K23944 L1_6 L142_147 0.028
K23945 L1_6 L178_182 0.0604
K23946 L1_6 L3_8 0.1011
K23947 L1_6 L149_154 0.0259
K23948 L1_6 L117_122 0.05
K23949 L1_6 L38_43 0.0447
K23950 L1_6 L135_174 0.0392
K23951 L1_6 L80_85 0.0253
K23952 L1_6 L10_15 0.0615
K23953 L1_6 L158_163 0.082
K23954 L1_6 L96_100 0.0273
K23955 L1_6 L49_53 0.1098
K23956 L1_6 L186_190 0.0581
K23957 L1_6 L82_87 0.0348
K23958 L1_6 L159_164 0.0705
K23959 L1_6 L9_14 0.0833
K23960 L1_6 L204_208 0.0315
K23961 L1_6 L44_92 0.0303
K23962 L1_6 L199_203 0.026
K23963 L1_6 L75_80 0.0261
K23964 L1_6 L70_75 0.0269
K23965 L1_6 L50_54 0.0389
K23966 L1_6 L56_60 0.0681
K23967 L1_6 L93_97 0.0234
K23968 L1_6 L90_94 0.0297
K23969 L1_6 L134_173 0.0434
K23970 L1_6 L139_144 0.0286
K23971 L1_6 L177_181 0.0813
K23972 L1_6 L111_116 0.0387
K23973 L1_6 L162_167 0.069
K23974 L1_6 L43_91 0.0309
K23975 L1_6 L122_127 0.0495
K23976 L1_6 L39_44 0.0436
K23977 L1_6 L123_128 0.066
K23978 L1_6 L61_65 0.1002
K23979 L1_6 L12_17 0.1129
K23980 L1_2 L199_200 0.0184
K23981 L1_2 L115_179 0.1566
K23982 L1_2 L196_197 0.0213
K23983 L1_2 L23_24 0.0792
K23984 L1_2 L158_159 0.0694
K23985 L1_2 L163_164 0.0566
K23986 L1_2 L91_92 0.0192
K23987 L1_2 L126_127 0.0242
K23988 L1_2 L204_205 0.0198
K23989 L1_2 L153_154 0.0137
K23990 L1_2 L41_42 0.0257
K23991 L1_2 L200_201 0.0205
K23992 L1_2 L36_37 0.0342
K23993 L1_2 L131_132 0.0256
K23994 L1_2 L100_101 0.0171
K23995 L1_2 L92_93 0.0191
K23996 L1_2 L148_149 0.0172
K23997 L1_2 L19_20 0.0757
K23998 L1_2 L187_188 0.0879
K23999 L1_2 L160_161 0.0613
K24000 L1_2 L165_166 0.0437
K24001 L1_2 L193_194 0.0228
K24002 L1_2 L21_65 0.0649
K24003 L1_2 L121_122 0.0262
K24004 L1_2 L9_10 0.1036
K24005 L1_2 L134_135 0.0251
K24006 L1_2 L171_172 0.0338
K24007 L1_2 L104_105 0.0137
K24008 L1_2 L151_210 0.0209
K24009 L1_2 L112_113 0.0344
K24010 L1_2 L183_184 0.1117
K24011 L1_2 L59_60 0.0339
K24012 L1_2 L38_39 0.0338
K24013 L1_2 L96_97 0.018
K24014 L1_2 L78_79 0.0245
K24015 L1_2 L44_45 0.0253
K24016 L1_2 L29_30 0.058
K24017 L1_2 L76_77 0.0206
K24018 L1_2 L16_17 0.1028
K24019 L1_2 L6_53 0.0863
K24020 L1_2 L149_150 0.0171
K24021 L1_2 L98_99 0.0173
K24022 L1_2 L113_114 0.0487
K24023 L1_2 L80_81 0.018
K24024 L1_2 L87_88 0.0197
K24025 L1_2 L146_147 0.0173
K24026 L1_2 L127_128 0.0309
K24027 L1_2 L181_182 0.0915
K24028 L1_2 L28_29 0.0606
K24029 L1_2 L157_158 0.0752
K24030 L1_2 L129_130 0.0629
K24031 L1_2 L21_22 0.0863
K24032 L1_2 L117_118 0.0341
K24033 L1_2 L116_117 0.0265
K24034 L1_2 L7_8 0.2134
K24035 L1_2 L82_83 0.0217
K24036 L1_2 L58_59 0.0263
K24037 L1_2 L70_71 0.019
K24038 L1_2 L68_69 0.0229
K24039 L1_2 L89_102 0.0138
K24040 L1_2 L8_9 0.1437
K24041 L1_2 L50_51 0.0267
K24042 L1_2 L90_91 0.0193
K24043 L1_2 L139_140 0.019
K24044 L1_2 L111_112 0.0266
K24045 L1_2 L162_163 0.0591
K24046 L1_2 L137_138 0.0192
K24047 L1_2 L179_180 0.1426
K24048 L1_2 L12_13 0.1362
K24049 L1_2 L142_143 0.0182
K24050 L1_2 L123_124 0.0464
K24051 L1_2 L191_192 0.0181
K24052 L1_2 L39_40 0.0333
K24053 L1_2 L156_157 0.0794
K24054 L1_2 L201_202 0.0226
K24055 L158_159 L115_179 0.091
K24056 L158_159 L196_197 0.0312
K24057 L158_159 L163_164 0.1549
K24058 L158_159 L91_92 0.0335
K24059 L158_159 L160_161 0.1245
K24060 L158_159 L146_147 0.0292
K24061 L158_159 L204_205 0.0293
K24062 L158_159 L153_154 0.0235
K24063 L158_159 L4_5 0.081
K24064 L158_159 L41_42 0.0442
K24065 L158_159 L200_201 0.0303
K24066 L158_159 L36_37 0.0602
K24067 L158_159 L131_132 0.0446
K24068 L158_159 L100_101 0.0295
K24069 L158_159 L92_93 0.0335
K24070 L158_159 L148_149 0.0296
K24071 L158_159 L19_20 0.1644
K24072 L158_159 L187_188 0.1555
K24073 L158_159 L165_166 0.0828
K24074 L158_159 L8_9 0.1006
K24075 L158_159 L193_194 0.0344
K24076 L158_159 L121_122 0.0389
K24077 L158_159 L134_135 0.0458
K24078 L158_159 L171_172 0.0623
K24079 L158_159 L104_105 0.0234
K24080 L158_159 L151_210 0.0332
K24081 L158_159 L112_113 0.0483
K24082 L158_159 L183_184 0.1231
K24083 L158_159 L59_60 0.0498
K24084 L158_159 L38_39 0.0624
K24085 L158_159 L96_97 0.0314
K24086 L158_159 L78_79 0.0385
K24087 L158_159 L44_45 0.0454
K24088 L158_159 L47_48 0.0445
K24089 L158_159 L29_30 0.1425
K24090 L158_159 L76_77 0.0302
K24091 L158_159 L16_17 0.1153
K24092 L158_159 L6_53 0.0946
K24093 L158_159 L149_150 0.0297
K24094 L158_159 L98_99 0.0293
K24095 L158_159 L113_114 0.0656
K24096 L158_159 L80_81 0.026
K24097 L158_159 L87_88 0.0299
K24098 L158_159 L181_182 0.1104
K24099 L158_159 L28_29 0.1389
K24100 L158_159 L9_10 0.1029
K24101 L158_159 L117_118 0.0493
K24102 L158_159 L116_117 0.0385
K24103 L158_159 L7_8 0.0947
K24104 L158_159 L82_83 0.033
K24105 L158_159 L199_200 0.0267
K24106 L158_159 L58_59 0.0387
K24107 L158_159 L70_71 0.0272
K24108 L158_159 L68_69 0.0342
K24109 L158_159 L89_102 0.023
K24110 L158_159 L50_51 0.0378
K24111 L158_159 L90_91 0.0332
K24112 L158_159 L139_140 0.0338
K24113 L158_159 L111_112 0.038
K24114 L158_159 L162_163 0.1502
K24115 L158_159 L137_138 0.0334
K24116 L158_159 L179_180 0.1004
K24117 L158_159 L12_13 0.1128
K24118 L158_159 L142_143 0.0313
K24119 L158_159 L123_124 0.0705
K24120 L158_159 L191_192 0.0259
K24121 L158_159 L39_40 0.0627
K24122 L158_159 L201_202 0.0344
K24123 L35_40 L181_185 0.0466
K24124 L35_40 L73_78 0.0497
K24125 L35_40 L163_168 0.1634
K24126 L35_40 L91_95 0.0569
K24127 L35_40 L130_160 0.0772
K24128 L35_40 L4_9 0.0431
K24129 L35_40 L109_114 0.0436
K24130 L35_40 L57_61 0.0477
K24131 L35_40 L53_57 0.0457
K24132 L35_40 L69_73 0.0516
K24133 L35_40 L200_204 0.0324
K24134 L35_40 L131_136 0.0616
K24135 L35_40 L46_50 0.0246
K24136 L35_40 L196_200 0.033
K24137 L35_40 L92_96 0.0589
K24138 L35_40 L19_24 0.0589
K24139 L35_40 L120_125 0.0536
K24140 L35_40 L193_197 0.0407
K24141 L35_40 L7_12 0.0449
K24142 L35_40 L137_142 0.0534
K24143 L35_40 L167_172 0.1794
K24144 L35_40 L121_126 0.026
K24145 L35_40 L110_115 0.047
K24146 L35_40 L113_118 0.0376
K24147 L35_40 L134_139 0.0651
K24148 L35_40 L141_146 0.0536
K24149 L35_40 L9_14 0.0473
K24150 L35_40 L33_38 0.2076
K24151 L35_40 L124_129 0.0493
K24152 L35_40 L78_83 0.0477
K24153 L35_40 L112_117 0.0317
K24154 L35_40 L183_187 0.0485
K24155 L35_40 L59_63 0.0331
K24156 L35_40 L58_62 0.026
K24157 L35_40 L29_34 0.189
K24158 L35_40 L179_183 0.0443
K24159 L35_40 L41_74 0.0625
K24160 L35_40 L131_170 0.1068
K24161 L35_40 L191_195 0.0263
K24162 L35_40 L66_70 0.0264
K24163 L35_40 L98_102 0.0449
K24164 L35_40 L27_32 0.1278
K24165 L35_40 L142_147 0.0485
K24166 L35_40 L3_8 0.0423
K24167 L35_40 L149_154 0.0466
K24168 L35_40 L117_122 0.0324
K24169 L35_40 L158_189 0.0576
K24170 L35_40 L38_43 0.1538
K24171 L35_40 L115_120 0.0501
K24172 L35_40 L80_85 0.0251
K24173 L35_40 L16_21 0.0582
K24174 L35_40 L158_163 0.0972
K24175 L35_40 L96_100 0.0525
K24176 L35_40 L49_53 0.0438
K24177 L35_40 L82_87 0.0378
K24178 L35_40 L125_130 0.0574
K24179 L35_40 L84_89 0.0506
K24180 L35_40 L204_208 0.0317
K24181 L35_40 L202_206 0.0474
K24182 L35_40 L44_92 0.067
K24183 L35_40 L21_26 0.0795
K24184 L35_40 L74_79 0.0582
K24185 L35_40 L165_170 0.1257
K24186 L35_40 L199_203 0.0255
K24187 L35_40 L75_80 0.0256
K24188 L35_40 L70_75 0.026
K24189 L35_40 L50_54 0.0251
K24190 L35_40 L56_60 0.0389
K24191 L35_40 L90_94 0.0544
K24192 L35_40 L134_173 0.1634
K24193 L35_40 L139_144 0.0576
K24194 L35_40 L177_181 0.0426
K24195 L35_40 L111_116 0.0251
K24196 L35_40 L162_167 0.1403
K24197 L35_40 L43_91 0.0641
K24198 L35_40 L122_127 0.033
K24199 L35_40 L39_44 0.189
K24200 L35_40 L123_128 0.0397
K24201 L35_40 L12_17 0.0492
K24202 L35_40 L146_151 0.0501
K24203 L35_40 L61_65 0.0497
K24204 L73_78 L163_168 0.0488
K24205 L73_78 L91_95 0.0602
K24206 L73_78 L130_160 0.0431
K24207 L73_78 L4_9 0.0293
K24208 L73_78 L181_185 0.0305
K24209 L73_78 L9_14 0.0306
K24210 L73_78 L200_204 0.0734
K24211 L73_78 L145_150 0.0417
K24212 L73_78 L30_35 0.0438
K24213 L73_78 L131_136 0.1053
K24214 L73_78 L46_50 0.0337
K24215 L73_78 L196_200 0.0736
K24216 L73_78 L92_96 0.0546
K24217 L73_78 L19_24 0.0334
K24218 L73_78 L120_125 0.0458
K24219 L73_78 L193_197 0.1104
K24220 L73_78 L7_12 0.0324
K24221 L73_78 L137_142 0.0659
K24222 L73_78 L167_172 0.0592
K24223 L73_78 L121_126 0.0376
K24224 L73_78 L110_115 0.0413
K24225 L73_78 L113_118 0.0487
K24226 L73_78 L134_139 0.0537
K24227 L73_78 L141_146 0.1053
K24228 L73_78 L33_38 0.0597
K24229 L73_78 L112_117 0.0437
K24230 L73_78 L40_45 0.0554
K24231 L73_78 L183_187 0.0338
K24232 L73_78 L59_63 0.0476
K24233 L73_78 L5_10 0.0238
K24234 L73_78 L15_20 0.0258
K24235 L73_78 L58_62 0.0378
K24236 L73_78 L29_34 0.0491
K24237 L73_78 L179_183 0.0322
K24238 L73_78 L41_74 0.1086
K24239 L73_78 L131_170 0.0724
K24240 L73_78 L191_195 0.0554
K24241 L73_78 L66_70 0.0558
K24242 L73_78 L98_102 0.0654
K24243 L73_78 L27_32 0.0537
K24244 L73_78 L142_147 0.0655
K24245 L73_78 L178_182 0.0237
K24246 L73_78 L3_8 0.0301
K24247 L73_78 L149_154 0.0531
K24248 L73_78 L117_122 0.0455
K24249 L73_78 L158_189 0.0332
K24250 L73_78 L38_43 0.0686
K24251 L73_78 L135_174 0.0549
K24252 L73_78 L115_120 0.0435
K24253 L73_78 L80_85 0.0553
K24254 L73_78 L10_15 0.0248
K24255 L73_78 L16_21 0.0487
K24256 L73_78 L158_163 0.0427
K24257 L73_78 L96_100 0.0544
K24258 L73_78 L165_170 0.0608
K24259 L73_78 L186_190 0.0257
K24260 L73_78 L82_87 0.1103
K24261 L73_78 L125_130 0.0484
K24262 L73_78 L159_164 0.0384
K24263 L73_78 L84_89 0.1051
K24264 L73_78 L204_208 0.0726
K24265 L73_78 L44_92 0.0544
K24266 L73_78 L21_26 0.0434
K24267 L73_78 L74_79 0.1098
K24268 L73_78 L199_203 0.0554
K24269 L73_78 L75_80 0.0558
K24270 L73_78 L70_75 0.056
K24271 L73_78 L50_54 0.035
K24272 L73_78 L56_60 0.0515
K24273 L73_78 L93_97 0.0423
K24274 L73_78 L90_94 0.0671
K24275 L73_78 L134_173 0.0628
K24276 L73_78 L139_144 0.054
K24277 L73_78 L177_181 0.0292
K24278 L73_78 L111_116 0.0349
K24279 L73_78 L162_167 0.051
K24280 L73_78 L43_91 0.0599
K24281 L73_78 L122_127 0.0474
K24282 L73_78 L39_44 0.0634
K24283 L73_78 L123_128 0.054
K24284 L73_78 L12_17 0.034
K24285 L73_78 L146_151 0.1022
K24286 L163_164 L199_200 0.0307
K24287 L163_164 L115_179 0.0722
K24288 L163_164 L196_197 0.0363
K24289 L163_164 L23_24 0.1389
K24290 L163_164 L91_92 0.0416
K24291 L163_164 L126_127 0.0398
K24292 L163_164 L204_205 0.0342
K24293 L163_164 L153_154 0.0286
K24294 L163_164 L4_5 0.0613
K24295 L163_164 L41_42 0.0554
K24296 L163_164 L200_201 0.0353
K24297 L163_164 L50_51 0.0404
K24298 L163_164 L131_132 0.0559
K24299 L163_164 L100_101 0.0362
K24300 L163_164 L92_93 0.0417
K24301 L163_164 L148_149 0.0363
K24302 L163_164 L19_20 0.1055
K24303 L163_164 L187_188 0.1032
K24304 L163_164 L165_166 0.1122
K24305 L163_164 L8_9 0.0758
K24306 L163_164 L193_194 0.0407
K24307 L163_164 L21_65 0.1049
K24308 L163_164 L121_122 0.042
K24309 L163_164 L9_10 0.0766
K24310 L163_164 L134_135 0.0579
K24311 L163_164 L171_172 0.0811
K24312 L163_164 L104_105 0.0285
K24313 L163_164 L151_210 0.0397
K24314 L163_164 L112_113 0.0503
K24315 L163_164 L183_184 0.0875
K24316 L163_164 L59_60 0.0528
K24317 L163_164 L38_39 0.0811
K24318 L163_164 L78_79 0.0463
K24319 L163_164 L44_45 0.0572
K24320 L163_164 L47_48 0.0462
K24321 L163_164 L76_77 0.0352
K24322 L163_164 L16_17 0.0907
K24323 L163_164 L6_53 0.0845
K24324 L163_164 L149_150 0.0364
K24325 L163_164 L98_99 0.0359
K24326 L163_164 L113_114 0.0649
K24327 L163_164 L80_81 0.03
K24328 L163_164 L87_88 0.0352
K24329 L163_164 L146_147 0.0357
K24330 L163_164 L127_128 0.0509
K24331 L163_164 L181_182 0.079
K24332 L163_164 L157_158 0.1502
K24333 L163_164 L96_97 0.0387
K24334 L163_164 L129_130 0.1086
K24335 L163_164 L21_22 0.1183
K24336 L163_164 L117_118 0.0518
K24337 L163_164 L116_117 0.0413
K24338 L163_164 L7_8 0.0736
K24339 L163_164 L82_83 0.0389
K24340 L163_164 L58_59 0.0418
K24341 L163_164 L70_71 0.0314
K24342 L163_164 L68_69 0.0405
K24343 L163_164 L89_102 0.028
K24344 L163_164 L36_37 0.0773
K24345 L163_164 L90_91 0.0412
K24346 L163_164 L139_140 0.042
K24347 L163_164 L111_112 0.0405
K24348 L163_164 L137_138 0.0415
K24349 L163_164 L179_180 0.0757
K24350 L163_164 L12_13 0.0843
K24351 L163_164 L142_143 0.0386
K24352 L163_164 L123_124 0.0715
K24353 L163_164 L191_192 0.0298
K24354 L163_164 L39_40 0.0817
K24355 L163_164 L156_157 0.1386
K24356 L163_164 L201_202 0.0407
K24357 L28_29 L199_200 0.0317
K24358 L28_29 L115_179 0.0736
K24359 L28_29 L196_197 0.0376
K24360 L28_29 L23_24 0.1549
K24361 L28_29 L91_92 0.042
K24362 L28_29 L126_127 0.0419
K24363 L28_29 L204_205 0.0353
K24364 L28_29 L153_154 0.0285
K24365 L28_29 L4_5 0.0624
K24366 L28_29 L41_42 0.057
K24367 L28_29 L200_201 0.0364
K24368 L28_29 L50_51 0.0426
K24369 L28_29 L131_132 0.0564
K24370 L28_29 L100_101 0.0363
K24371 L28_29 L92_93 0.0419
K24372 L28_29 L148_149 0.0362
K24373 L28_29 L19_20 0.1098
K24374 L28_29 L187_188 0.1035
K24375 L28_29 L165_166 0.1153
K24376 L28_29 L8_9 0.079
K24377 L28_29 L193_194 0.0421
K24378 L28_29 L21_65 0.1237
K24379 L28_29 L121_122 0.0441
K24380 L28_29 L9_10 0.0781
K24381 L28_29 L134_135 0.057
K24382 L28_29 L171_172 0.0811
K24383 L28_29 L104_105 0.0286
K24384 L28_29 L151_210 0.0406
K24385 L28_29 L112_113 0.053
K24386 L28_29 L183_184 0.0876
K24387 L28_29 L59_60 0.0569
K24388 L28_29 L38_39 0.0832
K24389 L28_29 L78_79 0.048
K24390 L28_29 L44_45 0.0577
K24391 L28_29 L47_48 0.0493
K24392 L28_29 L76_77 0.0365
K24393 L28_29 L16_17 0.1032
K24394 L28_29 L6_53 0.0921
K24395 L28_29 L149_150 0.0361
K24396 L28_29 L98_99 0.0363
K24397 L28_29 L113_114 0.0687
K24398 L28_29 L80_81 0.031
K24399 L28_29 L87_88 0.0365
K24400 L28_29 L146_147 0.0359
K24401 L28_29 L127_128 0.0543
K24402 L28_29 L181_182 0.0758
K24403 L28_29 L157_158 0.1425
K24404 L28_29 L96_97 0.0389
K24405 L28_29 L129_130 0.1182
K24406 L28_29 L21_22 0.1386
K24407 L28_29 L117_118 0.0548
K24408 L28_29 L116_117 0.0433
K24409 L28_29 L7_8 0.0781
K24410 L28_29 L82_83 0.0404
K24411 L28_29 L58_59 0.0443
K24412 L28_29 L70_71 0.0326
K24413 L28_29 L68_69 0.0424
K24414 L28_29 L89_102 0.0285
K24415 L28_29 L36_37 0.0811
K24416 L28_29 L90_91 0.0419
K24417 L28_29 L139_140 0.0416
K24418 L28_29 L111_112 0.0424
K24419 L28_29 L137_138 0.0416
K24420 L28_29 L179_180 0.0758
K24421 L28_29 L12_13 0.0913
K24422 L28_29 L142_143 0.0386
K24423 L28_29 L123_124 0.0767
K24424 L28_29 L191_192 0.0308
K24425 L28_29 L39_40 0.0827
K24426 L28_29 L156_157 0.1389
K24427 L28_29 L201_202 0.0419
K24428 L163_168 L91_95 0.0459
K24429 L163_168 L130_160 0.1398
K24430 L163_168 L202_206 0.0469
K24431 L163_168 L109_114 0.0562
K24432 L163_168 L57_61 0.0606
K24433 L163_168 L53_57 0.0582
K24434 L163_168 L69_73 0.0511
K24435 L163_168 L200_204 0.034
K24436 L163_168 L145_150 0.0424
K24437 L163_168 L30_35 0.2296
K24438 L163_168 L131_136 0.0568
K24439 L163_168 L46_50 0.029
K24440 L163_168 L196_200 0.0348
K24441 L163_168 L120_125 0.0774
K24442 L163_168 L193_197 0.0424
K24443 L163_168 L7_12 0.0668
K24444 L163_168 L137_142 0.0455
K24445 L163_168 L167_172 0.1944
K24446 L163_168 L121_126 0.0304
K24447 L163_168 L110_115 0.066
K24448 L163_168 L141_146 0.0495
K24449 L163_168 L122_127 0.0389
K24450 L163_168 L33_38 0.1706
K24451 L163_168 L124_129 0.0634
K24452 L163_168 L78_83 0.0466
K24453 L163_168 L112_117 0.0377
K24454 L163_168 L40_45 0.0972
K24455 L163_168 L183_187 0.0779
K24456 L163_168 L59_63 0.0387
K24457 L163_168 L5_10 0.0671
K24458 L163_168 L15_20 0.0934
K24459 L163_168 L58_62 0.0303
K24460 L163_168 L179_183 0.0685
K24461 L163_168 L41_74 0.0562
K24462 L163_168 L131_170 0.0915
K24463 L163_168 L191_195 0.028
K24464 L163_168 L98_102 0.0385
K24465 L163_168 L27_32 0.1838
K24466 L163_168 L178_182 0.0697
K24467 L163_168 L3_8 0.0619
K24468 L163_168 L66_70 0.028
K24469 L163_168 L117_122 0.0383
K24470 L163_168 L38_43 0.1038
K24471 L163_168 L135_174 0.1013
K24472 L163_168 L115_120 0.0714
K24473 L163_168 L80_85 0.0262
K24474 L163_168 L10_15 0.0784
K24475 L163_168 L16_21 0.082
K24476 L163_168 L113_118 0.0462
K24477 L163_168 L49_53 0.0558
K24478 L163_168 L186_190 0.1012
K24479 L163_168 L125_130 0.0838
K24480 L163_168 L159_164 0.189
K24481 L163_168 L84_89 0.0461
K24482 L163_168 L204_208 0.0331
K24483 L163_168 L82_87 0.0383
K24484 L163_168 L21_26 0.1298
K24485 L163_168 L74_79 0.0524
K24486 L163_168 L165_170 0.1398
K24487 L163_168 L199_203 0.0269
K24488 L163_168 L75_80 0.0268
K24489 L163_168 L70_75 0.0274
K24490 L163_168 L50_54 0.0295
K24491 L163_168 L56_60 0.0471
K24492 L163_168 L93_97 0.0463
K24493 L163_168 L90_94 0.045
K24494 L163_168 L111_116 0.0296
K24495 L163_168 L162_167 0.2991
K24496 L163_168 L43_91 0.0503
K24497 L163_168 L142_147 0.0419
K24498 L163_168 L123_128 0.0484
K24499 L163_168 L12_17 0.0754
K24500 L163_168 L146_151 0.0464
K24501 L163_168 L61_65 0.0628
K24502 L130_160 L181_185 0.1247
K24503 L130_160 L91_95 0.0389
K24504 L130_160 L4_9 0.1012
K24505 L130_160 L202_206 0.0411
K24506 L130_160 L109_114 0.0735
K24507 L130_160 L57_61 0.0795
K24508 L130_160 L158_189 0.1427
K24509 L130_160 L53_57 0.0761
K24510 L130_160 L69_73 0.0455
K24511 L130_160 L200_204 0.0319
K24512 L130_160 L145_150 0.0292
K24513 L130_160 L30_35 0.1068
K24514 L130_160 L46_50 0.0321
K24515 L130_160 L196_200 0.0328
K24516 L130_160 L92_96 0.0382
K24517 L130_160 L19_24 0.1272
K24518 L130_160 L193_197 0.0395
K24519 L130_160 L7_12 0.1665
K24520 L130_160 L137_142 0.0397
K24521 L130_160 L167_172 0.0983
K24522 L130_160 L121_126 0.0333
K24523 L130_160 L113_118 0.0549
K24524 L130_160 L134_139 0.0418
K24525 L130_160 L33_38 0.0946
K24526 L130_160 L124_129 0.0839
K24527 L130_160 L78_83 0.0409
K24528 L130_160 L112_117 0.0422
K24529 L130_160 L40_45 0.0571
K24530 L130_160 L183_187 0.2987
K24531 L130_160 L59_63 0.0429
K24532 L130_160 L5_10 0.0748
K24533 L130_160 L15_20 0.0873
K24534 L130_160 L58_62 0.0332
K24535 L130_160 L29_34 0.1298
K24536 L130_160 L179_183 0.2195
K24537 L130_160 L191_195 0.0268
K24538 L130_160 L66_70 0.0267
K24539 L130_160 L98_102 0.0338
K24540 L130_160 L27_32 0.1747
K24541 L130_160 L142_147 0.0367
K24542 L130_160 L178_182 0.0791
K24543 L130_160 L3_8 0.1175
K24544 L130_160 L149_154 0.0333
K24545 L130_160 L117_122 0.0427
K24546 L130_160 L38_43 0.0658
K24547 L130_160 L135_174 0.058
K24548 L130_160 L80_85 0.0245
K24549 L130_160 L10_15 0.082
K24550 L130_160 L158_163 0.1786
K24551 L130_160 L96_100 0.0354
K24552 L130_160 L49_53 0.0724
K24553 L130_160 L186_190 0.0941
K24554 L130_160 L82_87 0.0348
K24555 L130_160 L159_164 0.1357
K24556 L130_160 L9_14 0.1137
K24557 L130_160 L204_208 0.0309
K24558 L130_160 L44_92 0.0413
K24559 L130_160 L199_203 0.0253
K24560 L130_160 L75_80 0.0253
K24561 L130_160 L70_75 0.026
K24562 L130_160 L50_54 0.0325
K24563 L130_160 L56_60 0.0556
K24564 L130_160 L93_97 0.0311
K24565 L130_160 L90_94 0.0393
K24566 L130_160 L134_173 0.0648
K24567 L130_160 L139_144 0.0385
K24568 L130_160 L177_181 0.1087
K24569 L130_160 L111_116 0.0327
K24570 L130_160 L162_167 0.17
K24571 L130_160 L43_91 0.0422
K24572 L130_160 L122_127 0.0431
K24573 L130_160 L39_44 0.0637
K24574 L130_160 L123_128 0.057
K24575 L130_160 L61_65 0.0822
K24576 L130_160 L12_17 0.1975
K24577 L153_154 L115_179 0.0168
K24578 L153_154 L196_197 0.036
K24579 L153_154 L23_24 0.0234
K24580 L153_154 L91_92 0.0811
K24581 L153_154 L160_161 0.0285
K24582 L153_154 L126_127 0.0187
K24583 L153_154 L204_205 0.0373
K24584 L153_154 L4_5 0.0138
K24585 L153_154 L41_42 0.06
K24586 L153_154 L200_201 0.0368
K24587 L153_154 L36_37 0.0449
K24588 L153_154 L131_132 0.0621
K24589 L153_154 L100_101 0.1266
K24590 L153_154 L92_93 0.0789
K24591 L153_154 L148_149 0.1916
K24592 L153_154 L19_20 0.0187
K24593 L153_154 L187_188 0.0188
K24594 L153_154 L165_166 0.0351
K24595 L153_154 L8_9 0.0168
K24596 L153_154 L193_194 0.0469
K24597 L153_154 L21_65 0.0253
K24598 L153_154 L121_122 0.0193
K24599 L153_154 L9_10 0.0168
K24600 L153_154 L134_135 0.0644
K24601 L153_154 L171_172 0.0463
K24602 L153_154 L112_113 0.02
K24603 L153_154 L183_184 0.0178
K24604 L153_154 L59_60 0.0214
K24605 L153_154 L38_39 0.0459
K24606 L153_154 L78_79 0.0862
K24607 L153_154 L44_45 0.0622
K24608 L153_154 L47_48 0.0184
K24609 L153_154 L29_30 0.0285
K24610 L153_154 L76_77 0.0365
K24611 L153_154 L16_17 0.0186
K24612 L153_154 L181_182 0.0169
K24613 L153_154 L6_53 0.0229
K24614 L153_154 L149_150 0.1673
K24615 L153_154 L98_99 0.1266
K24616 L153_154 L113_114 0.0217
K24617 L153_154 L80_81 0.0281
K24618 L153_154 L146_147 0.1268
K24619 L153_154 L127_128 0.021
K24620 L153_154 L157_158 0.0235
K24621 L153_154 L96_97 0.0988
K24622 L153_154 L129_130 0.0254
K24623 L153_154 L117_118 0.0207
K24624 L153_154 L116_117 0.0187
K24625 L153_154 L21_22 0.0232
K24626 L153_154 L7_8 0.0168
K24627 L153_154 L82_83 0.0537
K24628 L153_154 L199_200 0.0281
K24629 L153_154 L58_59 0.0192
K24630 L153_154 L70_71 0.0276
K24631 L153_154 L68_69 0.0461
K24632 L153_154 L50_51 0.0181
K24633 L153_154 L90_91 0.0789
K24634 L153_154 L139_140 0.0861
K24635 L153_154 L111_112 0.0182
K24636 L153_154 L162_163 0.0287
K24637 L153_154 L137_138 0.0861
K24638 L153_154 L179_180 0.0169
K24639 L153_154 L12_13 0.0177
K24640 L153_154 L142_143 0.1144
K24641 L153_154 L123_124 0.0237
K24642 L153_154 L191_192 0.0258
K24643 L153_154 L39_40 0.0456
K24644 L153_154 L156_157 0.0235
K24645 L153_154 L201_202 0.0531
K24646 L204_208 L181_185 0.0227
K24647 L204_208 L91_95 0.0328
K24648 L204_208 L4_9 0.0221
K24649 L204_208 L202_206 0.0741
K24650 L204_208 L109_114 0.039
K24651 L204_208 L57_61 0.042
K24652 L204_208 L9_14 0.0227
K24653 L204_208 L53_57 0.0404
K24654 L204_208 L69_73 0.0713
K24655 L204_208 L145_150 0.025
K24656 L204_208 L30_35 0.0297
K24657 L204_208 L131_136 0.0498
K24658 L204_208 L46_50 0.0365
K24659 L204_208 L92_96 0.0311
K24660 L204_208 L19_24 0.0239
K24661 L204_208 L120_125 0.0336
K24662 L204_208 L193_197 0.1057
K24663 L204_208 L7_12 0.024
K24664 L204_208 L137_142 0.0349
K24665 L204_208 L167_172 0.0371
K24666 L204_208 L121_126 0.043
K24667 L204_208 L110_115 0.0315
K24668 L204_208 L141_146 0.0506
K24669 L204_208 L33_38 0.0369
K24670 L204_208 L124_129 0.0439
K24671 L204_208 L78_83 0.0734
K24672 L204_208 L134_139 0.031
K24673 L204_208 L40_45 0.0335
K24674 L204_208 L183_187 0.0247
K24675 L204_208 L5_10 0.0179
K24676 L204_208 L15_20 0.0189
K24677 L204_208 L58_62 0.0427
K24678 L204_208 L29_34 0.0331
K24679 L204_208 L179_183 0.024
K24680 L204_208 L158_189 0.0239
K24681 L204_208 L41_74 0.0495
K24682 L204_208 L131_170 0.0399
K24683 L204_208 L191_195 0.1273
K24684 L204_208 L66_70 0.1215
K24685 L204_208 L98_102 0.0349
K24686 L204_208 L27_32 0.0355
K24687 L204_208 L178_182 0.018
K24688 L204_208 L3_8 0.0227
K24689 L204_208 L149_154 0.0314
K24690 L204_208 L38_43 0.0394
K24691 L204_208 L113_118 0.0444
K24692 L204_208 L135_174 0.0336
K24693 L204_208 L115_120 0.0326
K24694 L204_208 L80_85 0.1437
K24695 L204_208 L10_15 0.0184
K24696 L204_208 L16_21 0.0347
K24697 L204_208 L158_163 0.0307
K24698 L204_208 L96_100 0.0312
K24699 L204_208 L49_53 0.0389
K24700 L204_208 L186_190 0.0189
K24701 L204_208 L82_87 0.1114
K24702 L204_208 L125_130 0.0348
K24703 L204_208 L159_164 0.0277
K24704 L204_208 L84_89 0.0504
K24705 L204_208 L44_92 0.0309
K24706 L204_208 L21_26 0.0308
K24707 L204_208 L74_79 0.05
K24708 L204_208 L165_170 0.0369
K24709 L204_208 L199_203 0.1506
K24710 L204_208 L75_80 0.1405
K24711 L204_208 L70_75 0.1322
K24712 L204_208 L50_54 0.0384
K24713 L204_208 L56_60 0.0464
K24714 L204_208 L93_97 0.0248
K24715 L204_208 L90_94 0.0347
K24716 L204_208 L134_173 0.0377
K24717 L204_208 L139_144 0.0312
K24718 L204_208 L177_181 0.0221
K24719 L204_208 L111_116 0.0385
K24720 L204_208 L162_167 0.0344
K24721 L204_208 L43_91 0.0325
K24722 L204_208 L142_147 0.0351
K24723 L204_208 L39_44 0.0376
K24724 L204_208 L123_128 0.0489
K24725 L204_208 L12_17 0.0247
K24726 L204_208 L146_151 0.0507
K24727 L204_208 L61_65 0.0437
K24728 L204_205 L199_200 0.1933
K24729 L204_205 L115_179 0.0242
K24730 L204_205 L196_197 0.2392
K24731 L204_205 L23_24 0.0302
K24732 L204_205 L91_92 0.0357
K24733 L204_205 L160_161 0.0378
K24734 L204_205 L126_127 0.0451
K24735 L204_205 L4_5 0.0184
K24736 L204_205 L41_42 0.0468
K24737 L204_205 L200_201 0.3334
K24738 L204_205 L36_37 0.0468
K24739 L204_205 L131_132 0.0472
K24740 L204_205 L92_93 0.0336
K24741 L204_205 L19_20 0.0238
K24742 L204_205 L187_188 0.0252
K24743 L204_205 L8_9 0.0229
K24744 L204_205 L193_194 0.1475
K24745 L204_205 L21_65 0.0414
K24746 L204_205 L121_122 0.045
K24747 L204_205 L9_10 0.0224
K24748 L204_205 L134_135 0.0395
K24749 L204_205 L171_172 0.0448
K24750 L204_205 L104_105 0.0343
K24751 L204_205 L151_210 0.0934
K24752 L204_205 L112_113 0.0414
K24753 L204_205 L183_184 0.0244
K24754 L204_205 L59_60 0.046
K24755 L204_205 L38_39 0.0424
K24756 L204_205 L96_97 0.0339
K24757 L204_205 L78_79 0.0969
K24758 L204_205 L44_45 0.0393
K24759 L204_205 L47_48 0.038
K24760 L204_205 L29_30 0.0341
K24761 L204_205 L76_77 0.2659
K24762 L204_205 L16_17 0.0259
K24763 L204_205 L6_53 0.0381
K24764 L204_205 L113_114 0.0405
K24765 L204_205 L87_88 0.1674
K24766 L204_205 L127_128 0.0465
K24767 L204_205 L181_182 0.0224
K24768 L204_205 L157_158 0.0302
K24769 L204_205 L129_130 0.0416
K24770 L204_205 L21_22 0.032
K24771 L204_205 L117_118 0.0437
K24772 L204_205 L116_117 0.0427
K24773 L204_205 L7_8 0.0235
K24774 L204_205 L58_59 0.0448
K24775 L204_205 L70_71 0.1537
K24776 L204_205 L68_69 0.1387
K24777 L204_205 L89_102 0.0438
K24778 L204_205 L50_51 0.0404
K24779 L204_205 L165_166 0.0423
K24780 L204_205 L90_91 0.038
K24781 L204_205 L139_140 0.0338
K24782 L204_205 L111_112 0.0405
K24783 L204_205 L162_163 0.0354
K24784 L204_205 L137_138 0.0383
K24785 L204_205 L179_180 0.0236
K24786 L204_205 L12_13 0.0243
K24787 L204_205 L142_143 0.0387
K24788 L204_205 L123_124 0.045
K24789 L204_205 L191_192 0.1475
K24790 L204_205 L39_40 0.0405
K24791 L204_205 L156_157 0.0312
K24792 L204_205 L201_202 0.1933
K24793 L30_35 L181_185 0.0651
K24794 L30_35 L91_95 0.0423
K24795 L30_35 L4_9 0.0589
K24796 L30_35 L109_114 0.0493
K24797 L30_35 L57_61 0.0536
K24798 L30_35 L53_57 0.0516
K24799 L30_35 L69_73 0.0457
K24800 L30_35 L200_204 0.0304
K24801 L30_35 L131_136 0.0501
K24802 L30_35 L46_50 0.026
K24803 L30_35 L196_200 0.0311
K24804 L30_35 L92_96 0.0431
K24805 L30_35 L19_24 0.0922
K24806 L30_35 L120_125 0.066
K24807 L30_35 L193_197 0.0376
K24808 L30_35 L7_12 0.0606
K24809 L30_35 L137_142 0.0408
K24810 L30_35 L167_172 0.1403
K24811 L30_35 L121_126 0.027
K24812 L30_35 L110_115 0.0574
K24813 L30_35 L113_118 0.0407
K24814 L30_35 L134_139 0.0466
K24815 L30_35 L141_146 0.0441
K24816 L30_35 L9_14 0.067
K24817 L30_35 L33_38 0.1538
K24818 L30_35 L124_129 0.0549
K24819 L30_35 L78_83 0.042
K24820 L30_35 L112_117 0.0335
K24821 L30_35 L183_187 0.0661
K24822 L30_35 L59_63 0.0346
K24823 L30_35 L58_62 0.0271
K24824 L30_35 L29_34 0.305
K24825 L30_35 L179_183 0.0592
K24826 L30_35 L41_74 0.0506
K24827 L30_35 L131_170 0.0772
K24828 L30_35 L191_195 0.0251
K24829 L30_35 L66_70 0.0251
K24830 L30_35 L98_102 0.0354
K24831 L30_35 L27_32 0.1566
K24832 L30_35 L142_147 0.0377
K24833 L30_35 L3_8 0.0569
K24834 L30_35 L149_154 0.0362
K24835 L30_35 L117_122 0.034
K24836 L30_35 L158_189 0.0874
K24837 L30_35 L38_43 0.095
K24838 L30_35 L115_120 0.0616
K24839 L30_35 L80_85 0.0236
K24840 L30_35 L16_21 0.0719
K24841 L30_35 L158_163 0.1634
K24842 L30_35 L96_100 0.0395
K24843 L30_35 L49_53 0.0497
K24844 L30_35 L82_87 0.0345
K24845 L30_35 L125_130 0.0705
K24846 L30_35 L84_89 0.0418
K24847 L30_35 L202_206 0.0418
K24848 L30_35 L44_92 0.0473
K24849 L30_35 L21_26 0.1129
K24850 L30_35 L74_79 0.0474
K24851 L30_35 L165_170 0.1068
K24852 L30_35 L199_203 0.0241
K24853 L30_35 L75_80 0.0241
K24854 L30_35 L70_75 0.0246
K24855 L30_35 L50_54 0.0264
K24856 L30_35 L56_60 0.0419
K24857 L30_35 L90_94 0.0412
K24858 L30_35 L134_173 0.0972
K24859 L30_35 L139_144 0.0426
K24860 L30_35 L177_181 0.0576
K24861 L30_35 L111_116 0.0263
K24862 L30_35 L162_167 0.1794
K24863 L30_35 L43_91 0.0463
K24864 L30_35 L122_127 0.0345
K24865 L30_35 L39_44 0.1013
K24866 L30_35 L123_128 0.0425
K24867 L30_35 L12_17 0.068
K24868 L30_35 L146_151 0.0416
K24869 L30_35 L61_65 0.0554
K24870 L181_182 L199_200 0.0207
K24871 L181_182 L196_197 0.0238
K24872 L181_182 L23_24 0.1006
K24873 L181_182 L91_92 0.0235
K24874 L181_182 L160_161 0.0722
K24875 L181_182 L126_127 0.0253
K24876 L181_182 L4_5 0.1566
K24877 L181_182 L41_42 0.0308
K24878 L181_182 L200_201 0.0231
K24879 L181_182 L131_132 0.031
K24880 L181_182 L100_101 0.0211
K24881 L181_182 L92_93 0.0236
K24882 L181_182 L148_149 0.0212
K24883 L181_182 L19_20 0.1173
K24884 L181_182 L187_188 0.1124
K24885 L181_182 L165_166 0.0524
K24886 L181_182 L193_194 0.0256
K24887 L181_182 L21_65 0.0563
K24888 L181_182 L121_122 0.0273
K24889 L181_182 L134_135 0.0316
K24890 L181_182 L171_172 0.0415
K24891 L181_182 L104_105 0.0168
K24892 L181_182 L151_210 0.0244
K24893 L181_182 L183_184 0.1439
K24894 L181_182 L59_60 0.0336
K24895 L181_182 L38_39 0.0416
K24896 L181_182 L96_97 0.0223
K24897 L181_182 L78_79 0.0282
K24898 L181_182 L44_45 0.0314
K24899 L181_182 L47_48 0.0387
K24900 L181_182 L29_30 0.0766
K24901 L181_182 L76_77 0.023
K24902 L181_182 L16_17 0.0884
K24903 L181_182 L149_150 0.0212
K24904 L181_182 L98_99 0.021
K24905 L181_182 L80_81 0.0201
K24906 L181_182 L87_88 0.0224
K24907 L181_182 L146_147 0.0209
K24908 L181_182 L127_128 0.0312
K24909 L181_182 L157_158 0.1076
K24910 L181_182 L129_130 0.0573
K24911 L181_182 L21_22 0.0868
K24912 L181_182 L117_118 0.0341
K24913 L181_182 L116_117 0.0275
K24914 L181_182 L82_83 0.0247
K24915 L181_182 L58_59 0.0272
K24916 L181_182 L70_71 0.0211
K24917 L181_182 L68_69 0.0256
K24918 L181_182 L89_102 0.0166
K24919 L181_182 L36_37 0.0406
K24920 L181_182 L90_91 0.0234
K24921 L181_182 L139_140 0.0237
K24922 L181_182 L162_163 0.0781
K24923 L181_182 L137_138 0.0235
K24924 L181_182 L12_13 0.1226
K24925 L181_182 L142_143 0.0222
K24926 L181_182 L123_124 0.0442
K24927 L181_182 L191_192 0.0201
K24928 L181_182 L39_40 0.0417
K24929 L181_182 L156_157 0.1004
K24930 L181_182 L201_202 0.0257
K24931 L100_101 L199_200 0.032
K24932 L100_101 L115_179 0.0209
K24933 L100_101 L196_197 0.0407
K24934 L100_101 L23_24 0.0296
K24935 L100_101 L91_92 0.1284
K24936 L100_101 L160_161 0.0355
K24937 L100_101 L126_127 0.0223
K24938 L100_101 L4_5 0.0173
K24939 L100_101 L41_42 0.0785
K24940 L100_101 L200_201 0.0413
K24941 L100_101 L36_37 0.0578
K24942 L100_101 L131_132 0.0757
K24943 L100_101 L92_93 0.1354
K24944 L100_101 L19_20 0.0237
K24945 L100_101 L187_188 0.0234
K24946 L100_101 L8_9 0.0212
K24947 L100_101 L193_194 0.0522
K24948 L100_101 L21_65 0.0315
K24949 L100_101 L121_122 0.0231
K24950 L100_101 L9_10 0.0212
K24951 L100_101 L134_135 0.0857
K24952 L100_101 L171_172 0.0585
K24953 L100_101 L104_105 0.1916
K24954 L100_101 L151_210 0.0604
K24955 L100_101 L112_113 0.0241
K24956 L100_101 L183_184 0.0221
K24957 L100_101 L59_60 0.026
K24958 L100_101 L38_39 0.0606
K24959 L100_101 L96_97 0.2054
K24960 L100_101 L78_79 0.0996
K24961 L100_101 L44_45 0.0898
K24962 L100_101 L47_48 0.0224
K24963 L100_101 L29_30 0.0364
K24964 L100_101 L76_77 0.0416
K24965 L100_101 L16_17 0.0233
K24966 L100_101 L6_53 0.0285
K24967 L100_101 L113_114 0.0264
K24968 L100_101 L87_88 0.042
K24969 L100_101 L127_128 0.0253
K24970 L100_101 L157_158 0.0294
K24971 L100_101 L129_130 0.0313
K24972 L100_101 L21_22 0.0292
K24973 L100_101 L117_118 0.025
K24974 L100_101 L116_117 0.0224
K24975 L100_101 L7_8 0.0211
K24976 L100_101 L58_59 0.0231
K24977 L100_101 L70_71 0.0319
K24978 L100_101 L68_69 0.053
K24979 L100_101 L89_102 0.0968
K24980 L100_101 L50_51 0.0218
K24981 L100_101 L165_166 0.0438
K24982 L100_101 L90_91 0.1124
K24983 L100_101 L139_140 0.1173
K24984 L100_101 L111_112 0.0218
K24985 L100_101 L162_163 0.0361
K24986 L100_101 L137_138 0.1015
K24987 L100_101 L179_180 0.021
K24988 L100_101 L12_13 0.0222
K24989 L100_101 L142_143 0.1226
K24990 L100_101 L123_124 0.0288
K24991 L100_101 L191_192 0.0295
K24992 L100_101 L39_40 0.061
K24993 L100_101 L156_157 0.0293
K24994 L100_101 L201_202 0.0579
K24995 L141_146 L181_185 0.0287
K24996 L141_146 L91_95 0.0941
K24997 L141_146 L4_9 0.0272
K24998 L141_146 L202_206 0.1098
K24999 L141_146 L109_114 0.0395
K25000 L141_146 L57_61 0.0435
K25001 L141_146 L158_189 0.032
K25002 L141_146 L53_57 0.0413
K25003 L141_146 L69_73 0.1022
K25004 L141_146 L200_204 0.0507
K25005 L141_146 L145_150 0.0622
K25006 L141_146 L46_50 0.026
K25007 L141_146 L196_200 0.0506
K25008 L141_146 L92_96 0.0803
K25009 L141_146 L19_24 0.0319
K25010 L141_146 L193_197 0.0681
K25011 L141_146 L7_12 0.0296
K25012 L141_146 L137_142 0.1224
K25013 L141_146 L167_172 0.0643
K25014 L141_146 L121_126 0.0286
K25015 L141_146 L113_118 0.0377
K25016 L141_146 L134_139 0.0802
K25017 L141_146 L33_38 0.0635
K25018 L141_146 L124_129 0.046
K25019 L141_146 L78_83 0.1064
K25020 L141_146 L112_117 0.0336
K25021 L141_146 L40_45 0.066
K25022 L141_146 L183_187 0.0314
K25023 L141_146 L59_63 0.0358
K25024 L141_146 L5_10 0.0222
K25025 L141_146 L15_20 0.0246
K25026 L141_146 L58_62 0.0285
K25027 L141_146 L29_34 0.0491
K25028 L141_146 L179_183 0.0297
K25029 L141_146 L191_195 0.0387
K25030 L141_146 L66_70 0.0385
K25031 L141_146 L98_102 0.1131
K25032 L141_146 L27_32 0.0521
K25033 L141_146 L142_147 0.1262
K25034 L141_146 L178_182 0.0223
K25035 L141_146 L3_8 0.0276
K25036 L141_146 L149_154 0.0833
K25037 L141_146 L117_122 0.0348
K25038 L141_146 L38_43 0.0823
K25039 L141_146 L135_174 0.0671
K25040 L141_146 L80_85 0.0387
K25041 L141_146 L10_15 0.0234
K25042 L141_146 L158_163 0.0411
K25043 L141_146 L96_100 0.0813
K25044 L141_146 L49_53 0.0394
K25045 L141_146 L186_190 0.0247
K25046 L141_146 L82_87 0.0681
K25047 L141_146 L159_164 0.0373
K25048 L141_146 L9_14 0.0286
K25049 L141_146 L44_92 0.0775
K25050 L141_146 L199_203 0.039
K25051 L141_146 L75_80 0.0388
K25052 L141_146 L70_75 0.0387
K25053 L141_146 L50_54 0.0268
K25054 L141_146 L56_60 0.0391
K25055 L141_146 L93_97 0.0598
K25056 L141_146 L90_94 0.1131
K25057 L141_146 L134_173 0.0774
K25058 L141_146 L139_144 0.0833
K25059 L141_146 L177_181 0.0273
K25060 L141_146 L111_116 0.0269
K25061 L141_146 L162_167 0.0511
K25062 L141_146 L43_91 0.0897
K25063 L141_146 L122_127 0.0359
K25064 L141_146 L39_44 0.0759
K25065 L141_146 L123_128 0.041
K25066 L141_146 L61_65 0.0458
K25067 L141_146 L12_17 0.0313
K25068 L181_185 L91_95 0.0248
K25069 L181_185 L202_206 0.0293
K25070 L181_185 L109_114 0.0544
K25071 L181_185 L57_61 0.0537
K25072 L181_185 L53_57 0.054
K25073 L181_185 L69_73 0.0318
K25074 L181_185 L200_204 0.0233
K25075 L181_185 L145_150 0.0195
K25076 L181_185 L131_136 0.032
K25077 L181_185 L46_50 0.0243
K25078 L181_185 L196_200 0.0239
K25079 L181_185 L120_125 0.0833
K25080 L181_185 L193_197 0.028
K25081 L181_185 L7_12 0.1173
K25082 L181_185 L137_142 0.0247
K25083 L181_185 L167_172 0.0633
K25084 L181_185 L121_126 0.0243
K25085 L181_185 L110_115 0.0833
K25086 L181_185 L122_127 0.0312
K25087 L181_185 L33_38 0.0619
K25088 L181_185 L124_129 0.0537
K25089 L181_185 L78_83 0.0292
K25090 L181_185 L112_117 0.0314
K25091 L181_185 L40_45 0.0362
K25092 L181_185 L183_187 0.1284
K25093 L181_185 L59_63 0.0311
K25094 L181_185 L5_10 0.1266
K25095 L181_185 L15_20 0.1266
K25096 L181_185 L58_62 0.0243
K25097 L181_185 L179_183 0.1354
K25098 L181_185 L41_74 0.0319
K25099 L181_185 L131_170 0.0418
K25100 L181_185 L191_195 0.0196
K25101 L181_185 L98_102 0.022
K25102 L181_185 L27_32 0.086
K25103 L181_185 L178_182 0.1673
K25104 L181_185 L3_8 0.1438
K25105 L181_185 L66_70 0.0195
K25106 L181_185 L117_122 0.0313
K25107 L181_185 L38_43 0.0459
K25108 L181_185 L135_174 0.0365
K25109 L181_185 L115_120 0.0844
K25110 L181_185 L80_85 0.0181
K25111 L181_185 L10_15 0.1363
K25112 L181_185 L16_21 0.0775
K25113 L181_185 L113_118 0.0398
K25114 L181_185 L49_53 0.0537
K25115 L181_185 L186_190 0.1673
K25116 L181_185 L125_130 0.0802
K25117 L181_185 L159_164 0.1128
K25118 L181_185 L84_89 0.0272
K25119 L181_185 L82_87 0.0253
K25120 L181_185 L21_26 0.1137
K25121 L181_185 L74_79 0.0301
K25122 L181_185 L165_170 0.0557
K25123 L181_185 L199_203 0.0186
K25124 L181_185 L75_80 0.0186
K25125 L181_185 L70_75 0.019
K25126 L181_185 L50_54 0.0244
K25127 L181_185 L56_60 0.0395
K25128 L181_185 L93_97 0.0206
K25129 L181_185 L90_94 0.0246
K25130 L181_185 L111_116 0.0245
K25131 L181_185 L162_167 0.098
K25132 L181_185 L43_91 0.0265
K25133 L181_185 L142_147 0.0233
K25134 L181_185 L123_128 0.0395
K25135 L181_185 L12_17 0.1127
K25136 L181_185 L146_151 0.0273
K25137 L181_185 L61_65 0.0531
K25138 L122_127 L91_95 0.026
K25139 L122_127 L4_9 0.0309
K25140 L122_127 L202_206 0.0457
K25141 L122_127 L109_114 0.072
K25142 L122_127 L57_61 0.0734
K25143 L122_127 L9_14 0.0311
K25144 L122_127 L53_57 0.0726
K25145 L122_127 L69_73 0.0494
K25146 L122_127 L145_150 0.0199
K25147 L122_127 L131_136 0.0384
K25148 L122_127 L46_50 0.1215
K25149 L122_127 L92_96 0.0251
K25150 L122_127 L19_24 0.0313
K25151 L122_127 L120_125 0.0506
K25152 L122_127 L193_197 0.0574
K25153 L122_127 L7_12 0.0347
K25154 L122_127 L137_142 0.027
K25155 L122_127 L167_172 0.0388
K25156 L122_127 L121_126 0.1548
K25157 L122_127 L110_115 0.0498
K25158 L122_127 L33_38 0.0386
K25159 L122_127 L124_129 0.0744
K25160 L122_127 L78_83 0.0455
K25161 L122_127 L134_139 0.0258
K25162 L122_127 L40_45 0.0311
K25163 L122_127 L183_187 0.0351
K25164 L122_127 L5_10 0.0246
K25165 L122_127 L15_20 0.0249
K25166 L122_127 L58_62 0.1437
K25167 L122_127 L29_34 0.0387
K25168 L122_127 L179_183 0.0349
K25169 L122_127 L158_189 0.0314
K25170 L122_127 L41_74 0.0383
K25171 L122_127 L131_170 0.0359
K25172 L122_127 L191_195 0.0517
K25173 L122_127 L66_70 0.0513
K25174 L122_127 L98_102 0.0254
K25175 L122_127 L27_32 0.0429
K25176 L122_127 L178_182 0.0247
K25177 L122_127 L3_8 0.0325
K25178 L122_127 L149_154 0.0239
K25179 L122_127 L38_43 0.0361
K25180 L122_127 L113_118 0.1103
K25181 L122_127 L135_174 0.0312
K25182 L122_127 L115_120 0.0503
K25183 L122_127 L80_85 0.0427
K25184 L122_127 L10_15 0.0248
K25185 L122_127 L16_21 0.0504
K25186 L122_127 L158_163 0.04
K25187 L122_127 L96_100 0.0245
K25188 L122_127 L49_53 0.0713
K25189 L122_127 L186_190 0.025
K25190 L122_127 L82_87 0.0487
K25191 L122_127 L125_130 0.0507
K25192 L122_127 L159_164 0.0355
K25193 L122_127 L84_89 0.0347
K25194 L122_127 L44_92 0.0258
K25195 L122_127 L21_26 0.0429
K25196 L122_127 L74_79 0.037
K25197 L122_127 L165_170 0.0389
K25198 L122_127 L199_203 0.0455
K25199 L122_127 L75_80 0.0453
K25200 L122_127 L70_75 0.0481
K25201 L122_127 L50_54 0.1322
K25202 L122_127 L56_60 0.1104
K25203 L122_127 L93_97 0.0203
K25204 L122_127 L90_94 0.0269
K25205 L122_127 L134_173 0.0348
K25206 L122_127 L139_144 0.0252
K25207 L122_127 L177_181 0.031
K25208 L122_127 L111_116 0.1402
K25209 L122_127 L162_167 0.0409
K25210 L122_127 L43_91 0.0267
K25211 L122_127 L142_147 0.0262
K25212 L122_127 L39_44 0.0347
K25213 L122_127 L123_128 0.1145
K25214 L122_127 L12_17 0.0349
K25215 L122_127 L146_151 0.0348
K25216 L122_127 L61_65 0.0736
K25217 L19_24 L91_95 0.0285
K25218 L19_24 L202_206 0.0318
K25219 L19_24 L109_114 0.052
K25220 L19_24 L57_61 0.0544
K25221 L19_24 L53_57 0.0537
K25222 L19_24 L69_73 0.0349
K25223 L19_24 L200_204 0.0245
K25224 L19_24 L145_150 0.022
K25225 L19_24 L131_136 0.0358
K25226 L19_24 L46_50 0.0242
K25227 L19_24 L196_200 0.0251
K25228 L19_24 L120_125 0.0803
K25229 L19_24 L193_197 0.0299
K25230 L19_24 L7_12 0.1124
K25231 L19_24 L137_142 0.0279
K25232 L19_24 L167_172 0.08
K25233 L19_24 L121_126 0.0244
K25234 L19_24 L110_115 0.0735
K25235 L19_24 L33_38 0.083
K25236 L19_24 L124_129 0.054
K25237 L19_24 L78_83 0.032
K25238 L19_24 L112_117 0.0311
K25239 L19_24 L40_45 0.0431
K25240 L19_24 L183_187 0.1127
K25241 L19_24 L59_63 0.0314
K25242 L19_24 L5_10 0.0968
K25243 L19_24 L15_20 0.1673
K25244 L19_24 L58_62 0.0245
K25245 L19_24 L179_183 0.1015
K25246 L19_24 L41_74 0.0361
K25247 L19_24 L131_170 0.0494
K25248 L19_24 L191_195 0.0204
K25249 L19_24 L98_102 0.0247
K25250 L19_24 L27_32 0.1233
K25251 L19_24 L178_182 0.0867
K25252 L19_24 L3_8 0.1124
K25253 L19_24 L66_70 0.0205
K25254 L19_24 L117_122 0.0312
K25255 L19_24 L38_43 0.0565
K25256 L19_24 L135_174 0.0426
K25257 L19_24 L115_120 0.0775
K25258 L19_24 L80_85 0.0191
K25259 L19_24 L10_15 0.1268
K25260 L19_24 L16_21 0.0844
K25261 L19_24 L113_118 0.0392
K25262 L19_24 L49_53 0.0526
K25263 L19_24 L186_190 0.1266
K25264 L19_24 L125_130 0.0813
K25265 L19_24 L159_164 0.1522
K25266 L19_24 L84_89 0.0303
K25267 L19_24 L82_87 0.0271
K25268 L19_24 L21_26 0.1427
K25269 L19_24 L74_79 0.0339
K25270 L19_24 L165_170 0.0685
K25271 L19_24 L199_203 0.0195
K25272 L19_24 L75_80 0.0196
K25273 L19_24 L70_75 0.02
K25274 L19_24 L50_54 0.0243
K25275 L19_24 L56_60 0.0398
K25276 L19_24 L93_97 0.0237
K25277 L19_24 L90_94 0.0281
K25278 L19_24 L111_116 0.0243
K25279 L19_24 L162_167 0.1319
K25280 L19_24 L43_91 0.0306
K25281 L19_24 L142_147 0.0262
K25282 L19_24 L123_128 0.0396
K25283 L19_24 L12_17 0.1284
K25284 L19_24 L146_151 0.0301
K25285 L19_24 L61_65 0.0546
K25286 L148_149 L199_200 0.0341
K25287 L148_149 L115_179 0.0211
K25288 L148_149 L196_197 0.0442
K25289 L148_149 L23_24 0.0295
K25290 L148_149 L91_92 0.1173
K25291 L148_149 L160_161 0.0361
K25292 L148_149 L126_127 0.0231
K25293 L148_149 L4_5 0.0172
K25294 L148_149 L41_42 0.0808
K25295 L148_149 L200_201 0.0449
K25296 L148_149 L36_37 0.0585
K25297 L148_149 L131_132 0.0842
K25298 L148_149 L92_93 0.1127
K25299 L148_149 L19_20 0.0235
K25300 L148_149 L187_188 0.0237
K25301 L148_149 L8_9 0.0211
K25302 L148_149 L193_194 0.0585
K25303 L148_149 L21_65 0.0319
K25304 L148_149 L121_122 0.0238
K25305 L148_149 L9_10 0.0211
K25306 L148_149 L134_135 0.0883
K25307 L148_149 L171_172 0.0606
K25308 L148_149 L104_105 0.1266
K25309 L148_149 L151_210 0.0697
K25310 L148_149 L112_113 0.0248
K25311 L148_149 L183_184 0.0223
K25312 L148_149 L59_60 0.0266
K25313 L148_149 L38_39 0.0599
K25314 L148_149 L96_97 0.1438
K25315 L148_149 L78_79 0.1117
K25316 L148_149 L44_45 0.0844
K25317 L148_149 L47_48 0.0228
K25318 L148_149 L29_30 0.0361
K25319 L148_149 L76_77 0.0445
K25320 L148_149 L16_17 0.0234
K25321 L148_149 L6_53 0.0287
K25322 L148_149 L113_114 0.0271
K25323 L148_149 L87_88 0.0451
K25324 L148_149 L127_128 0.0261
K25325 L148_149 L157_158 0.0297
K25326 L148_149 L129_130 0.032
K25327 L148_149 L21_22 0.0293
K25328 L148_149 L117_118 0.0257
K25329 L148_149 L116_117 0.0231
K25330 L148_149 L7_8 0.0211
K25331 L148_149 L58_59 0.0238
K25332 L148_149 L70_71 0.0336
K25333 L148_149 L68_69 0.0575
K25334 L148_149 L89_102 0.1062
K25335 L148_149 L50_51 0.0224
K25336 L148_149 L165_166 0.045
K25337 L148_149 L90_91 0.1127
K25338 L148_149 L139_140 0.1284
K25339 L148_149 L111_112 0.0224
K25340 L148_149 L162_163 0.0364
K25341 L148_149 L137_138 0.1284
K25342 L148_149 L179_180 0.0212
K25343 L148_149 L12_13 0.0222
K25344 L148_149 L142_143 0.1832
K25345 L148_149 L123_124 0.0296
K25346 L148_149 L191_192 0.0314
K25347 L148_149 L39_40 0.0596
K25348 L148_149 L156_157 0.0296
K25349 L148_149 L201_202 0.0656
K25350 L19_20 L199_200 0.0217
K25351 L19_20 L115_179 0.0884
K25352 L19_20 L196_197 0.0252
K25353 L19_20 L23_24 0.1891
K25354 L19_20 L91_92 0.0268
K25355 L19_20 L160_161 0.0907
K25356 L19_20 L126_127 0.0255
K25357 L19_20 L4_5 0.1028
K25358 L19_20 L41_42 0.0354
K25359 L19_20 L200_201 0.0245
K25360 L19_20 L36_37 0.048
K25361 L19_20 L131_132 0.0351
K25362 L19_20 L92_93 0.0269
K25363 L19_20 L165_166 0.063
K25364 L19_20 L193_194 0.0276
K25365 L19_20 L21_65 0.0616
K25366 L19_20 L9_10 0.1354
K25367 L19_20 L134_135 0.036
K25368 L19_20 L171_172 0.0484
K25369 L19_20 L104_105 0.0188
K25370 L19_20 L151_210 0.0266
K25371 L19_20 L112_113 0.0407
K25372 L19_20 L183_184 0.1226
K25373 L19_20 L38_39 0.0496
K25374 L19_20 L78_79 0.0311
K25375 L19_20 L44_45 0.0363
K25376 L19_20 L47_48 0.0381
K25377 L19_20 L29_30 0.1123
K25378 L19_20 L76_77 0.0245
K25379 L19_20 L191_192 0.021
K25380 L19_20 L6_53 0.0921
K25381 L19_20 L149_150 0.0236
K25382 L19_20 L98_99 0.0235
K25383 L19_20 L113_114 0.0564
K25384 L19_20 L80_81 0.0212
K25385 L19_20 L87_88 0.0242
K25386 L19_20 L146_147 0.0232
K25387 L19_20 L127_128 0.0317
K25388 L19_20 L157_158 0.1556
K25389 L19_20 L96_97 0.0252
K25390 L19_20 L129_130 0.0604
K25391 L19_20 L21_22 0.1261
K25392 L19_20 L117_118 0.0413
K25393 L19_20 L116_117 0.032
K25394 L19_20 L7_8 0.1124
K25395 L19_20 L82_83 0.0267
K25396 L19_20 L70_71 0.0222
K25397 L19_20 L68_69 0.0277
K25398 L19_20 L89_102 0.0185
K25399 L19_20 L8_9 0.1284
K25400 L19_20 L50_51 0.0319
K25401 L19_20 L90_91 0.0266
K25402 L19_20 L139_140 0.0267
K25403 L19_20 L111_112 0.0317
K25404 L19_20 L162_163 0.1035
K25405 L19_20 L137_138 0.0265
K25406 L19_20 L179_180 0.1015
K25407 L19_20 L12_13 0.1439
K25408 L19_20 L142_143 0.0248
K25409 L19_20 L39_40 0.0498
K25410 L19_20 L156_157 0.136
K25411 L19_20 L201_202 0.0277
K25412 L23_24 L115_179 0.0947
K25413 L23_24 L196_197 0.0322
K25414 L23_24 L91_92 0.0338
K25415 L23_24 L160_161 0.1299
K25416 L23_24 L146_147 0.0293
K25417 L23_24 L4_5 0.0843
K25418 L23_24 L41_42 0.0453
K25419 L23_24 L200_201 0.0312
K25420 L23_24 L36_37 0.0623
K25421 L23_24 L131_132 0.0449
K25422 L23_24 L92_93 0.0337
K25423 L23_24 L187_188 0.1556
K25424 L23_24 L165_166 0.0843
K25425 L23_24 L8_9 0.1104
K25426 L23_24 L193_194 0.0355
K25427 L23_24 L121_122 0.041
K25428 L23_24 L134_135 0.0453
K25429 L23_24 L171_172 0.0624
K25430 L23_24 L104_105 0.0235
K25431 L23_24 L151_210 0.0338
K25432 L23_24 L112_113 0.0514
K25433 L23_24 L183_184 0.1234
K25434 L23_24 L59_60 0.0541
K25435 L23_24 L38_39 0.0635
K25436 L23_24 L96_97 0.0315
K25437 L23_24 L78_79 0.0397
K25438 L23_24 L44_45 0.0457
K25439 L23_24 L47_48 0.048
K25440 L23_24 L29_30 0.1502
K25441 L23_24 L76_77 0.0312
K25442 L23_24 L16_17 0.1555
K25443 L23_24 L6_53 0.1088
K25444 L23_24 L149_150 0.0294
K25445 L23_24 L98_99 0.0296
K25446 L23_24 L113_114 0.0707
K25447 L23_24 L80_81 0.0268
K25448 L23_24 L87_88 0.0308
K25449 L23_24 L9_10 0.1076
K25450 L23_24 L117_118 0.0526
K25451 L23_24 L116_117 0.0405
K25452 L23_24 L7_8 0.1076
K25453 L23_24 L82_83 0.034
K25454 L23_24 L199_200 0.0274
K25455 L23_24 L58_59 0.0412
K25456 L23_24 L70_71 0.0282
K25457 L23_24 L68_69 0.0356
K25458 L23_24 L89_102 0.0233
K25459 L23_24 L50_51 0.0402
K25460 L23_24 L90_91 0.0337
K25461 L23_24 L139_140 0.0335
K25462 L23_24 L111_112 0.04
K25463 L23_24 L162_163 0.1425
K25464 L23_24 L137_138 0.0335
K25465 L23_24 L179_180 0.1006
K25466 L23_24 L12_13 0.1375
K25467 L23_24 L142_143 0.0313
K25468 L23_24 L123_124 0.0768
K25469 L23_24 L191_192 0.0267
K25470 L23_24 L39_40 0.0632
K25471 L23_24 L201_202 0.0353
K25472 L160_161 L199_200 0.034
K25473 L160_161 L115_179 0.079
K25474 L160_161 L196_197 0.0407
K25475 L160_161 L91_92 0.0412
K25476 L160_161 L126_127 0.0476
K25477 L160_161 L4_5 0.0566
K25478 L160_161 L41_42 0.0572
K25479 L160_161 L200_201 0.0392
K25480 L160_161 L50_51 0.0472
K25481 L160_161 L131_132 0.0579
K25482 L160_161 L92_93 0.0406
K25483 L160_161 L187_188 0.1098
K25484 L160_161 L165_166 0.1279
K25485 L160_161 L8_9 0.0736
K25486 L160_161 L193_194 0.0459
K25487 L160_161 L21_65 0.1489
K25488 L160_161 L121_122 0.0499
K25489 L160_161 L9_10 0.0704
K25490 L160_161 L134_135 0.0559
K25491 L160_161 L171_172 0.0827
K25492 L160_161 L104_105 0.028
K25493 L160_161 L151_210 0.0426
K25494 L160_161 L112_113 0.0607
K25495 L160_161 L183_184 0.0913
K25496 L160_161 L59_60 0.0652
K25497 L160_161 L38_39 0.0796
K25498 L160_161 L78_79 0.0504
K25499 L160_161 L44_45 0.0554
K25500 L160_161 L47_48 0.0554
K25501 L160_161 L76_77 0.0391
K25502 L160_161 L16_17 0.1055
K25503 L160_161 L6_53 0.1002
K25504 L160_161 L149_150 0.0357
K25505 L160_161 L98_99 0.0361
K25506 L160_161 L113_114 0.0802
K25507 L160_161 L80_81 0.033
K25508 L160_161 L87_88 0.0385
K25509 L160_161 L146_147 0.0364
K25510 L160_161 L127_128 0.0642
K25511 L160_161 L157_158 0.1386
K25512 L160_161 L96_97 0.0379
K25513 L160_161 L129_130 0.1608
K25514 L160_161 L21_22 0.1425
K25515 L160_161 L117_118 0.0633
K25516 L160_161 L116_117 0.0487
K25517 L160_161 L7_8 0.0758
K25518 L160_161 L82_83 0.0428
K25519 L160_161 L58_59 0.0496
K25520 L160_161 L70_71 0.0349
K25521 L160_161 L68_69 0.0456
K25522 L160_161 L89_102 0.0285
K25523 L160_161 L36_37 0.0817
K25524 L160_161 L90_91 0.0416
K25525 L160_161 L139_140 0.0409
K25526 L160_161 L111_112 0.0475
K25527 L160_161 L137_138 0.0419
K25528 L160_161 L179_180 0.0781
K25529 L160_161 L12_13 0.0876
K25530 L160_161 L142_143 0.0389
K25531 L160_161 L123_124 0.0939
K25532 L160_161 L191_192 0.0333
K25533 L160_161 L39_40 0.0773
K25534 L160_161 L156_157 0.1502
K25535 L160_161 L201_202 0.0451
K25536 L8_9 L199_200 0.0212
K25537 L8_9 L196_197 0.0245
K25538 L8_9 L91_92 0.0237
K25539 L8_9 L126_127 0.0265
K25540 L8_9 L4_5 0.2134
K25541 L8_9 L41_42 0.0313
K25542 L8_9 L200_201 0.0237
K25543 L8_9 L131_132 0.0311
K25544 L8_9 L92_93 0.0237
K25545 L8_9 L187_188 0.1127
K25546 L8_9 L165_166 0.053
K25547 L8_9 L193_194 0.0263
K25548 L8_9 L21_65 0.0636
K25549 L8_9 L121_122 0.0286
K25550 L8_9 L134_135 0.0313
K25551 L8_9 L171_172 0.0416
K25552 L8_9 L104_105 0.0169
K25553 L8_9 L151_210 0.0248
K25554 L8_9 L183_184 0.1438
K25555 L8_9 L59_60 0.0359
K25556 L8_9 L38_39 0.042
K25557 L8_9 L96_97 0.0223
K25558 L8_9 L78_79 0.0289
K25559 L8_9 L44_45 0.0315
K25560 L8_9 L47_48 0.0422
K25561 L8_9 L29_30 0.0781
K25562 L8_9 L76_77 0.0237
K25563 L8_9 L16_17 0.1124
K25564 L8_9 L149_150 0.0211
K25565 L8_9 L98_99 0.0212
K25566 L8_9 L80_81 0.0207
K25567 L8_9 L87_88 0.023
K25568 L8_9 L146_147 0.021
K25569 L8_9 L127_128 0.0329
K25570 L8_9 L157_158 0.1029
K25571 L8_9 L129_130 0.0622
K25572 L8_9 L21_22 0.1004
K25573 L8_9 L117_118 0.0361
K25574 L8_9 L116_117 0.0287
K25575 L8_9 L82_83 0.0254
K25576 L8_9 L58_59 0.0287
K25577 L8_9 L70_71 0.0218
K25578 L8_9 L68_69 0.0264
K25579 L8_9 L89_102 0.0168
K25580 L8_9 L36_37 0.0415
K25581 L8_9 L90_91 0.0237
K25582 L8_9 L139_140 0.0235
K25583 L8_9 L162_163 0.0766
K25584 L8_9 L137_138 0.0235
K25585 L8_9 L12_13 0.1832
K25586 L8_9 L142_143 0.0222
K25587 L8_9 L123_124 0.0474
K25588 L8_9 L191_192 0.0207
K25589 L8_9 L39_40 0.0419
K25590 L8_9 L156_157 0.1006
K25591 L8_9 L201_202 0.0263
K25592 L165_166 L199_200 0.0369
K25593 L165_166 L115_179 0.0548
K25594 L165_166 L196_197 0.0455
K25595 L165_166 L91_92 0.053
K25596 L165_166 L126_127 0.0446
K25597 L165_166 L4_5 0.0419
K25598 L165_166 L41_42 0.0772
K25599 L165_166 L200_201 0.0438
K25600 L165_166 L36_37 0.1221
K25601 L165_166 L131_132 0.0788
K25602 L165_166 L92_93 0.0518
K25603 L165_166 L193_194 0.0537
K25604 L165_166 L21_65 0.0963
K25605 L165_166 L121_122 0.0461
K25606 L165_166 L9_10 0.0518
K25607 L165_166 L187_188 0.0683
K25608 L165_166 L134_135 0.0741
K25609 L165_166 L171_172 0.1258
K25610 L165_166 L104_105 0.0343
K25611 L165_166 L151_210 0.0512
K25612 L165_166 L112_113 0.0527
K25613 L165_166 L183_184 0.0606
K25614 L165_166 L59_60 0.0575
K25615 L165_166 L38_39 0.1153
K25616 L165_166 L78_79 0.0615
K25617 L165_166 L44_45 0.0727
K25618 L165_166 L47_48 0.0482
K25619 L165_166 L29_30 0.1084
K25620 L165_166 L76_77 0.0436
K25621 L165_166 L16_17 0.0673
K25622 L165_166 L6_53 0.073
K25623 L165_166 L149_150 0.0442
K25624 L165_166 L98_99 0.045
K25625 L165_166 L113_114 0.0641
K25626 L165_166 L80_81 0.0359
K25627 L165_166 L87_88 0.0445
K25628 L165_166 L146_147 0.0456
K25629 L165_166 L127_128 0.0572
K25630 L165_166 L157_158 0.0864
K25631 L165_166 L96_97 0.0475
K25632 L165_166 L129_130 0.099
K25633 L165_166 L21_22 0.0873
K25634 L165_166 L117_118 0.0553
K25635 L165_166 L116_117 0.0448
K25636 L165_166 L7_8 0.0538
K25637 L165_166 L82_83 0.0496
K25638 L165_166 L58_59 0.0459
K25639 L165_166 L70_71 0.0377
K25640 L165_166 L68_69 0.0533
K25641 L165_166 L89_102 0.0352
K25642 L165_166 L50_51 0.0432
K25643 L165_166 L90_91 0.0538
K25644 L165_166 L139_140 0.0524
K25645 L165_166 L111_112 0.0434
K25646 L165_166 L162_163 0.12
K25647 L165_166 L137_138 0.0545
K25648 L165_166 L179_180 0.0545
K25649 L165_166 L12_13 0.0596
K25650 L165_166 L142_143 0.0496
K25651 L165_166 L123_124 0.0743
K25652 L165_166 L191_192 0.036
K25653 L165_166 L39_40 0.1084
K25654 L165_166 L156_157 0.0888
K25655 L165_166 L201_202 0.0525
K25656 L193_194 L199_200 0.0917
K25657 L193_194 L115_179 0.0279
K25658 L193_194 L196_197 0.2045
K25659 L193_194 L91_92 0.061
K25660 L193_194 L126_127 0.0449
K25661 L193_194 L4_5 0.021
K25662 L193_194 L200_201 0.1727
K25663 L193_194 L36_37 0.0621
K25664 L193_194 L92_93 0.0548
K25665 L193_194 L187_188 0.0297
K25666 L193_194 L21_65 0.0498
K25667 L193_194 L121_122 0.045
K25668 L193_194 L9_10 0.0256
K25669 L193_194 L171_172 0.0584
K25670 L193_194 L104_105 0.0421
K25671 L193_194 L151_210 0.123
K25672 L193_194 L112_113 0.0438
K25673 L193_194 L183_184 0.0284
K25674 L193_194 L59_60 0.0492
K25675 L193_194 L38_39 0.0541
K25676 L193_194 L96_97 0.0537
K25677 L193_194 L78_79 0.1576
K25678 L193_194 L47_48 0.0401
K25679 L193_194 L29_30 0.0405
K25680 L193_194 L76_77 0.1576
K25681 L193_194 L16_17 0.0305
K25682 L193_194 L6_53 0.0436
K25683 L193_194 L149_150 0.053
K25684 L193_194 L98_99 0.0639
K25685 L193_194 L113_114 0.0451
K25686 L193_194 L80_81 0.0858
K25687 L193_194 L87_88 0.1492
K25688 L193_194 L146_147 0.0737
K25689 L193_194 L127_128 0.0502
K25690 L193_194 L157_158 0.0356
K25691 L193_194 L129_130 0.0502
K25692 L193_194 L21_22 0.038
K25693 L193_194 L117_118 0.0465
K25694 L193_194 L116_117 0.0427
K25695 L193_194 L7_8 0.0271
K25696 L193_194 L82_83 0.1866
K25697 L193_194 L58_59 0.0447
K25698 L193_194 L70_71 0.0923
K25699 L193_194 L89_102 0.0564
K25700 L193_194 L50_51 0.0404
K25701 L193_194 L90_91 0.0689
K25702 L193_194 L139_140 0.0557
K25703 L193_194 L111_112 0.0406
K25704 L193_194 L162_163 0.0424
K25705 L193_194 L137_138 0.0708
K25706 L193_194 L179_180 0.0272
K25707 L193_194 L12_13 0.0283
K25708 L193_194 L142_143 0.0685
K25709 L193_194 L123_124 0.0513
K25710 L193_194 L39_40 0.0507
K25711 L193_194 L156_157 0.0369
K25712 L193_194 L201_202 0.2809
K25713 L193_197 L91_95 0.0423
K25714 L193_197 L4_9 0.027
K25715 L193_197 L202_206 0.1103
K25716 L193_197 L109_114 0.0489
K25717 L193_197 L57_61 0.054
K25718 L193_197 L53_57 0.0513
K25719 L193_197 L69_73 0.1114
K25720 L193_197 L200_204 0.1103
K25721 L193_197 L145_150 0.0312
K25722 L193_197 L131_136 0.0692
K25723 L193_197 L46_50 0.0391
K25724 L193_197 L196_200 0.1134
K25725 L193_197 L92_96 0.0395
K25726 L193_197 L120_125 0.0428
K25727 L193_197 L7_12 0.0298
K25728 L193_197 L137_142 0.0459
K25729 L193_197 L167_172 0.0488
K25730 L193_197 L121_126 0.0456
K25731 L193_197 L110_115 0.0393
K25732 L193_197 L134_139 0.0398
K25733 L193_197 L9_14 0.0279
K25734 L193_197 L33_38 0.0486
K25735 L193_197 L124_129 0.0574
K25736 L193_197 L78_83 0.1076
K25737 L193_197 L112_117 0.0515
K25738 L193_197 L40_45 0.0432
K25739 L193_197 L183_187 0.0311
K25740 L193_197 L59_63 0.057
K25741 L193_197 L5_10 0.0219
K25742 L193_197 L15_20 0.0233
K25743 L193_197 L58_62 0.0454
K25744 L193_197 L29_34 0.0422
K25745 L193_197 L179_183 0.03
K25746 L193_197 L158_189 0.03
K25747 L193_197 L41_74 0.0684
K25748 L193_197 L131_170 0.0549
K25749 L193_197 L191_195 0.0818
K25750 L193_197 L66_70 0.0802
K25751 L193_197 L98_102 0.0445
K25752 L193_197 L27_32 0.0463
K25753 L193_197 L142_147 0.0455
K25754 L193_197 L178_182 0.0219
K25755 L193_197 L3_8 0.0279
K25756 L193_197 L149_154 0.0391
K25757 L193_197 L117_122 0.0543
K25758 L193_197 L38_43 0.0522
K25759 L193_197 L135_174 0.0434
K25760 L193_197 L115_120 0.041
K25761 L193_197 L80_85 0.0759
K25762 L193_197 L10_15 0.0226
K25763 L193_197 L16_21 0.0445
K25764 L193_197 L158_163 0.0384
K25765 L193_197 L96_100 0.0392
K25766 L193_197 L49_53 0.0487
K25767 L193_197 L186_190 0.0234
K25768 L193_197 L125_130 0.0447
K25769 L193_197 L159_164 0.0345
K25770 L193_197 L44_92 0.0396
K25771 L193_197 L21_26 0.0393
K25772 L193_197 L84_89 0.066
K25773 L193_197 L74_79 0.0681
K25774 L193_197 L165_170 0.0501
K25775 L193_197 L199_203 0.0796
K25776 L193_197 L75_80 0.0782
K25777 L193_197 L70_75 0.0797
K25778 L193_197 L50_54 0.041
K25779 L193_197 L93_97 0.0312
K25780 L193_197 L90_94 0.0455
K25781 L193_197 L134_173 0.0493
K25782 L193_197 L139_144 0.0398
K25783 L193_197 L177_181 0.0271
K25784 L193_197 L111_116 0.0412
K25785 L193_197 L162_167 0.0444
K25786 L193_197 L43_91 0.0424
K25787 L193_197 L39_44 0.049
K25788 L193_197 L12_17 0.031
K25789 L193_197 L146_151 0.0668
K25790 L193_197 L61_65 0.057
K25791 L137_142 L91_95 0.1536
K25792 L137_142 L4_9 0.0232
K25793 L137_142 L202_206 0.0667
K25794 L137_142 L109_114 0.0309
K25795 L137_142 L57_61 0.0338
K25796 L137_142 L53_57 0.0322
K25797 L137_142 L69_73 0.0655
K25798 L137_142 L200_204 0.0351
K25799 L137_142 L145_150 0.0861
K25800 L137_142 L131_136 0.1224
K25801 L137_142 L46_50 0.0197
K25802 L137_142 L196_200 0.0351
K25803 L137_142 L92_96 0.1173
K25804 L137_142 L120_125 0.0334
K25805 L137_142 L167_172 0.0633
K25806 L137_142 L121_126 0.0214
K25807 L137_142 L110_115 0.0297
K25808 L137_142 L113_118 0.0288
K25809 L137_142 L9_14 0.0246
K25810 L137_142 L33_38 0.0619
K25811 L137_142 L134_139 0.1284
K25812 L137_142 L124_129 0.0357
K25813 L137_142 L78_83 0.0655
K25814 L137_142 L112_117 0.0255
K25815 L137_142 L40_45 0.0742
K25816 L137_142 L59_63 0.0269
K25817 L137_142 L5_10 0.0191
K25818 L137_142 L15_20 0.0215
K25819 L137_142 L58_62 0.0214
K25820 L137_142 L29_34 0.045
K25821 L137_142 L41_74 0.1131
K25822 L137_142 L131_170 0.156
K25823 L137_142 L191_195 0.0271
K25824 L137_142 L178_182 0.0192
K25825 L137_142 L3_8 0.0234
K25826 L137_142 L149_154 0.1124
K25827 L137_142 L66_70 0.027
K25828 L137_142 L117_122 0.0262
K25829 L137_142 L158_189 0.0281
K25830 L137_142 L38_43 0.093
K25831 L137_142 L135_174 0.077
K25832 L137_142 L115_120 0.0314
K25833 L137_142 L80_85 0.0269
K25834 L137_142 L10_15 0.0202
K25835 L137_142 L16_21 0.0353
K25836 L137_142 L158_163 0.0362
K25837 L137_142 L96_100 0.1127
K25838 L137_142 L49_53 0.0308
K25839 L137_142 L186_190 0.0216
K25840 L137_142 L82_87 0.0451
K25841 L137_142 L125_130 0.0356
K25842 L137_142 L159_164 0.033
K25843 L137_142 L84_89 0.1056
K25844 L137_142 L44_92 0.1127
K25845 L137_142 L21_26 0.0393
K25846 L137_142 L74_79 0.1161
K25847 L137_142 L165_170 0.0794
K25848 L137_142 L199_203 0.0271
K25849 L137_142 L75_80 0.027
K25850 L137_142 L70_75 0.0271
K25851 L137_142 L50_54 0.0203
K25852 L137_142 L56_60 0.0298
K25853 L137_142 L93_97 0.0811
K25854 L137_142 L134_173 0.0898
K25855 L137_142 L139_144 0.1354
K25856 L137_142 L177_181 0.0233
K25857 L137_142 L111_116 0.0203
K25858 L137_142 L162_167 0.0465
K25859 L137_142 L43_91 0.1438
K25860 L137_142 L39_44 0.086
K25861 L137_142 L123_128 0.0311
K25862 L137_142 L146_151 0.1129
K25863 L137_142 L61_65 0.0355
K25864 L110_115 L91_95 0.0291
K25865 L110_115 L4_9 0.0813
K25866 L110_115 L202_206 0.0395
K25867 L110_115 L109_114 0.1098
K25868 L110_115 L57_61 0.1022
K25869 L110_115 L158_189 0.0757
K25870 L110_115 L53_57 0.1053
K25871 L110_115 L69_73 0.0435
K25872 L110_115 L200_204 0.0326
K25873 L110_115 L145_150 0.0223
K25874 L110_115 L46_50 0.0388
K25875 L110_115 L196_200 0.0336
K25876 L110_115 L92_96 0.0286
K25877 L110_115 L7_12 0.1131
K25878 L110_115 L167_172 0.0549
K25879 L110_115 L121_126 0.0383
K25880 L110_115 L113_118 0.069
K25881 L110_115 L134_139 0.0303
K25882 L110_115 L33_38 0.0544
K25883 L110_115 L124_129 0.1002
K25884 L110_115 L78_83 0.0394
K25885 L110_115 L112_117 0.0506
K25886 L110_115 L40_45 0.0392
K25887 L110_115 L183_187 0.1129
K25888 L110_115 L59_63 0.0495
K25889 L110_115 L5_10 0.0604
K25890 L110_115 L15_20 0.0581
K25891 L110_115 L58_62 0.0381
K25892 L110_115 L29_34 0.0651
K25893 L110_115 L179_183 0.1224
K25894 L110_115 L191_195 0.0277
K25895 L110_115 L66_70 0.0276
K25896 L110_115 L98_102 0.0266
K25897 L110_115 L27_32 0.0728
K25898 L110_115 L142_147 0.0281
K25899 L110_115 L178_182 0.0622
K25900 L110_115 L3_8 0.0958
K25901 L110_115 L149_154 0.026
K25902 L110_115 L117_122 0.0503
K25903 L110_115 L38_43 0.0445
K25904 L110_115 L135_174 0.0394
K25905 L110_115 L80_85 0.0252
K25906 L110_115 L10_15 0.0598
K25907 L110_115 L158_163 0.0838
K25908 L110_115 L96_100 0.0272
K25909 L110_115 L49_53 0.1064
K25910 L110_115 L186_190 0.0597
K25911 L110_115 L82_87 0.0347
K25912 L110_115 L159_164 0.0719
K25913 L110_115 L9_14 0.0803
K25914 L110_115 L44_92 0.0301
K25915 L110_115 L199_203 0.0261
K25916 L110_115 L75_80 0.026
K25917 L110_115 L70_75 0.0268
K25918 L110_115 L50_54 0.0387
K25919 L110_115 L56_60 0.0673
K25920 L110_115 L93_97 0.0234
K25921 L110_115 L90_94 0.0296
K25922 L110_115 L134_173 0.0436
K25923 L110_115 L139_144 0.0287
K25924 L110_115 L177_181 0.0844
K25925 L110_115 L111_116 0.0389
K25926 L110_115 L162_167 0.0701
K25927 L110_115 L43_91 0.0307
K25928 L110_115 L39_44 0.0434
K25929 L110_115 L123_128 0.0668
K25930 L110_115 L61_65 0.0977
K25931 L110_115 L12_17 0.1056
K25932 L171_172 L199_200 0.0379
K25933 L171_172 L115_179 0.0419
K25934 L171_172 L196_197 0.0475
K25935 L171_172 L91_92 0.0758
K25936 L171_172 L126_127 0.0389
K25937 L171_172 L4_5 0.0335
K25938 L171_172 L41_42 0.116
K25939 L171_172 L200_201 0.0461
K25940 L171_172 L131_132 0.122
K25941 L171_172 L92_93 0.0736
K25942 L171_172 L187_188 0.0498
K25943 L171_172 L21_65 0.0678
K25944 L171_172 L121_122 0.0402
K25945 L171_172 L9_10 0.0412
K25946 L171_172 L134_135 0.1157
K25947 L171_172 L104_105 0.0449
K25948 L171_172 L151_210 0.0608
K25949 L171_172 L112_113 0.044
K25950 L171_172 L183_184 0.0456
K25951 L171_172 L59_60 0.0477
K25952 L171_172 L78_79 0.0732
K25953 L171_172 L44_45 0.1106
K25954 L171_172 L47_48 0.0404
K25955 L171_172 L29_30 0.0796
K25956 L171_172 L76_77 0.0459
K25957 L171_172 L16_17 0.049
K25958 L171_172 L6_53 0.0562
K25959 L171_172 L149_150 0.0595
K25960 L171_172 L98_99 0.0599
K25961 L171_172 L113_114 0.0508
K25962 L171_172 L80_81 0.037
K25963 L171_172 L87_88 0.0494
K25964 L171_172 L146_147 0.0606
K25965 L171_172 L127_128 0.0472
K25966 L171_172 L157_158 0.0632
K25967 L171_172 L96_97 0.0653
K25968 L171_172 L129_130 0.0687
K25969 L171_172 L21_22 0.0624
K25970 L171_172 L117_118 0.0459
K25971 L171_172 L116_117 0.0389
K25972 L171_172 L7_8 0.0417
K25973 L171_172 L82_83 0.0549
K25974 L171_172 L58_59 0.04
K25975 L171_172 L70_71 0.0385
K25976 L171_172 L68_69 0.0579
K25977 L171_172 L89_102 0.0456
K25978 L171_172 L50_51 0.0376
K25979 L171_172 L90_91 0.0766
K25980 L171_172 L139_140 0.0757
K25981 L171_172 L111_112 0.0377
K25982 L171_172 L162_163 0.0827
K25983 L171_172 L137_138 0.079
K25984 L171_172 L179_180 0.042
K25985 L171_172 L12_13 0.0451
K25986 L171_172 L142_143 0.0688
K25987 L171_172 L123_124 0.0574
K25988 L171_172 L191_192 0.0365
K25989 L171_172 L156_157 0.0635
K25990 L171_172 L201_202 0.0579
K25991 L183_184 L199_200 0.0225
K25992 L183_184 L115_179 0.1832
K25993 L183_184 L196_197 0.0261
K25994 L183_184 L91_92 0.025
K25995 L183_184 L126_127 0.0282
K25996 L183_184 L4_5 0.0969
K25997 L183_184 L41_42 0.0335
K25998 L183_184 L200_201 0.0252
K25999 L183_184 L36_37 0.045
K26000 L183_184 L131_132 0.0337
K26001 L183_184 L92_93 0.0248
K26002 L183_184 L187_188 0.2054
K26003 L183_184 L21_65 0.0738
K26004 L183_184 L121_122 0.0304
K26005 L183_184 L9_10 0.1226
K26006 L183_184 L134_135 0.0334
K26007 L183_184 L104_105 0.0176
K26008 L183_184 L151_210 0.0265
K26009 L183_184 L112_113 0.0488
K26010 L183_184 L59_60 0.0385
K26011 L183_184 L129_130 0.0761
K26012 L183_184 L38_39 0.045
K26013 L183_184 L96_97 0.0234
K26014 L183_184 L78_79 0.0308
K26015 L183_184 L44_45 0.0332
K26016 L183_184 L47_48 0.0448
K26017 L183_184 L29_30 0.0843
K26018 L183_184 L76_77 0.0252
K26019 L183_184 L16_17 0.1438
K26020 L183_184 L149_150 0.0222
K26021 L183_184 L98_99 0.0223
K26022 L183_184 L6_53 0.133
K26023 L183_184 L113_114 0.0741
K26024 L183_184 L80_81 0.0218
K26025 L183_184 L87_88 0.0244
K26026 L183_184 L146_147 0.0223
K26027 L183_184 L127_128 0.0358
K26028 L183_184 L157_158 0.1375
K26029 L183_184 L21_22 0.1234
K26030 L183_184 L7_8 0.1536
K26031 L183_184 L82_83 0.027
K26032 L183_184 L58_59 0.0303
K26033 L183_184 L70_71 0.023
K26034 L183_184 L68_69 0.0283
K26035 L183_184 L89_102 0.0177
K26036 L183_184 L50_51 0.0361
K26037 L183_184 L90_91 0.025
K26038 L183_184 L139_140 0.025
K26039 L183_184 L111_112 0.0363
K26040 L183_184 L162_163 0.0913
K26041 L183_184 L137_138 0.0252
K26042 L183_184 L179_180 0.2054
K26043 L183_184 L142_143 0.0237
K26044 L183_184 L123_124 0.0533
K26045 L183_184 L191_192 0.0219
K26046 L183_184 L39_40 0.0445
K26047 L183_184 L156_157 0.1436
K26048 L183_184 L201_202 0.0282
K26049 L183_187 L91_95 0.0265
K26050 L183_187 L4_9 0.1015
K26051 L183_187 L202_206 0.0324
K26052 L183_187 L109_114 0.0654
K26053 L183_187 L57_61 0.0659
K26054 L183_187 L53_57 0.0655
K26055 L183_187 L69_73 0.0355
K26056 L183_187 L200_204 0.0255
K26057 L183_187 L145_150 0.0203
K26058 L183_187 L131_136 0.0356
K26059 L183_187 L46_50 0.0269
K26060 L183_187 L196_200 0.0262
K26061 L183_187 L92_96 0.0262
K26062 L183_187 L120_125 0.1262
K26063 L183_187 L167_172 0.0565
K26064 L183_187 L121_126 0.0271
K26065 L183_187 L113_118 0.0459
K26066 L183_187 L9_14 0.1127
K26067 L183_187 L33_38 0.0555
K26068 L183_187 L134_139 0.0281
K26069 L183_187 L124_129 0.0667
K26070 L183_187 L78_83 0.0322
K26071 L183_187 L112_117 0.0351
K26072 L183_187 L40_45 0.0377
K26073 L183_187 L59_63 0.0349
K26074 L183_187 L5_10 0.073
K26075 L183_187 L15_20 0.0811
K26076 L183_187 L58_62 0.027
K26077 L183_187 L29_34 0.0754
K26078 L183_187 L41_74 0.0353
K26079 L183_187 L131_170 0.0477
K26080 L183_187 L191_195 0.0214
K26081 L183_187 L178_182 0.0787
K26082 L183_187 L3_8 0.1226
K26083 L183_187 L149_154 0.0233
K26084 L183_187 L66_70 0.0214
K26085 L183_187 L117_122 0.0351
K26086 L183_187 L158_189 0.1284
K26087 L183_187 L38_43 0.0422
K26088 L183_187 L135_174 0.0381
K26089 L183_187 L115_120 0.1224
K26090 L183_187 L80_85 0.0197
K26091 L183_187 L10_15 0.0789
K26092 L183_187 L16_21 0.1131
K26093 L183_187 L158_163 0.1233
K26094 L183_187 L96_100 0.0246
K26095 L183_187 L49_53 0.0643
K26096 L183_187 L186_190 0.0891
K26097 L183_187 L82_87 0.0277
K26098 L183_187 L125_130 0.1224
K26099 L183_187 L159_164 0.0997
K26100 L183_187 L84_89 0.0296
K26101 L183_187 L44_92 0.0279
K26102 L183_187 L21_26 0.1975
K26103 L183_187 L74_79 0.0332
K26104 L183_187 L165_170 0.0681
K26105 L183_187 L199_203 0.0203
K26106 L183_187 L75_80 0.0203
K26107 L183_187 L70_75 0.0208
K26108 L183_187 L50_54 0.027
K26109 L183_187 L56_60 0.0457
K26110 L183_187 L93_97 0.0215
K26111 L183_187 L134_173 0.0419
K26112 L183_187 L139_144 0.0263
K26113 L183_187 L177_181 0.1124
K26114 L183_187 L111_116 0.0271
K26115 L183_187 L162_167 0.083
K26116 L183_187 L43_91 0.0283
K26117 L183_187 L39_44 0.0415
K26118 L183_187 L123_128 0.0459
K26119 L183_187 L146_151 0.0297
K26120 L183_187 L61_65 0.0655
K26121 L5_10 L91_95 0.0194
K26122 L5_10 L4_9 0.1916
K26123 L5_10 L109_114 0.0418
K26124 L5_10 L57_61 0.0417
K26125 L5_10 L53_57 0.0421
K26126 L5_10 L69_73 0.0248
K26127 L5_10 L200_204 0.0184
K26128 L5_10 L131_136 0.0246
K26129 L5_10 L46_50 0.0195
K26130 L5_10 L196_200 0.0189
K26131 L5_10 L92_96 0.0195
K26132 L5_10 L120_125 0.0581
K26133 L5_10 L7_12 0.0861
K26134 L5_10 L167_172 0.0451
K26135 L5_10 L121_126 0.0193
K26136 L5_10 L113_118 0.0312
K26137 L5_10 L134_139 0.0206
K26138 L5_10 L9_14 0.1673
K26139 L5_10 L33_38 0.0458
K26140 L5_10 L124_129 0.0405
K26141 L5_10 L78_83 0.0229
K26142 L5_10 L112_117 0.0249
K26143 L5_10 L59_63 0.0247
K26144 L5_10 L58_62 0.0193
K26145 L5_10 L29_34 0.0697
K26146 L5_10 L179_183 0.0789
K26147 L5_10 L41_74 0.0247
K26148 L5_10 L131_170 0.0311
K26149 L5_10 L191_195 0.0154
K26150 L5_10 L66_70 0.0155
K26151 L5_10 L98_102 0.0172
K26152 L5_10 L27_32 0.061
K26153 L5_10 L142_147 0.0181
K26154 L5_10 L3_8 0.1216
K26155 L5_10 L149_154 0.0174
K26156 L5_10 L117_122 0.0248
K26157 L5_10 L158_189 0.0867
K26158 L5_10 L38_43 0.0349
K26159 L5_10 L115_120 0.0598
K26160 L5_10 L80_85 0.0144
K26161 L5_10 L16_21 0.057
K26162 L5_10 L158_163 0.1131
K26163 L5_10 L96_100 0.0185
K26164 L5_10 L49_53 0.0423
K26165 L5_10 L82_87 0.02
K26166 L5_10 L125_130 0.0556
K26167 L5_10 L84_89 0.0213
K26168 L5_10 L202_206 0.0228
K26169 L5_10 L44_92 0.0207
K26170 L5_10 L21_26 0.0791
K26171 L5_10 L74_79 0.0234
K26172 L5_10 L165_170 0.0398
K26173 L5_10 L199_203 0.0147
K26174 L5_10 L75_80 0.0147
K26175 L5_10 L70_75 0.0151
K26176 L5_10 L50_54 0.0195
K26177 L5_10 L56_60 0.0312
K26178 L5_10 L90_94 0.0192
K26179 L5_10 L134_173 0.0351
K26180 L5_10 L139_144 0.0194
K26181 L5_10 L177_181 0.1363
K26182 L5_10 L111_116 0.0194
K26183 L5_10 L162_167 0.0635
K26184 L5_10 L43_91 0.0206
K26185 L5_10 L39_44 0.0355
K26186 L5_10 L123_128 0.0307
K26187 L5_10 L12_17 0.0787
K26188 L5_10 L146_151 0.0212
K26189 L5_10 L61_65 0.0409
K26190 L58_62 L91_95 0.0207
K26191 L58_62 L4_9 0.0242
K26192 L58_62 L202_206 0.0362
K26193 L58_62 L109_114 0.0541
K26194 L58_62 L57_61 0.0558
K26195 L58_62 L53_57 0.0553
K26196 L58_62 L69_73 0.0393
K26197 L58_62 L200_204 0.0453
K26198 L58_62 L145_150 0.0158
K26199 L58_62 L131_136 0.0303
K26200 L58_62 L196_200 0.0481
K26201 L58_62 L92_96 0.02
K26202 L58_62 L120_125 0.0387
K26203 L58_62 L7_12 0.027
K26204 L58_62 L167_172 0.0303
K26205 L58_62 L113_118 0.0782
K26206 L58_62 L134_139 0.0204
K26207 L58_62 L9_14 0.0243
K26208 L58_62 L33_38 0.0304
K26209 L58_62 L124_129 0.0555
K26210 L58_62 L78_83 0.0364
K26211 L58_62 L112_117 0.1322
K26212 L58_62 L40_45 0.0246
K26213 L58_62 L59_63 0.1548
K26214 L58_62 L15_20 0.0195
K26215 L58_62 L29_34 0.0304
K26216 L58_62 L158_189 0.0244
K26217 L58_62 L41_74 0.0304
K26218 L58_62 L131_170 0.0282
K26219 L58_62 L98_102 0.0203
K26220 L58_62 L27_32 0.0336
K26221 L58_62 L178_182 0.0193
K26222 L58_62 L3_8 0.0254
K26223 L58_62 L149_154 0.019
K26224 L58_62 L117_122 0.1405
K26225 L58_62 L38_43 0.0286
K26226 L58_62 L135_174 0.0246
K26227 L58_62 L115_120 0.0385
K26228 L58_62 L10_15 0.0194
K26229 L58_62 L16_21 0.039
K26230 L58_62 L158_163 0.0311
K26231 L58_62 L96_100 0.0196
K26232 L58_62 L49_53 0.0545
K26233 L58_62 L186_190 0.0194
K26234 L58_62 L82_87 0.0393
K26235 L58_62 L125_130 0.0388
K26236 L58_62 L159_164 0.0277
K26237 L58_62 L44_92 0.0205
K26238 L58_62 L21_26 0.0333
K26239 L58_62 L84_89 0.0277
K26240 L58_62 L74_79 0.0295
K26241 L58_62 L165_170 0.0303
K26242 L58_62 L56_60 0.0812
K26243 L58_62 L93_97 0.0162
K26244 L58_62 L90_94 0.0214
K26245 L58_62 L134_173 0.0274
K26246 L58_62 L139_144 0.02
K26247 L58_62 L177_181 0.0241
K26248 L58_62 L179_183 0.0269
K26249 L58_62 L162_167 0.0318
K26250 L58_62 L43_91 0.0212
K26251 L58_62 L142_147 0.0208
K26252 L58_62 L39_44 0.0275
K26253 L58_62 L123_128 0.0802
K26254 L58_62 L12_17 0.0271
K26255 L58_62 L146_151 0.0276
K26256 L58_62 L61_65 0.056
K26257 L29_30 L199_200 0.0307
K26258 L29_30 L115_179 0.0704
K26259 L29_30 L196_197 0.0362
K26260 L29_30 L91_92 0.0419
K26261 L29_30 L126_127 0.0396
K26262 L29_30 L4_5 0.063
K26263 L29_30 L41_42 0.0559
K26264 L29_30 L200_201 0.0352
K26265 L29_30 L50_51 0.0405
K26266 L29_30 L131_132 0.0554
K26267 L29_30 L92_93 0.042
K26268 L29_30 L187_188 0.098
K26269 L29_30 L21_65 0.1086
K26270 L29_30 L121_122 0.0418
K26271 L29_30 L9_10 0.079
K26272 L29_30 L134_135 0.0572
K26273 L29_30 L104_105 0.0287
K26274 L29_30 L151_210 0.0395
K26275 L29_30 L112_113 0.05
K26276 L29_30 L59_60 0.0532
K26277 L29_30 L38_39 0.0827
K26278 L29_30 L78_79 0.0466
K26279 L29_30 L44_45 0.0579
K26280 L29_30 L47_48 0.0465
K26281 L29_30 L76_77 0.0353
K26282 L29_30 L16_17 0.0947
K26283 L29_30 L6_53 0.0861
K26284 L29_30 L149_150 0.0362
K26285 L29_30 L98_99 0.0361
K26286 L29_30 L113_114 0.0642
K26287 L29_30 L80_81 0.03
K26288 L29_30 L87_88 0.0354
K26289 L29_30 L146_147 0.0355
K26290 L29_30 L127_128 0.0506
K26291 L29_30 L157_158 0.1389
K26292 L29_30 L96_97 0.039
K26293 L29_30 L129_130 0.1049
K26294 L29_30 L21_22 0.1245
K26295 L29_30 L117_118 0.0514
K26296 L29_30 L116_117 0.0411
K26297 L29_30 L7_8 0.0757
K26298 L29_30 L82_83 0.0391
K26299 L29_30 L58_59 0.042
K26300 L29_30 L70_71 0.0314
K26301 L29_30 L68_69 0.0407
K26302 L29_30 L89_102 0.0282
K26303 L29_30 L36_37 0.0786
K26304 L29_30 L90_91 0.0415
K26305 L29_30 L139_140 0.0417
K26306 L29_30 L111_112 0.0404
K26307 L29_30 L137_138 0.0412
K26308 L29_30 L179_180 0.0736
K26309 L29_30 L12_13 0.0875
K26310 L29_30 L142_143 0.0383
K26311 L29_30 L123_124 0.0706
K26312 L29_30 L191_192 0.0297
K26313 L29_30 L39_40 0.0832
K26314 L29_30 L156_157 0.1299
K26315 L29_30 L201_202 0.0405
K26316 L76_77 L115_179 0.025
K26317 L76_77 L196_197 0.2659
K26318 L76_77 L91_92 0.0363
K26319 L76_77 L126_127 0.0477
K26320 L76_77 L4_5 0.019
K26321 L76_77 L41_42 0.0483
K26322 L76_77 L191_192 0.1576
K26323 L76_77 L36_37 0.0487
K26324 L76_77 L131_132 0.048
K26325 L76_77 L92_93 0.0341
K26326 L76_77 L187_188 0.026
K26327 L76_77 L21_65 0.0438
K26328 L76_77 L121_122 0.0474
K26329 L76_77 L9_10 0.0231
K26330 L76_77 L134_135 0.04
K26331 L76_77 L104_105 0.0341
K26332 L76_77 L151_210 0.0878
K26333 L76_77 L98_99 0.0488
K26334 L76_77 L112_113 0.0435
K26335 L76_77 L59_60 0.0491
K26336 L76_77 L38_39 0.0438
K26337 L76_77 L44_45 0.0402
K26338 L76_77 L47_48 0.0402
K26339 L76_77 L16_17 0.0269
K26340 L76_77 L6_53 0.04
K26341 L76_77 L149_150 0.0413
K26342 L76_77 L113_114 0.0425
K26343 L76_77 L80_81 0.1933
K26344 L76_77 L87_88 0.1593
K26345 L76_77 L146_147 0.0527
K26346 L76_77 L127_128 0.0493
K26347 L76_77 L157_158 0.0312
K26348 L76_77 L129_130 0.0436
K26349 L76_77 L21_22 0.0333
K26350 L76_77 L117_118 0.046
K26351 L76_77 L116_117 0.0448
K26352 L76_77 L7_8 0.0244
K26353 L76_77 L82_83 0.1933
K26354 L76_77 L58_59 0.0477
K26355 L76_77 L70_71 0.1933
K26356 L76_77 L68_69 0.1727
K26357 L76_77 L89_102 0.0435
K26358 L76_77 L50_51 0.0427
K26359 L76_77 L90_91 0.0387
K26360 L76_77 L139_140 0.0339
K26361 L76_77 L111_112 0.0425
K26362 L76_77 L162_163 0.0364
K26363 L76_77 L137_138 0.0385
K26364 L76_77 L179_180 0.0243
K26365 L76_77 L12_13 0.0252
K26366 L76_77 L123_124 0.0474
K26367 L76_77 L39_40 0.0417
K26368 L76_77 L156_157 0.0322
K26369 L29_34 L91_95 0.0465
K26370 L29_34 L202_206 0.0466
K26371 L29_34 L109_114 0.0558
K26372 L29_34 L57_61 0.0611
K26373 L29_34 L53_57 0.0587
K26374 L29_34 L69_73 0.0514
K26375 L29_34 L200_204 0.0339
K26376 L29_34 L145_150 0.0419
K26377 L29_34 L131_136 0.0562
K26378 L29_34 L46_50 0.0291
K26379 L29_34 L196_200 0.0347
K26380 L29_34 L120_125 0.0759
K26381 L29_34 L7_12 0.0685
K26382 L29_34 L167_172 0.1706
K26383 L29_34 L121_126 0.0303
K26384 L29_34 L33_38 0.1944
K26385 L29_34 L124_129 0.0628
K26386 L29_34 L78_83 0.0469
K26387 L29_34 L112_117 0.0376
K26388 L29_34 L40_45 0.1013
K26389 L29_34 L59_63 0.0389
K26390 L29_34 L15_20 0.1012
K26391 L29_34 L179_183 0.0668
K26392 L29_34 L41_74 0.0568
K26393 L29_34 L131_170 0.0885
K26394 L29_34 L191_195 0.028
K26395 L29_34 L98_102 0.0389
K26396 L29_34 L27_32 0.2092
K26397 L29_34 L178_182 0.0671
K26398 L29_34 L3_8 0.0633
K26399 L29_34 L66_70 0.028
K26400 L29_34 L117_122 0.0382
K26401 L29_34 L38_43 0.1081
K26402 L29_34 L135_174 0.0972
K26403 L29_34 L115_120 0.0703
K26404 L29_34 L80_85 0.0263
K26405 L29_34 L10_15 0.0827
K26406 L29_34 L16_21 0.0838
K26407 L29_34 L113_118 0.0459
K26408 L29_34 L49_53 0.0562
K26409 L29_34 L186_190 0.0934
K26410 L29_34 L125_130 0.082
K26411 L29_34 L159_164 0.1634
K26412 L29_34 L84_89 0.0464
K26413 L29_34 L82_87 0.0384
K26414 L29_34 L21_26 0.1398
K26415 L29_34 L74_79 0.0529
K26416 L29_34 L165_170 0.1298
K26417 L29_34 L199_203 0.0268
K26418 L29_34 L75_80 0.0269
K26419 L29_34 L70_75 0.0275
K26420 L29_34 L50_54 0.0296
K26421 L29_34 L56_60 0.0473
K26422 L29_34 L93_97 0.0471
K26423 L29_34 L90_94 0.0455
K26424 L29_34 L111_116 0.0295
K26425 L29_34 L162_167 0.2341
K26426 L29_34 L43_91 0.051
K26427 L29_34 L142_147 0.0415
K26428 L29_34 L123_128 0.0481
K26429 L29_34 L12_17 0.0779
K26430 L29_34 L146_151 0.0461
K26431 L29_34 L61_65 0.0634
K26432 L41_74 L91_95 0.0991
K26433 L41_74 L4_9 0.0303
K26434 L41_74 L202_206 0.1022
K26435 L41_74 L109_114 0.0435
K26436 L41_74 L57_61 0.0487
K26437 L41_74 L158_189 0.0358
K26438 L41_74 L53_57 0.046
K26439 L41_74 L69_73 0.1098
K26440 L41_74 L200_204 0.05
K26441 L41_74 L145_150 0.0581
K26442 L41_74 L46_50 0.0277
K26443 L41_74 L196_200 0.0503
K26444 L41_74 L92_96 0.0833
K26445 L41_74 L7_12 0.0334
K26446 L41_74 L167_172 0.0753
K26447 L41_74 L121_126 0.0303
K26448 L41_74 L113_118 0.0408
K26449 L41_74 L134_139 0.0813
K26450 L41_74 L33_38 0.0767
K26451 L41_74 L124_129 0.0512
K26452 L41_74 L78_83 0.1051
K26453 L41_74 L112_117 0.0358
K26454 L41_74 L40_45 0.0767
K26455 L41_74 L59_63 0.0384
K26456 L41_74 L15_20 0.0275
K26457 L41_74 L179_183 0.0332
K26458 L41_74 L191_195 0.0388
K26459 L41_74 L66_70 0.039
K26460 L41_74 L98_102 0.1012
K26461 L41_74 L27_32 0.0617
K26462 L41_74 L142_147 0.1056
K26463 L41_74 L178_182 0.0246
K26464 L41_74 L3_8 0.0309
K26465 L41_74 L149_154 0.0735
K26466 L41_74 L117_122 0.037
K26467 L41_74 L38_43 0.1019
K26468 L41_74 L135_174 0.075
K26469 L41_74 L80_85 0.0383
K26470 L41_74 L10_15 0.026
K26471 L41_74 L158_163 0.0461
K26472 L41_74 L96_100 0.0802
K26473 L41_74 L49_53 0.0437
K26474 L41_74 L186_190 0.0274
K26475 L41_74 L82_87 0.0668
K26476 L41_74 L159_164 0.0416
K26477 L41_74 L9_14 0.032
K26478 L41_74 L44_92 0.0844
K26479 L41_74 L199_203 0.0385
K26480 L41_74 L75_80 0.0387
K26481 L41_74 L70_75 0.0389
K26482 L41_74 L50_54 0.0286
K26483 L41_74 L56_60 0.0428
K26484 L41_74 L93_97 0.0615
K26485 L41_74 L90_94 0.1224
K26486 L41_74 L134_173 0.0881
K26487 L41_74 L139_144 0.0803
K26488 L41_74 L177_181 0.0301
K26489 L41_74 L111_116 0.0285
K26490 L41_74 L162_167 0.0586
K26491 L41_74 L43_91 0.1011
K26492 L41_74 L39_44 0.0904
K26493 L41_74 L123_128 0.0445
K26494 L41_74 L61_65 0.0516
K26495 L41_74 L12_17 0.0356
K26496 L131_170 L91_95 0.1175
K26497 L131_170 L4_9 0.0382
K26498 L131_170 L202_206 0.0694
K26499 L131_170 L109_114 0.0434
K26500 L131_170 L57_61 0.0481
K26501 L131_170 L158_189 0.0502
K26502 L131_170 L53_57 0.0455
K26503 L131_170 L69_73 0.0761
K26504 L131_170 L200_204 0.0407
K26505 L131_170 L145_150 0.0703
K26506 L131_170 L46_50 0.026
K26507 L131_170 L196_200 0.0415
K26508 L131_170 L92_96 0.1012
K26509 L131_170 L7_12 0.0428
K26510 L131_170 L167_172 0.17
K26511 L131_170 L121_126 0.0283
K26512 L131_170 L113_118 0.0395
K26513 L131_170 L134_139 0.1247
K26514 L131_170 L33_38 0.1517
K26515 L131_170 L124_129 0.0513
K26516 L131_170 L78_83 0.0685
K26517 L131_170 L112_117 0.0339
K26518 L131_170 L40_45 0.1257
K26519 L131_170 L59_63 0.0358
K26520 L131_170 L15_20 0.0364
K26521 L131_170 L179_183 0.0433
K26522 L131_170 L191_195 0.0327
K26523 L131_170 L66_70 0.0325
K26524 L131_170 L98_102 0.0898
K26525 L131_170 L27_32 0.0992
K26526 L131_170 L142_147 0.1185
K26527 L131_170 L178_182 0.0314
K26528 L131_170 L3_8 0.0389
K26529 L131_170 L149_154 0.081
K26530 L131_170 L117_122 0.0349
K26531 L131_170 L38_43 0.2027
K26532 L131_170 L135_174 0.1357
K26533 L131_170 L80_85 0.031
K26534 L131_170 L10_15 0.0336
K26535 L131_170 L158_163 0.0648
K26536 L131_170 L96_100 0.0887
K26537 L131_170 L49_53 0.0431
K26538 L131_170 L186_190 0.0369
K26539 L131_170 L82_87 0.0497
K26540 L131_170 L159_164 0.058
K26541 L131_170 L9_14 0.0413
K26542 L131_170 L44_92 0.1137
K26543 L131_170 L199_203 0.0317
K26544 L131_170 L75_80 0.0316
K26545 L131_170 L70_75 0.0321
K26546 L131_170 L50_54 0.0267
K26547 L131_170 L56_60 0.0409
K26548 L131_170 L93_97 0.0748
K26549 L131_170 L90_94 0.1339
K26550 L131_170 L134_173 0.1786
K26551 L131_170 L139_144 0.1087
K26552 L131_170 L177_181 0.0385
K26553 L131_170 L111_116 0.0268
K26554 L131_170 L162_167 0.0983
K26555 L131_170 L43_91 0.1381
K26556 L131_170 L39_44 0.1599
K26557 L131_170 L123_128 0.0428
K26558 L131_170 L61_65 0.0509
K26559 L131_170 L12_17 0.047
K26560 L16_17 L199_200 0.0237
K26561 L16_17 L115_179 0.1173
K26562 L16_17 L196_197 0.0279
K26563 L16_17 L91_92 0.0266
K26564 L16_17 L126_127 0.0299
K26565 L16_17 L4_5 0.0757
K26566 L16_17 L41_42 0.0363
K26567 L16_17 L200_201 0.0269
K26568 L16_17 L36_37 0.0498
K26569 L16_17 L131_132 0.036
K26570 L16_17 L92_93 0.0263
K26571 L16_17 L21_65 0.0945
K26572 L16_17 L9_10 0.0953
K26573 L16_17 L134_135 0.0351
K26574 L16_17 L104_105 0.0185
K26575 L16_17 L151_210 0.0281
K26576 L16_17 L112_113 0.0515
K26577 L16_17 L38_39 0.049
K26578 L16_17 L78_79 0.0333
K26579 L16_17 L44_45 0.0354
K26580 L16_17 L47_48 0.0483
K26581 L16_17 L191_192 0.0232
K26582 L16_17 L6_53 0.1459
K26583 L16_17 L149_150 0.0232
K26584 L16_17 L98_99 0.0237
K26585 L16_17 L113_114 0.078
K26586 L16_17 L80_81 0.0231
K26587 L16_17 L87_88 0.0261
K26588 L16_17 L146_147 0.0236
K26589 L16_17 L127_128 0.0386
K26590 L16_17 L157_158 0.136
K26591 L16_17 L96_97 0.0247
K26592 L16_17 L129_130 0.09
K26593 L16_17 L21_22 0.2069
K26594 L16_17 L117_118 0.0527
K26595 L16_17 L116_117 0.0385
K26596 L16_17 L7_8 0.1284
K26597 L16_17 L82_83 0.0289
K26598 L16_17 L70_71 0.0245
K26599 L16_17 L68_69 0.0307
K26600 L16_17 L89_102 0.0188
K26601 L16_17 L50_51 0.0383
K26602 L16_17 L90_91 0.0268
K26603 L16_17 L139_140 0.0262
K26604 L16_17 L111_112 0.038
K26605 L16_17 L162_163 0.098
K26606 L16_17 L137_138 0.0266
K26607 L16_17 L179_180 0.1127
K26608 L16_17 L12_13 0.1832
K26609 L16_17 L142_143 0.025
K26610 L16_17 L39_40 0.048
K26611 L16_17 L156_157 0.1556
K26612 L16_17 L201_202 0.0302
K26613 L191_195 L91_95 0.0256
K26614 L191_195 L4_9 0.019
K26615 L191_195 L202_206 0.0553
K26616 L191_195 L109_114 0.035
K26617 L191_195 L57_61 0.0376
K26618 L191_195 L53_57 0.0362
K26619 L191_195 L69_73 0.0555
K26620 L191_195 L200_204 0.1402
K26621 L191_195 L145_150 0.0194
K26622 L191_195 L131_136 0.039
K26623 L191_195 L196_200 0.1506
K26624 L191_195 L92_96 0.0243
K26625 L191_195 L120_125 0.0295
K26626 L191_195 L7_12 0.0208
K26627 L191_195 L167_172 0.031
K26628 L191_195 L113_118 0.0412
K26629 L191_195 L134_139 0.0245
K26630 L191_195 L9_14 0.0195
K26631 L191_195 L33_38 0.0309
K26632 L191_195 L124_129 0.0393
K26633 L191_195 L78_83 0.0549
K26634 L191_195 L112_117 0.0455
K26635 L191_195 L40_45 0.0273
K26636 L191_195 L59_63 0.0513
K26637 L191_195 L15_20 0.0161
K26638 L191_195 L158_189 0.0205
K26639 L191_195 L98_102 0.0267
K26640 L191_195 L27_32 0.0303
K26641 L191_195 L178_182 0.0155
K26642 L191_195 L3_8 0.0196
K26643 L191_195 L149_154 0.0242
K26644 L191_195 L117_122 0.0484
K26645 L191_195 L38_43 0.0322
K26646 L191_195 L135_174 0.0274
K26647 L191_195 L115_120 0.0286
K26648 L191_195 L10_15 0.0158
K26649 L191_195 L16_21 0.0303
K26650 L191_195 L158_163 0.0263
K26651 L191_195 L96_100 0.0243
K26652 L191_195 L49_53 0.0349
K26653 L191_195 L186_190 0.0162
K26654 L191_195 L82_87 0.0759
K26655 L191_195 L125_130 0.0304
K26656 L191_195 L159_164 0.0236
K26657 L191_195 L44_92 0.0244
K26658 L191_195 L21_26 0.0267
K26659 L191_195 L84_89 0.0381
K26660 L191_195 L74_79 0.0387
K26661 L191_195 L165_170 0.0311
K26662 L191_195 L56_60 0.0431
K26663 L191_195 L93_97 0.0194
K26664 L191_195 L90_94 0.027
K26665 L191_195 L134_173 0.0307
K26666 L191_195 L139_144 0.0244
K26667 L191_195 L177_181 0.0191
K26668 L191_195 L179_183 0.0209
K26669 L191_195 L162_167 0.0292
K26670 L191_195 L43_91 0.0256
K26671 L191_195 L142_147 0.027
K26672 L191_195 L39_44 0.0306
K26673 L191_195 L123_128 0.0456
K26674 L191_195 L12_17 0.0214
K26675 L191_195 L146_151 0.0383
K26676 L191_195 L61_65 0.0391
K26677 L27_32 L91_95 0.0565
K26678 L27_32 L4_9 0.0779
K26679 L27_32 L202_206 0.0506
K26680 L27_32 L109_114 0.0629
K26681 L27_32 L57_61 0.0709
K26682 L27_32 L53_57 0.0672
K26683 L27_32 L69_73 0.0568
K26684 L27_32 L200_204 0.0366
K26685 L27_32 L145_150 0.0398
K26686 L27_32 L131_136 0.0609
K26687 L27_32 L46_50 0.0318
K26688 L27_32 L196_200 0.0376
K26689 L27_32 L92_96 0.0548
K26690 L27_32 L120_125 0.0891
K26691 L27_32 L167_172 0.1706
K26692 L27_32 L121_126 0.0334
K26693 L27_32 L113_118 0.0515
K26694 L27_32 L9_14 0.0898
K26695 L27_32 L33_38 0.1944
K26696 L27_32 L134_139 0.0598
K26697 L27_32 L124_129 0.0736
K26698 L27_32 L78_83 0.0509
K26699 L27_32 L112_117 0.0414
K26700 L27_32 L40_45 0.0879
K26701 L27_32 L59_63 0.0431
K26702 L27_32 L15_20 0.0787
K26703 L27_32 L178_182 0.0593
K26704 L27_32 L3_8 0.083
K26705 L27_32 L149_154 0.045
K26706 L27_32 L66_70 0.0305
K26707 L27_32 L117_122 0.0422
K26708 L27_32 L158_189 0.1139
K26709 L27_32 L38_43 0.1081
K26710 L27_32 L135_174 0.0853
K26711 L27_32 L115_120 0.0803
K26712 L27_32 L80_85 0.0282
K26713 L27_32 L10_15 0.0691
K26714 L27_32 L16_21 0.1027
K26715 L27_32 L158_163 0.1463
K26716 L27_32 L96_100 0.0498
K26717 L27_32 L49_53 0.0636
K26718 L27_32 L186_190 0.075
K26719 L27_32 L82_87 0.0415
K26720 L27_32 L125_130 0.0992
K26721 L27_32 L159_164 0.1202
K26722 L27_32 L84_89 0.0489
K26723 L27_32 L44_92 0.061
K26724 L27_32 L21_26 0.2112
K26725 L27_32 L74_79 0.0568
K26726 L27_32 L165_170 0.1747
K26727 L27_32 L199_203 0.0289
K26728 L27_32 L75_80 0.029
K26729 L27_32 L70_75 0.0297
K26730 L27_32 L50_54 0.0325
K26731 L27_32 L56_60 0.0534
K26732 L27_32 L93_97 0.0442
K26733 L27_32 L134_173 0.0976
K26734 L27_32 L139_144 0.054
K26735 L27_32 L177_181 0.0754
K26736 L27_32 L111_116 0.0323
K26737 L27_32 L162_167 0.2341
K26738 L27_32 L43_91 0.0633
K26739 L27_32 L39_44 0.101
K26740 L27_32 L123_128 0.0546
K26741 L27_32 L146_151 0.0486
K26742 L27_32 L61_65 0.0746
K26743 L117_122 L91_95 0.0253
K26744 L117_122 L4_9 0.0311
K26745 L117_122 L202_206 0.0439
K26746 L117_122 L109_114 0.0733
K26747 L117_122 L57_61 0.0736
K26748 L117_122 L9_14 0.0312
K26749 L117_122 L53_57 0.0734
K26750 L117_122 L69_73 0.0474
K26751 L117_122 L145_150 0.0194
K26752 L117_122 L131_136 0.0371
K26753 L117_122 L46_50 0.1322
K26754 L117_122 L92_96 0.0245
K26755 L117_122 L120_125 0.0507
K26756 L117_122 L7_12 0.0349
K26757 L117_122 L167_172 0.0379
K26758 L117_122 L121_126 0.1506
K26759 L117_122 L33_38 0.0378
K26760 L117_122 L124_129 0.0741
K26761 L117_122 L78_83 0.0437
K26762 L117_122 L134_139 0.0252
K26763 L117_122 L40_45 0.0304
K26764 L117_122 L15_20 0.0249
K26765 L117_122 L179_183 0.0351
K26766 L117_122 L158_189 0.0313
K26767 L117_122 L66_70 0.0481
K26768 L117_122 L98_102 0.0247
K26769 L117_122 L178_182 0.0249
K26770 L117_122 L3_8 0.0328
K26771 L117_122 L149_154 0.0233
K26772 L117_122 L38_43 0.0352
K26773 L117_122 L113_118 0.1134
K26774 L117_122 L135_174 0.0305
K26775 L117_122 L115_120 0.0506
K26776 L117_122 L80_85 0.0405
K26777 L117_122 L10_15 0.0249
K26778 L117_122 L16_21 0.0503
K26779 L117_122 L158_163 0.0397
K26780 L117_122 L96_100 0.0239
K26781 L117_122 L49_53 0.0726
K26782 L117_122 L186_190 0.025
K26783 L117_122 L82_87 0.0464
K26784 L117_122 L125_130 0.0506
K26785 L117_122 L159_164 0.0353
K26786 L117_122 L84_89 0.0336
K26787 L117_122 L44_92 0.0251
K26788 L117_122 L21_26 0.0425
K26789 L117_122 L74_79 0.0358
K26790 L117_122 L165_170 0.038
K26791 L117_122 L199_203 0.043
K26792 L117_122 L75_80 0.0427
K26793 L117_122 L70_75 0.0453
K26794 L117_122 L50_54 0.1405
K26795 L117_122 L56_60 0.1114
K26796 L117_122 L93_97 0.0198
K26797 L117_122 L90_94 0.0262
K26798 L117_122 L134_173 0.034
K26799 L117_122 L139_144 0.0246
K26800 L117_122 L177_181 0.0312
K26801 L117_122 L111_116 0.1506
K26802 L117_122 L162_167 0.0403
K26803 L117_122 L43_91 0.026
K26804 L117_122 L142_147 0.0255
K26805 L117_122 L39_44 0.0339
K26806 L117_122 L123_128 0.1134
K26807 L117_122 L12_17 0.0349
K26808 L117_122 L146_151 0.0336
K26809 L117_122 L61_65 0.0734
K26810 L126_127 L115_179 0.0295
K26811 L126_127 L196_197 0.0512
K26812 L126_127 L91_92 0.0244
K26813 L126_127 L146_147 0.0246
K26814 L126_127 L4_5 0.0208
K26815 L126_127 L41_42 0.0335
K26816 L126_127 L200_201 0.0479
K26817 L126_127 L36_37 0.0406
K26818 L126_127 L131_132 0.0337
K26819 L126_127 L92_93 0.0236
K26820 L126_127 L187_188 0.0284
K26821 L126_127 L121_122 0.3407
K26822 L126_127 L134_135 0.0299
K26823 L126_127 L104_105 0.0181
K26824 L126_127 L151_210 0.0336
K26825 L126_127 L112_113 0.1369
K26826 L126_127 L59_60 0.1674
K26827 L126_127 L38_39 0.037
K26828 L126_127 L96_97 0.0229
K26829 L126_127 L78_79 0.0386
K26830 L126_127 L44_45 0.0298
K26831 L126_127 L47_48 0.1173
K26832 L126_127 L6_53 0.0588
K26833 L126_127 L149_150 0.0223
K26834 L126_127 L98_99 0.0237
K26835 L126_127 L113_114 0.0854
K26836 L126_127 L80_81 0.0462
K26837 L126_127 L87_88 0.0372
K26838 L126_127 L9_10 0.0252
K26839 L126_127 L117_118 0.1593
K26840 L126_127 L116_117 0.2387
K26841 L126_127 L7_8 0.0278
K26842 L126_127 L82_83 0.0414
K26843 L126_127 L199_200 0.0496
K26844 L126_127 L58_59 0.2623
K26845 L126_127 L70_71 0.0528
K26846 L126_127 L68_69 0.0446
K26847 L126_127 L89_102 0.0198
K26848 L126_127 L50_51 0.1684
K26849 L126_127 L90_91 0.0253
K26850 L126_127 L139_140 0.0236
K26851 L126_127 L111_112 0.1829
K26852 L126_127 L162_163 0.0421
K26853 L126_127 L137_138 0.0254
K26854 L126_127 L179_180 0.0279
K26855 L126_127 L12_13 0.0281
K26856 L126_127 L142_143 0.0246
K26857 L126_127 L123_124 0.0934
K26858 L126_127 L191_192 0.0524
K26859 L126_127 L39_40 0.0354
K26860 L126_127 L201_202 0.0438
K26861 L158_189 L91_95 0.0283
K26862 L158_189 L202_206 0.032
K26863 L158_189 L109_114 0.0526
K26864 L158_189 L57_61 0.0537
K26865 L158_189 L53_57 0.0531
K26866 L158_189 L69_73 0.0347
K26867 L158_189 L200_204 0.0246
K26868 L158_189 L145_150 0.0221
K26869 L158_189 L131_136 0.0361
K26870 L158_189 L46_50 0.0241
K26871 L158_189 L196_200 0.0252
K26872 L158_189 L120_125 0.0833
K26873 L158_189 L7_12 0.1015
K26874 L158_189 L167_172 0.083
K26875 L158_189 L121_126 0.0245
K26876 L158_189 L33_38 0.08
K26877 L158_189 L124_129 0.0546
K26878 L158_189 L78_83 0.0318
K26879 L158_189 L112_117 0.0312
K26880 L158_189 L40_45 0.0426
K26881 L158_189 L59_63 0.0313
K26882 L158_189 L15_20 0.1266
K26883 L158_189 L179_183 0.1124
K26884 L158_189 L98_102 0.0246
K26885 L158_189 L178_182 0.0968
K26886 L158_189 L3_8 0.1015
K26887 L158_189 L66_70 0.0204
K26888 L158_189 L38_43 0.0555
K26889 L158_189 L135_174 0.0431
K26890 L158_189 L115_120 0.0802
K26891 L158_189 L80_85 0.019
K26892 L158_189 L10_15 0.1062
K26893 L158_189 L16_21 0.0813
K26894 L158_189 L113_118 0.0395
K26895 L158_189 L49_53 0.052
K26896 L158_189 L186_190 0.1673
K26897 L158_189 L125_130 0.0844
K26898 L158_189 L159_164 0.1862
K26899 L158_189 L84_89 0.0301
K26900 L158_189 L82_87 0.027
K26901 L158_189 L21_26 0.1272
K26902 L158_189 L74_79 0.0337
K26903 L158_189 L165_170 0.0707
K26904 L158_189 L199_203 0.0196
K26905 L158_189 L75_80 0.0195
K26906 L158_189 L70_75 0.02
K26907 L158_189 L50_54 0.0243
K26908 L158_189 L56_60 0.0395
K26909 L158_189 L93_97 0.0235
K26910 L158_189 L90_94 0.0279
K26911 L158_189 L111_116 0.0243
K26912 L158_189 L162_167 0.1482
K26913 L158_189 L43_91 0.0304
K26914 L158_189 L142_147 0.0263
K26915 L158_189 L123_128 0.0398
K26916 L158_189 L12_17 0.1127
K26917 L158_189 L146_151 0.0303
K26918 L158_189 L61_65 0.054
K26919 L113_114 L199_200 0.04
K26920 L113_114 L196_197 0.045
K26921 L113_114 L91_92 0.0295
K26922 L113_114 L4_5 0.0372
K26923 L113_114 L41_42 0.0405
K26924 L113_114 L200_201 0.0427
K26925 L113_114 L131_132 0.0407
K26926 L113_114 L92_93 0.0288
K26927 L113_114 L187_188 0.071
K26928 L113_114 L21_65 0.13
K26929 L113_114 L121_122 0.0952
K26930 L113_114 L134_135 0.0377
K26931 L113_114 L104_105 0.0212
K26932 L113_114 L151_210 0.0364
K26933 L113_114 L59_60 0.1537
K26934 L113_114 L38_39 0.0488
K26935 L113_114 L96_97 0.0276
K26936 L113_114 L78_79 0.0425
K26937 L113_114 L44_45 0.0375
K26938 L113_114 L47_48 0.1765
K26939 L113_114 L149_150 0.0265
K26940 L113_114 L98_99 0.0275
K26941 L113_114 L80_81 0.0381
K26942 L113_114 L87_88 0.037
K26943 L113_114 L146_147 0.028
K26944 L113_114 L127_128 0.1369
K26945 L113_114 L157_158 0.0718
K26946 L113_114 L129_130 0.1369
K26947 L113_114 L21_22 0.0855
K26948 L113_114 L117_118 0.1933
K26949 L113_114 L116_117 0.0993
K26950 L113_114 L82_83 0.0412
K26951 L113_114 L58_59 0.0931
K26952 L113_114 L70_71 0.0418
K26953 L113_114 L68_69 0.0448
K26954 L113_114 L89_102 0.0224
K26955 L113_114 L36_37 0.0521
K26956 L113_114 L90_91 0.0302
K26957 L113_114 L139_140 0.0289
K26958 L113_114 L162_163 0.0696
K26959 L113_114 L137_138 0.0303
K26960 L113_114 L12_13 0.0723
K26961 L113_114 L142_143 0.0289
K26962 L113_114 L123_124 0.2392
K26963 L113_114 L191_192 0.0406
K26964 L113_114 L39_40 0.0471
K26965 L113_114 L156_157 0.0791
K26966 L113_114 L201_202 0.0437
K26967 L113_118 L91_95 0.0279
K26968 L113_118 L4_9 0.0395
K26969 L113_118 L202_206 0.0466
K26970 L113_118 L109_114 0.1134
K26971 L113_118 L57_61 0.1104
K26972 L113_118 L53_57 0.1114
K26973 L113_118 L69_73 0.0513
K26974 L113_118 L200_204 0.0466
K26975 L113_118 L145_150 0.0213
K26976 L113_118 L131_136 0.041
K26977 L113_118 L46_50 0.0797
K26978 L113_118 L196_200 0.0489
K26979 L113_118 L92_96 0.027
K26980 L113_118 L120_125 0.069
K26981 L113_118 L7_12 0.0457
K26982 L113_118 L167_172 0.0444
K26983 L113_118 L121_126 0.0796
K26984 L113_118 L134_139 0.028
K26985 L113_118 L9_14 0.0396
K26986 L113_118 L33_38 0.0442
K26987 L113_118 L124_129 0.1103
K26988 L113_118 L78_83 0.0464
K26989 L113_118 L112_117 0.1145
K26990 L113_118 L40_45 0.0344
K26991 L113_118 L59_63 0.1076
K26992 L113_118 L15_20 0.0312
K26993 L113_118 L179_183 0.0461
K26994 L113_118 L66_70 0.041
K26995 L113_118 L98_102 0.0267
K26996 L113_118 L142_147 0.0278
K26997 L113_118 L178_182 0.0313
K26998 L113_118 L3_8 0.0423
K26999 L113_118 L149_154 0.0254
K27000 L113_118 L38_43 0.0398
K27001 L113_118 L135_174 0.0345
K27002 L113_118 L115_120 0.0692
K27003 L113_118 L80_85 0.0357
K27004 L113_118 L10_15 0.0312
K27005 L113_118 L16_21 0.0673
K27006 L113_118 L158_163 0.0493
K27007 L113_118 L96_100 0.0261
K27008 L113_118 L49_53 0.1104
K27009 L113_118 L186_190 0.0313
K27010 L113_118 L125_130 0.0681
K27011 L113_118 L159_164 0.0434
K27012 L113_118 L44_92 0.0279
K27013 L113_118 L21_26 0.0544
K27014 L113_118 L84_89 0.0361
K27015 L113_118 L74_79 0.0391
K27016 L113_118 L165_170 0.0446
K27017 L113_118 L199_203 0.0375
K27018 L113_118 L75_80 0.0373
K27019 L113_118 L70_75 0.0391
K27020 L113_118 L50_54 0.0802
K27021 L113_118 L93_97 0.0219
K27022 L113_118 L90_94 0.0287
K27023 L113_118 L134_173 0.0384
K27024 L113_118 L139_144 0.0271
K27025 L113_118 L177_181 0.0398
K27026 L113_118 L111_116 0.0818
K27027 L113_118 L162_167 0.0488
K27028 L113_118 L43_91 0.0289
K27029 L113_118 L39_44 0.0383
K27030 L113_118 L12_17 0.0455
K27031 L113_118 L146_151 0.0362
K27032 L113_118 L61_65 0.1076
K27033 L135_174 L91_95 0.0812
K27034 L135_174 L4_9 0.0337
K27035 L135_174 L109_114 0.0385
K27036 L135_174 L57_61 0.0418
K27037 L135_174 L53_57 0.04
K27038 L135_174 L69_73 0.0565
K27039 L135_174 L200_204 0.0342
K27040 L135_174 L131_136 0.0767
K27041 L135_174 L46_50 0.0231
K27042 L135_174 L196_200 0.0346
K27043 L135_174 L92_96 0.0874
K27044 L135_174 L120_125 0.0445
K27045 L135_174 L7_12 0.0351
K27046 L135_174 L167_172 0.1538
K27047 L135_174 L121_126 0.0246
K27048 L135_174 L134_139 0.1128
K27049 L135_174 L9_14 0.0362
K27050 L135_174 L33_38 0.1403
K27051 L135_174 L124_129 0.0438
K27052 L135_174 L78_83 0.0531
K27053 L135_174 L112_117 0.0298
K27054 L135_174 L59_63 0.0311
K27055 L135_174 L179_183 0.0354
K27056 L135_174 L66_70 0.0273
K27057 L135_174 L98_102 0.0592
K27058 L135_174 L142_147 0.068
K27059 L135_174 L3_8 0.0333
K27060 L135_174 L149_154 0.067
K27061 L135_174 L38_43 0.1794
K27062 L135_174 L115_120 0.0418
K27063 L135_174 L80_85 0.0263
K27064 L135_174 L16_21 0.047
K27065 L135_174 L158_163 0.0678
K27066 L135_174 L96_100 0.0748
K27067 L135_174 L49_53 0.0384
K27068 L135_174 L82_87 0.0407
K27069 L135_174 L125_130 0.0474
K27070 L135_174 L84_89 0.0616
K27071 L135_174 L202_206 0.0536
K27072 L135_174 L44_92 0.1041
K27073 L135_174 L21_26 0.0571
K27074 L135_174 L74_79 0.0705
K27075 L135_174 L165_170 0.1129
K27076 L135_174 L199_203 0.0268
K27077 L135_174 L75_80 0.0267
K27078 L135_174 L70_75 0.027
K27079 L135_174 L50_54 0.0236
K27080 L135_174 L56_60 0.0355
K27081 L135_174 L90_94 0.0742
K27082 L135_174 L134_173 0.305
K27083 L135_174 L139_144 0.0922
K27084 L135_174 L177_181 0.0339
K27085 L135_174 L111_116 0.0236
K27086 L135_174 L162_167 0.095
K27087 L135_174 L43_91 0.094
K27088 L135_174 L39_44 0.2296
K27089 L135_174 L123_128 0.0367
K27090 L135_174 L12_17 0.0377
K27091 L135_174 L146_151 0.0625
K27092 L135_174 L61_65 0.0436
K27093 L87_88 L115_179 0.0239
K27094 L87_88 L196_197 0.13
K27095 L87_88 L91_92 0.0438
K27096 L87_88 L4_5 0.0185
K27097 L87_88 L41_42 0.0564
K27098 L87_88 L200_201 0.1479
K27099 L87_88 L36_37 0.0523
K27100 L87_88 L131_132 0.0558
K27101 L87_88 L92_93 0.0406
K27102 L87_88 L187_188 0.0254
K27103 L87_88 L21_65 0.0403
K27104 L87_88 L121_122 0.0376
K27105 L87_88 L9_10 0.0225
K27106 L87_88 L134_135 0.0455
K27107 L87_88 L112_113 0.0363
K27108 L87_88 L59_60 0.0403
K27109 L87_88 L38_39 0.0472
K27110 L87_88 L78_79 0.1593
K27111 L87_88 L44_45 0.0459
K27112 L87_88 L47_48 0.0335
K27113 L87_88 L6_53 0.0364
K27114 L87_88 L149_150 0.0416
K27115 L87_88 L98_99 0.05
K27116 L87_88 L80_81 0.0934
K27117 L87_88 L146_147 0.0543
K27118 L87_88 L127_128 0.0401
K27119 L87_88 L157_158 0.0307
K27120 L87_88 L96_97 0.0414
K27121 L87_88 L129_130 0.0401
K27122 L87_88 L117_118 0.0381
K27123 L87_88 L116_117 0.0359
K27124 L87_88 L21_22 0.0324
K27125 L87_88 L7_8 0.0235
K27126 L87_88 L82_83 0.3407
K27127 L87_88 L199_200 0.0878
K27128 L87_88 L58_59 0.0377
K27129 L87_88 L70_71 0.0854
K27130 L87_88 L68_69 0.1605
K27131 L87_88 L50_51 0.0345
K27132 L87_88 L90_91 0.0476
K27133 L87_88 L139_140 0.0402
K27134 L87_88 L111_112 0.0344
K27135 L87_88 L162_163 0.0363
K27136 L87_88 L137_138 0.047
K27137 L87_88 L179_180 0.0234
K27138 L87_88 L12_13 0.0244
K27139 L87_88 L142_143 0.0483
K27140 L87_88 L123_124 0.0411
K27141 L87_88 L191_192 0.077
K27142 L87_88 L39_40 0.0449
K27143 L87_88 L156_157 0.0315
K27144 L87_88 L201_202 0.2081
K27145 L10_15 L91_95 0.0206
K27146 L10_15 L4_9 0.1673
K27147 L10_15 L109_114 0.0417
K27148 L10_15 L57_61 0.0421
K27149 L10_15 L53_57 0.0423
K27150 L10_15 L69_73 0.0258
K27151 L10_15 L200_204 0.0189
K27152 L10_15 L131_136 0.0259
K27153 L10_15 L46_50 0.0195
K27154 L10_15 L196_200 0.0193
K27155 L10_15 L92_96 0.0207
K27156 L10_15 L120_125 0.0598
K27157 L10_15 L7_12 0.0891
K27158 L10_15 L167_172 0.05
K27159 L10_15 L121_126 0.0194
K27160 L10_15 L134_139 0.022
K27161 L10_15 L9_14 0.1916
K27162 L10_15 L33_38 0.051
K27163 L10_15 L124_129 0.0412
K27164 L10_15 L78_83 0.0238
K27165 L10_15 L112_117 0.0249
K27166 L10_15 L59_63 0.0249
K27167 L10_15 L179_183 0.0811
K27168 L10_15 L66_70 0.0158
K27169 L10_15 L98_102 0.0181
K27170 L10_15 L142_147 0.0191
K27171 L10_15 L3_8 0.1144
K27172 L10_15 L149_154 0.0184
K27173 L10_15 L38_43 0.0379
K27174 L10_15 L115_120 0.0604
K27175 L10_15 L80_85 0.0147
K27176 L10_15 L16_21 0.0597
K27177 L10_15 L158_163 0.1366
K27178 L10_15 L96_100 0.0195
K27179 L10_15 L49_53 0.0421
K27180 L10_15 L82_87 0.0206
K27181 L10_15 L125_130 0.0581
K27182 L10_15 L84_89 0.0223
K27183 L10_15 L202_206 0.0237
K27184 L10_15 L44_92 0.0221
K27185 L10_15 L21_26 0.0877
K27186 L10_15 L74_79 0.0247
K27187 L10_15 L165_170 0.0437
K27188 L10_15 L199_203 0.0151
K27189 L10_15 L75_80 0.0151
K27190 L10_15 L70_75 0.0155
K27191 L10_15 L50_54 0.0195
K27192 L10_15 L56_60 0.0313
K27193 L10_15 L90_94 0.0203
K27194 L10_15 L134_173 0.0382
K27195 L10_15 L139_144 0.0206
K27196 L10_15 L177_181 0.1266
K27197 L10_15 L111_116 0.0195
K27198 L10_15 L162_167 0.0728
K27199 L10_15 L43_91 0.0219
K27200 L10_15 L39_44 0.0386
K27201 L10_15 L123_128 0.031
K27202 L10_15 L12_17 0.0861
K27203 L10_15 L146_151 0.0222
K27204 L10_15 L61_65 0.0417
K27205 L146_147 L199_200 0.0387
K27206 L146_147 L115_179 0.0212
K27207 L146_147 L196_197 0.0521
K27208 L146_147 L91_92 0.1015
K27209 L146_147 L4_5 0.0171
K27210 L146_147 L41_42 0.0857
K27211 L146_147 L200_201 0.0533
K27212 L146_147 L36_37 0.0599
K27213 L146_147 L131_132 0.0898
K27214 L146_147 L92_93 0.0884
K27215 L146_147 L187_188 0.0237
K27216 L146_147 L21_65 0.0327
K27217 L146_147 L121_122 0.0252
K27218 L146_147 L9_10 0.0209
K27219 L146_147 L134_135 0.0785
K27220 L146_147 L104_105 0.0867
K27221 L146_147 L151_210 0.0945
K27222 L146_147 L112_113 0.026
K27223 L146_147 L59_60 0.0281
K27224 L146_147 L38_39 0.0585
K27225 L146_147 L96_97 0.1015
K27226 L146_147 L78_79 0.1583
K27227 L146_147 L44_45 0.0757
K27228 L146_147 L47_48 0.0239
K27229 L146_147 L6_53 0.0293
K27230 L146_147 L127_128 0.0278
K27231 L146_147 L157_158 0.0294
K27232 L146_147 L129_130 0.0329
K27233 L146_147 L21_22 0.0295
K27234 L146_147 L117_118 0.027
K27235 L146_147 L116_117 0.0244
K27236 L146_147 L7_8 0.0211
K27237 L146_147 L58_59 0.0252
K27238 L146_147 L70_71 0.038
K27239 L146_147 L68_69 0.0716
K27240 L146_147 L89_102 0.1363
K27241 L146_147 L50_51 0.0235
K27242 L146_147 L90_91 0.1127
K27243 L146_147 L139_140 0.0953
K27244 L146_147 L111_112 0.0236
K27245 L146_147 L162_163 0.0361
K27246 L146_147 L137_138 0.1284
K27247 L146_147 L179_180 0.0212
K27248 L146_147 L12_13 0.0222
K27249 L146_147 L142_143 0.1832
K27250 L146_147 L123_124 0.0309
K27251 L146_147 L191_192 0.0356
K27252 L146_147 L39_40 0.0569
K27253 L146_147 L156_157 0.0296
K27254 L146_147 L201_202 0.0851
K27255 L127_128 L115_179 0.0377
K27256 L127_128 L196_197 0.0532
K27257 L127_128 L91_92 0.0282
K27258 L127_128 L4_5 0.0256
K27259 L127_128 L41_42 0.0394
K27260 L127_128 L200_201 0.0496
K27261 L127_128 L36_37 0.0494
K27262 L127_128 L131_132 0.0396
K27263 L127_128 L92_93 0.0272
K27264 L127_128 L187_188 0.0362
K27265 L127_128 L121_122 0.1877
K27266 L127_128 L134_135 0.035
K27267 L127_128 L104_105 0.0204
K27268 L127_128 L151_210 0.0373
K27269 L127_128 L112_113 0.1829
K27270 L127_128 L59_60 0.2623
K27271 L127_128 L38_39 0.0447
K27272 L127_128 L96_97 0.0262
K27273 L127_128 L78_79 0.0436
K27274 L127_128 L44_45 0.0349
K27275 L127_128 L47_48 0.1492
K27276 L127_128 L6_53 0.0837
K27277 L127_128 L149_150 0.0253
K27278 L127_128 L98_99 0.0269
K27279 L127_128 L80_81 0.0449
K27280 L127_128 L9_10 0.031
K27281 L127_128 L117_118 0.2387
K27282 L127_128 L116_117 0.1593
K27283 L127_128 L7_8 0.0351
K27284 L127_128 L82_83 0.0449
K27285 L127_128 L199_200 0.0479
K27286 L127_128 L58_59 0.1674
K27287 L127_128 L70_71 0.0508
K27288 L127_128 L68_69 0.0498
K27289 L127_128 L89_102 0.0222
K27290 L127_128 L50_51 0.13
K27291 L127_128 L90_91 0.0292
K27292 L127_128 L139_140 0.0273
K27293 L127_128 L111_112 0.1369
K27294 L127_128 L162_163 0.0547
K27295 L127_128 L137_138 0.0293
K27296 L127_128 L179_180 0.0353
K27297 L127_128 L12_13 0.0356
K27298 L127_128 L142_143 0.0281
K27299 L127_128 L123_124 0.1877
K27300 L127_128 L191_192 0.0502
K27301 L127_128 L39_40 0.0425
K27302 L127_128 L201_202 0.0479
K27303 L158_163 L91_95 0.0364
K27304 L158_163 L202_206 0.041
K27305 L158_163 L109_114 0.0634
K27306 L158_163 L57_61 0.0666
K27307 L158_163 L53_57 0.0648
K27308 L158_163 L69_73 0.0446
K27309 L158_163 L200_204 0.0315
K27310 L158_163 L145_150 0.0328
K27311 L158_163 L131_136 0.0464
K27312 L158_163 L46_50 0.0303
K27313 L158_163 L196_200 0.0323
K27314 L158_163 L120_125 0.0968
K27315 L158_163 L7_12 0.0989
K27316 L158_163 L167_172 0.1081
K27317 L158_163 L121_126 0.0312
K27318 L158_163 L33_38 0.1038
K27319 L158_163 L124_129 0.0687
K27320 L158_163 L78_83 0.0408
K27321 L158_163 L112_117 0.0393
K27322 L158_163 L40_45 0.0666
K27323 L158_163 L59_63 0.0398
K27324 L158_163 L15_20 0.1578
K27325 L158_163 L179_183 0.1049
K27326 L158_163 L98_102 0.0316
K27327 L158_163 L178_182 0.1284
K27328 L158_163 L3_8 0.093
K27329 L158_163 L66_70 0.0262
K27330 L158_163 L38_43 0.0717
K27331 L158_163 L115_120 0.0904
K27332 L158_163 L80_85 0.0244
K27333 L158_163 L16_21 0.0989
K27334 L158_163 L49_53 0.0628
K27335 L158_163 L186_190 0.2077
K27336 L158_163 L125_130 0.1022
K27337 L158_163 L159_164 0.305
K27338 L158_163 L84_89 0.0387
K27339 L158_163 L82_87 0.0347
K27340 L158_163 L21_26 0.1599
K27341 L158_163 L74_79 0.0434
K27342 L158_163 L165_170 0.0915
K27343 L158_163 L199_203 0.0251
K27344 L158_163 L75_80 0.025
K27345 L158_163 L70_75 0.0256
K27346 L158_163 L50_54 0.0306
K27347 L158_163 L56_60 0.0497
K27348 L158_163 L93_97 0.0351
K27349 L158_163 L90_94 0.0359
K27350 L158_163 L111_116 0.0307
K27351 L158_163 L162_167 0.1944
K27352 L158_163 L43_91 0.0391
K27353 L158_163 L142_147 0.0339
K27354 L158_163 L123_128 0.0506
K27355 L158_163 L12_17 0.1139
K27356 L158_163 L146_151 0.0389
K27357 L158_163 L61_65 0.0679
K27358 L49_53 L91_95 0.0301
K27359 L49_53 L4_9 0.0546
K27360 L49_53 L9_14 0.0544
K27361 L49_53 L200_204 0.0404
K27362 L49_53 L145_150 0.0228
K27363 L49_53 L131_136 0.0435
K27364 L49_53 L46_50 0.056
K27365 L49_53 L196_200 0.042
K27366 L49_53 L92_96 0.0293
K27367 L49_53 L120_125 0.1022
K27368 L49_53 L7_12 0.0667
K27369 L49_53 L167_172 0.051
K27370 L49_53 L121_126 0.0541
K27371 L49_53 L134_139 0.0305
K27372 L49_53 L33_38 0.0514
K27373 L49_53 L112_117 0.0734
K27374 L49_53 L40_45 0.0385
K27375 L49_53 L59_63 0.072
K27376 L49_53 L15_20 0.0417
K27377 L49_53 L179_183 0.0655
K27378 L49_53 L66_70 0.035
K27379 L49_53 L98_102 0.0282
K27380 L49_53 L142_147 0.0294
K27381 L49_53 L178_182 0.0418
K27382 L49_53 L3_8 0.0602
K27383 L49_53 L149_154 0.027
K27384 L49_53 L38_43 0.0444
K27385 L49_53 L115_120 0.1053
K27386 L49_53 L80_85 0.0313
K27387 L49_53 L16_21 0.1002
K27388 L49_53 L96_100 0.0282
K27389 L49_53 L165_170 0.0509
K27390 L49_53 L186_190 0.0412
K27391 L49_53 L82_87 0.0425
K27392 L49_53 L125_130 0.0977
K27393 L49_53 L159_164 0.0549
K27394 L49_53 L84_89 0.0377
K27395 L49_53 L44_92 0.0306
K27396 L49_53 L21_26 0.0735
K27397 L49_53 L74_79 0.0415
K27398 L49_53 L199_203 0.0324
K27399 L49_53 L75_80 0.0325
K27400 L49_53 L70_75 0.0337
K27401 L49_53 L50_54 0.0558
K27402 L49_53 L56_60 0.1103
K27403 L49_53 L93_97 0.0238
K27404 L49_53 L90_94 0.0309
K27405 L49_53 L134_173 0.0427
K27406 L49_53 L139_144 0.0292
K27407 L49_53 L177_181 0.054
K27408 L49_53 L111_116 0.0554
K27409 L49_53 L162_167 0.0592
K27410 L49_53 L43_91 0.0315
K27411 L49_53 L39_44 0.0429
K27412 L49_53 L123_128 0.1034
K27413 L49_53 L12_17 0.0654
K27414 L49_53 L146_151 0.0376
K27415 L186_190 L91_95 0.0218
K27416 L186_190 L4_9 0.1062
K27417 L186_190 L109_114 0.0417
K27418 L186_190 L57_61 0.0418
K27419 L186_190 L53_57 0.0417
K27420 L186_190 L69_73 0.0268
K27421 L186_190 L200_204 0.0194
K27422 L186_190 L131_136 0.0275
K27423 L186_190 L46_50 0.0194
K27424 L186_190 L196_200 0.0199
K27425 L186_190 L92_96 0.022
K27426 L186_190 L120_125 0.0622
K27427 L186_190 L7_12 0.0789
K27428 L186_190 L167_172 0.0575
K27429 L186_190 L121_126 0.0195
K27430 L186_190 L134_139 0.0237
K27431 L186_190 L9_14 0.1266
K27432 L186_190 L33_38 0.0561
K27433 L186_190 L124_129 0.0421
K27434 L186_190 L78_83 0.0247
K27435 L186_190 L112_117 0.025
K27436 L186_190 L59_63 0.0249
K27437 L186_190 L179_183 0.0861
K27438 L186_190 L66_70 0.0161
K27439 L186_190 L98_102 0.0191
K27440 L186_190 L142_147 0.0203
K27441 L186_190 L3_8 0.088
K27442 L186_190 L149_154 0.0195
K27443 L186_190 L38_43 0.041
K27444 L186_190 L115_120 0.0615
K27445 L186_190 L80_85 0.0151
K27446 L186_190 L16_21 0.0598
K27447 L186_190 L96_100 0.0206
K27448 L186_190 L82_87 0.0212
K27449 L186_190 L125_130 0.0615
K27450 L186_190 L84_89 0.0234
K27451 L186_190 L202_206 0.0248
K27452 L186_190 L44_92 0.0235
K27453 L186_190 L21_26 0.0873
K27454 L186_190 L74_79 0.0259
K27455 L186_190 L165_170 0.0494
K27456 L186_190 L199_203 0.0155
K27457 L186_190 L75_80 0.0154
K27458 L186_190 L70_75 0.0158
K27459 L186_190 L50_54 0.0194
K27460 L186_190 L56_60 0.0312
K27461 L186_190 L90_94 0.0215
K27462 L186_190 L134_173 0.0424
K27463 L186_190 L139_144 0.0221
K27464 L186_190 L177_181 0.1268
K27465 L186_190 L111_116 0.0195
K27466 L186_190 L162_167 0.0897
K27467 L186_190 L43_91 0.0232
K27468 L186_190 L39_44 0.0419
K27469 L186_190 L123_128 0.0313
K27470 L186_190 L12_17 0.0811
K27471 L186_190 L146_151 0.0234
K27472 L186_190 L61_65 0.0417
K27473 L157_158 L115_179 0.1004
K27474 L157_158 L196_197 0.0323
K27475 L157_158 L91_92 0.0335
K27476 L157_158 L4_5 0.0794
K27477 L157_158 L41_42 0.0449
K27478 L157_158 L200_201 0.0312
K27479 L157_158 L36_37 0.0615
K27480 L157_158 L131_132 0.0453
K27481 L157_158 L92_93 0.0335
K27482 L157_158 L187_188 0.1891
K27483 L157_158 L121_122 0.0412
K27484 L157_158 L134_135 0.0457
K27485 L157_158 L104_105 0.0233
K27486 L157_158 L151_210 0.0339
K27487 L157_158 L112_113 0.0518
K27488 L157_158 L59_60 0.0536
K27489 L157_158 L38_39 0.0627
K27490 L157_158 L96_97 0.0313
K27491 L157_158 L78_79 0.0395
K27492 L157_158 L44_45 0.0453
K27493 L157_158 L47_48 0.0476
K27494 L157_158 L6_53 0.1048
K27495 L157_158 L149_150 0.0296
K27496 L157_158 L98_99 0.0294
K27497 L157_158 L80_81 0.0268
K27498 L157_158 L9_10 0.1006
K27499 L157_158 L117_118 0.0531
K27500 L157_158 L116_117 0.0407
K27501 L157_158 L7_8 0.1006
K27502 L157_158 L82_83 0.0339
K27503 L157_158 L199_200 0.0275
K27504 L157_158 L58_59 0.041
K27505 L157_158 L70_71 0.0281
K27506 L157_158 L68_69 0.0355
K27507 L157_158 L89_102 0.0232
K27508 L157_158 L50_51 0.04
K27509 L157_158 L90_91 0.0335
K27510 L157_158 L139_140 0.0337
K27511 L157_158 L111_112 0.0402
K27512 L157_158 L162_163 0.1549
K27513 L157_158 L137_138 0.0337
K27514 L157_158 L179_180 0.1076
K27515 L157_158 L12_13 0.1234
K27516 L157_158 L142_143 0.0315
K27517 L157_158 L123_124 0.0783
K27518 L157_158 L191_192 0.0268
K27519 L157_158 L39_40 0.0624
K27520 L157_158 L201_202 0.0355
K27521 L21_22 L115_179 0.1029
K27522 L21_22 L196_197 0.0344
K27523 L21_22 L91_92 0.0334
K27524 L21_22 L4_5 0.0725
K27525 L21_22 L41_42 0.0458
K27526 L21_22 L200_201 0.0332
K27527 L21_22 L36_37 0.0635
K27528 L21_22 L131_132 0.0454
K27529 L21_22 L92_93 0.0331
K27530 L21_22 L187_188 0.1556
K27531 L21_22 L121_122 0.0464
K27532 L21_22 L134_135 0.0442
K27533 L21_22 L104_105 0.0231
K27534 L21_22 L151_210 0.0351
K27535 L21_22 L112_113 0.0597
K27536 L21_22 L59_60 0.064
K27537 L21_22 L38_39 0.0623
K27538 L21_22 L96_97 0.031
K27539 L21_22 L78_79 0.0416
K27540 L21_22 L44_45 0.0446
K27541 L21_22 L47_48 0.0558
K27542 L21_22 L6_53 0.1332
K27543 L21_22 L149_150 0.029
K27544 L21_22 L98_99 0.0296
K27545 L21_22 L80_81 0.0285
K27546 L21_22 L9_10 0.091
K27547 L21_22 L117_118 0.0616
K27548 L21_22 L116_117 0.0458
K27549 L21_22 L7_8 0.1076
K27550 L21_22 L82_83 0.0359
K27551 L21_22 L199_200 0.0292
K27552 L21_22 L58_59 0.0468
K27553 L21_22 L70_71 0.0301
K27554 L21_22 L68_69 0.0382
K27555 L21_22 L89_102 0.0235
K27556 L21_22 L50_51 0.0453
K27557 L21_22 L90_91 0.0337
K27558 L21_22 L139_140 0.0328
K27559 L21_22 L111_112 0.045
K27560 L21_22 L162_163 0.1299
K27561 L21_22 L137_138 0.0335
K27562 L21_22 L179_180 0.1006
K27563 L21_22 L12_13 0.1375
K27564 L21_22 L142_143 0.0313
K27565 L21_22 L123_124 0.0972
K27566 L21_22 L191_192 0.0286
K27567 L21_22 L39_40 0.0609
K27568 L21_22 L201_202 0.0375
K27569 L84_89 L91_95 0.0939
K27570 L84_89 L4_9 0.026
K27571 L84_89 L202_206 0.1053
K27572 L84_89 L109_114 0.0376
K27573 L84_89 L57_61 0.0415
K27574 L84_89 L53_57 0.0395
K27575 L84_89 L69_73 0.1002
K27576 L84_89 L200_204 0.0503
K27577 L84_89 L145_150 0.0598
K27578 L84_89 L46_50 0.0253
K27579 L84_89 L196_200 0.05
K27580 L84_89 L92_96 0.0802
K27581 L84_89 L7_12 0.0281
K27582 L84_89 L167_172 0.0586
K27583 L84_89 L121_126 0.0276
K27584 L84_89 L134_139 0.0735
K27585 L84_89 L33_38 0.0593
K27586 L84_89 L124_129 0.0435
K27587 L84_89 L78_83 0.1086
K27588 L84_89 L112_117 0.0325
K27589 L84_89 L40_45 0.0625
K27590 L84_89 L59_63 0.0348
K27591 L84_89 L15_20 0.0234
K27592 L84_89 L179_183 0.028
K27593 L84_89 L66_70 0.0383
K27594 L84_89 L98_102 0.1262
K27595 L84_89 L142_147 0.1131
K27596 L84_89 L178_182 0.0212
K27597 L84_89 L3_8 0.0264
K27598 L84_89 L149_154 0.0813
K27599 L84_89 L38_43 0.0767
K27600 L84_89 L80_85 0.039
K27601 L84_89 L96_100 0.0833
K27602 L84_89 L82_87 0.0692
K27603 L84_89 L159_164 0.0352
K27604 L84_89 L9_14 0.0273
K27605 L84_89 L44_92 0.0757
K27606 L84_89 L199_203 0.0387
K27607 L84_89 L75_80 0.0389
K27608 L84_89 L70_75 0.0387
K27609 L84_89 L50_54 0.0261
K27610 L84_89 L56_60 0.0377
K27611 L84_89 L93_97 0.0597
K27612 L84_89 L90_94 0.1129
K27613 L84_89 L134_173 0.0703
K27614 L84_89 L139_144 0.0775
K27615 L84_89 L177_181 0.0259
K27616 L84_89 L111_116 0.026
K27617 L84_89 L162_167 0.0474
K27618 L84_89 L43_91 0.0869
K27619 L84_89 L39_44 0.0714
K27620 L84_89 L123_128 0.0391
K27621 L84_89 L61_65 0.0437
K27622 L84_89 L12_17 0.0297
K27623 L96_97 L115_179 0.022
K27624 L96_97 L196_197 0.0413
K27625 L96_97 L91_92 0.1832
K27626 L96_97 L4_5 0.0183
K27627 L96_97 L41_42 0.091
K27628 L96_97 L191_192 0.0298
K27629 L96_97 L36_37 0.0642
K27630 L96_97 L131_132 0.0868
K27631 L96_97 L92_93 0.2054
K27632 L96_97 L187_188 0.0248
K27633 L96_97 L21_65 0.0333
K27634 L96_97 L121_122 0.0237
K27635 L96_97 L9_10 0.0224
K27636 L96_97 L134_135 0.1029
K27637 L96_97 L104_105 0.1216
K27638 L96_97 L151_210 0.0586
K27639 L96_97 L98_99 0.1439
K27640 L96_97 L112_113 0.025
K27641 L96_97 L59_60 0.0269
K27642 L96_97 L38_39 0.0683
K27643 L96_97 L44_45 0.1104
K27644 L96_97 L47_48 0.0232
K27645 L96_97 L6_53 0.0299
K27646 L96_97 L149_150 0.1536
K27647 L96_97 L80_81 0.0275
K27648 L96_97 L129_130 0.0331
K27649 L96_97 L117_118 0.0259
K27650 L96_97 L116_117 0.0231
K27651 L96_97 L7_8 0.0222
K27652 L96_97 L82_83 0.0449
K27653 L96_97 L58_59 0.0238
K27654 L96_97 L70_71 0.0321
K27655 L96_97 L68_69 0.0546
K27656 L96_97 L89_102 0.0823
K27657 L96_97 L50_51 0.0225
K27658 L96_97 L90_91 0.1439
K27659 L96_97 L139_140 0.1536
K27660 L96_97 L111_112 0.0224
K27661 L96_97 L162_163 0.0386
K27662 L96_97 L137_138 0.1226
K27663 L96_97 L179_180 0.0221
K27664 L96_97 L12_13 0.0235
K27665 L96_97 L123_124 0.0302
K27666 L96_97 L39_40 0.0688
K27667 L96_97 L156_157 0.0311
K27668 L82_87 L91_95 0.0423
K27669 L82_87 L4_9 0.0246
K27670 L82_87 L202_206 0.1104
K27671 L82_87 L109_114 0.0423
K27672 L82_87 L57_61 0.0466
K27673 L82_87 L53_57 0.0444
K27674 L82_87 L69_73 0.1057
K27675 L82_87 L200_204 0.1104
K27676 L82_87 L145_150 0.0312
K27677 L82_87 L131_136 0.066
K27678 L82_87 L46_50 0.0343
K27679 L82_87 L196_200 0.1076
K27680 L82_87 L92_96 0.0395
K27681 L82_87 L120_125 0.0375
K27682 L82_87 L7_12 0.0268
K27683 L82_87 L167_172 0.0442
K27684 L82_87 L121_126 0.0391
K27685 L82_87 L134_139 0.0388
K27686 L82_87 L9_14 0.0254
K27687 L82_87 L33_38 0.0444
K27688 L82_87 L124_129 0.0487
K27689 L82_87 L78_83 0.1134
K27690 L82_87 L112_117 0.0443
K27691 L82_87 L40_45 0.0409
K27692 L82_87 L59_63 0.0489
K27693 L82_87 L15_20 0.0213
K27694 L82_87 L179_183 0.0267
K27695 L82_87 L66_70 0.0772
K27696 L82_87 L98_102 0.0461
K27697 L82_87 L142_147 0.0455
K27698 L82_87 L178_182 0.0199
K27699 L82_87 L3_8 0.0252
K27700 L82_87 L149_154 0.0396
K27701 L82_87 L38_43 0.0488
K27702 L82_87 L115_120 0.0361
K27703 L82_87 L80_85 0.0818
K27704 L82_87 L16_21 0.0393
K27705 L82_87 L96_100 0.0398
K27706 L82_87 L125_130 0.0391
K27707 L82_87 L159_164 0.0313
K27708 L82_87 L44_92 0.0391
K27709 L82_87 L21_26 0.035
K27710 L82_87 L74_79 0.0681
K27711 L82_87 L165_170 0.0443
K27712 L82_87 L199_203 0.0797
K27713 L82_87 L75_80 0.0812
K27714 L82_87 L70_75 0.0796
K27715 L82_87 L50_54 0.0358
K27716 L82_87 L93_97 0.0312
K27717 L82_87 L90_94 0.0455
K27718 L82_87 L134_173 0.0459
K27719 L82_87 L139_144 0.0392
K27720 L82_87 L177_181 0.0245
K27721 L82_87 L111_116 0.0357
K27722 L82_87 L162_167 0.0398
K27723 L82_87 L43_91 0.0418
K27724 L82_87 L39_44 0.0462
K27725 L82_87 L12_17 0.0278
K27726 L82_87 L146_151 0.0684
K27727 L82_87 L61_65 0.0489
K27728 L7_8 L199_200 0.0218
K27729 L7_8 L196_197 0.0252
K27730 L7_8 L91_92 0.0237
K27731 L7_8 L4_5 0.1437
K27732 L7_8 L41_42 0.0315
K27733 L7_8 L200_201 0.0243
K27734 L7_8 L131_132 0.0313
K27735 L7_8 L92_93 0.0235
K27736 L7_8 L187_188 0.1173
K27737 L7_8 L21_65 0.0711
K27738 L7_8 L121_122 0.0301
K27739 L7_8 L134_135 0.0311
K27740 L7_8 L104_105 0.0168
K27741 L7_8 L151_210 0.0252
K27742 L7_8 L59_60 0.0383
K27743 L7_8 L38_39 0.0419
K27744 L7_8 L78_79 0.0294
K27745 L7_8 L44_45 0.0313
K27746 L7_8 L47_48 0.0459
K27747 L7_8 L149_150 0.021
K27748 L7_8 L98_99 0.0212
K27749 L7_8 L80_81 0.0213
K27750 L7_8 L129_130 0.0693
K27751 L7_8 L117_118 0.0385
K27752 L7_8 L116_117 0.0303
K27753 L7_8 L82_83 0.026
K27754 L7_8 L58_59 0.0302
K27755 L7_8 L70_71 0.0225
K27756 L7_8 L68_69 0.0272
K27757 L7_8 L89_102 0.0169
K27758 L7_8 L36_37 0.0419
K27759 L7_8 L90_91 0.0237
K27760 L7_8 L139_140 0.0234
K27761 L7_8 L162_163 0.0758
K27762 L7_8 L137_138 0.0236
K27763 L7_8 L12_13 0.2054
K27764 L7_8 L142_143 0.0223
K27765 L7_8 L123_124 0.0515
K27766 L7_8 L191_192 0.0213
K27767 L7_8 L39_40 0.0415
K27768 L7_8 L156_157 0.1029
K27769 L7_8 L201_202 0.027
K27770 L82_83 L199_200 0.0969
K27771 L82_83 L115_179 0.0264
K27772 L82_83 L196_197 0.1537
K27773 L82_83 L91_92 0.0478
K27774 L82_83 L4_5 0.0203
K27775 L82_83 L41_42 0.0628
K27776 L82_83 L200_201 0.1743
K27777 L82_83 L36_37 0.0584
K27778 L82_83 L131_132 0.062
K27779 L82_83 L92_93 0.0442
K27780 L82_83 L187_188 0.0281
K27781 L82_83 L21_65 0.0451
K27782 L82_83 L121_122 0.0418
K27783 L82_83 L9_10 0.0248
K27784 L82_83 L134_135 0.05
K27785 L82_83 L104_105 0.049
K27786 L82_83 L151_210 0.1674
K27787 L82_83 L112_113 0.0404
K27788 L82_83 L59_60 0.045
K27789 L82_83 L38_39 0.0523
K27790 L82_83 L78_79 0.1933
K27791 L82_83 L44_45 0.0504
K27792 L82_83 L47_48 0.0373
K27793 L82_83 L6_53 0.0405
K27794 L82_83 L129_130 0.0449
K27795 L82_83 L117_118 0.0425
K27796 L82_83 L116_117 0.0399
K27797 L82_83 L58_59 0.0419
K27798 L82_83 L70_71 0.0952
K27799 L82_83 L68_69 0.2072
K27800 L82_83 L89_102 0.0713
K27801 L82_83 L50_51 0.0382
K27802 L82_83 L90_91 0.0521
K27803 L82_83 L139_140 0.0438
K27804 L82_83 L111_112 0.0381
K27805 L82_83 L162_163 0.0402
K27806 L82_83 L137_138 0.0515
K27807 L82_83 L179_180 0.0259
K27808 L82_83 L12_13 0.027
K27809 L82_83 L142_143 0.0527
K27810 L82_83 L123_124 0.046
K27811 L82_83 L191_192 0.0858
K27812 L82_83 L39_40 0.0496
K27813 L82_83 L156_157 0.0349
K27814 L82_83 L201_202 0.2659
K27815 L74_79 L91_95 0.1011
K27816 L74_79 L4_9 0.0287
K27817 L74_79 L202_206 0.1053
K27818 L74_79 L109_114 0.0413
K27819 L74_79 L57_61 0.046
K27820 L74_79 L53_57 0.0437
K27821 L74_79 L69_73 0.1086
K27822 L74_79 L200_204 0.0503
K27823 L74_79 L145_150 0.0598
K27824 L74_79 L46_50 0.0269
K27825 L74_79 L196_200 0.0504
K27826 L74_79 L92_96 0.0844
K27827 L74_79 L7_12 0.0314
K27828 L74_79 L167_172 0.069
K27829 L74_79 L121_126 0.0294
K27830 L74_79 L134_139 0.0803
K27831 L74_79 L33_38 0.0701
K27832 L74_79 L124_129 0.0484
K27833 L74_79 L78_83 0.1086
K27834 L74_79 L112_117 0.0347
K27835 L74_79 L40_45 0.0719
K27836 L74_79 L59_63 0.0371
K27837 L74_79 L15_20 0.026
K27838 L74_79 L179_183 0.0313
K27839 L74_79 L66_70 0.0389
K27840 L74_79 L98_102 0.1129
K27841 L74_79 L142_147 0.1131
K27842 L74_79 L178_182 0.0234
K27843 L74_79 L3_8 0.0292
K27844 L74_79 L149_154 0.0775
K27845 L74_79 L38_43 0.0927
K27846 L74_79 L80_85 0.0387
K27847 L74_79 L96_100 0.0833
K27848 L74_79 L159_164 0.0392
K27849 L74_79 L9_14 0.0303
K27850 L74_79 L44_92 0.0833
K27851 L74_79 L199_203 0.0387
K27852 L74_79 L75_80 0.0389
K27853 L74_79 L70_75 0.039
K27854 L74_79 L50_54 0.0277
K27855 L74_79 L56_60 0.041
K27856 L74_79 L93_97 0.0622
K27857 L74_79 L90_94 0.1262
K27858 L74_79 L134_173 0.082
K27859 L74_79 L139_144 0.0813
K27860 L74_79 L177_181 0.0286
K27861 L74_79 L111_116 0.0276
K27862 L74_79 L162_167 0.0544
K27863 L74_79 L43_91 0.0991
K27864 L74_79 L39_44 0.0838
K27865 L74_79 L123_128 0.0426
K27866 L74_79 L61_65 0.0487
K27867 L74_79 L12_17 0.0334
K27868 L78_79 L115_179 0.0298
K27869 L78_79 L196_197 0.0969
K27870 L78_79 L91_92 0.0741
K27871 L78_79 L4_5 0.0232
K27872 L78_79 L41_42 0.0975
K27873 L78_79 L191_192 0.0607
K27874 L78_79 L36_37 0.0788
K27875 L78_79 L131_132 0.0946
K27876 L78_79 L92_93 0.0656
K27877 L78_79 L187_188 0.0325
K27878 L78_79 L21_65 0.0496
K27879 L78_79 L121_122 0.0393
K27880 L78_79 L9_10 0.0283
K27881 L78_79 L134_135 0.0707
K27882 L78_79 L104_105 0.0779
K27883 L78_79 L151_210 0.2081
K27884 L78_79 L98_99 0.1476
K27885 L78_79 L112_113 0.0399
K27886 L78_79 L59_60 0.0441
K27887 L78_79 L38_39 0.0698
K27888 L78_79 L44_45 0.0718
K27889 L78_79 L47_48 0.0369
K27890 L78_79 L6_53 0.0437
K27891 L78_79 L149_150 0.095
K27892 L78_79 L80_81 0.066
K27893 L78_79 L129_130 0.0493
K27894 L78_79 L117_118 0.0418
K27895 L78_79 L116_117 0.0378
K27896 L78_79 L58_59 0.0395
K27897 L78_79 L70_71 0.066
K27898 L78_79 L68_69 0.1727
K27899 L78_79 L89_102 0.1275
K27900 L78_79 L50_51 0.0365
K27901 L78_79 L90_91 0.0851
K27902 L78_79 L139_140 0.0643
K27903 L78_79 L111_112 0.0364
K27904 L78_79 L162_163 0.0478
K27905 L78_79 L137_138 0.0822
K27906 L78_79 L179_180 0.0293
K27907 L78_79 L12_13 0.0309
K27908 L78_79 L123_124 0.0474
K27909 L78_79 L39_40 0.0656
K27910 L78_79 L156_157 0.0405
K27911 L199_203 L91_95 0.0256
K27912 L199_203 L4_9 0.0181
K27913 L199_203 L202_206 0.056
K27914 L199_203 L109_114 0.0325
K27915 L199_203 L57_61 0.0349
K27916 L199_203 L53_57 0.0336
K27917 L199_203 L69_73 0.0549
K27918 L199_203 L200_204 0.1548
K27919 L199_203 L145_150 0.0195
K27920 L199_203 L131_136 0.0387
K27921 L199_203 L196_200 0.1506
K27922 L199_203 L92_96 0.0243
K27923 L199_203 L120_125 0.0277
K27924 L199_203 L7_12 0.0197
K27925 L199_203 L167_172 0.0298
K27926 L199_203 L134_139 0.0243
K27927 L199_203 L9_14 0.0186
K27928 L199_203 L33_38 0.0297
K27929 L199_203 L124_129 0.0364
K27930 L199_203 L78_83 0.0555
K27931 L199_203 L112_117 0.0406
K27932 L199_203 L40_45 0.0267
K27933 L199_203 L59_63 0.0453
K27934 L199_203 L15_20 0.0154
K27935 L199_203 L98_102 0.027
K27936 L199_203 L178_182 0.0147
K27937 L199_203 L3_8 0.0186
K27938 L199_203 L149_154 0.0244
K27939 L199_203 L38_43 0.0314
K27940 L199_203 L115_120 0.0269
K27941 L199_203 L16_21 0.0285
K27942 L199_203 L96_100 0.0244
K27943 L199_203 L125_130 0.0286
K27944 L199_203 L159_164 0.0226
K27945 L199_203 L44_92 0.0243
K27946 L199_203 L21_26 0.0253
K27947 L199_203 L165_170 0.0298
K27948 L199_203 L56_60 0.0391
K27949 L199_203 L93_97 0.0194
K27950 L199_203 L90_94 0.027
K27951 L199_203 L134_173 0.03
K27952 L199_203 L139_144 0.0244
K27953 L199_203 L177_181 0.0182
K27954 L199_203 L179_183 0.0197
K27955 L199_203 L162_167 0.0279
K27956 L199_203 L43_91 0.0255
K27957 L199_203 L142_147 0.0272
K27958 L199_203 L39_44 0.0299
K27959 L199_203 L123_128 0.0412
K27960 L199_203 L12_17 0.0203
K27961 L199_203 L146_151 0.0389
K27962 L199_203 L61_65 0.0362
K27963 L75_80 L91_95 0.0257
K27964 L75_80 L4_9 0.0182
K27965 L75_80 L202_206 0.0555
K27966 L75_80 L109_114 0.0324
K27967 L75_80 L57_61 0.035
K27968 L75_80 L53_57 0.0337
K27969 L75_80 L69_73 0.0553
K27970 L75_80 L200_204 0.1437
K27971 L75_80 L145_150 0.0195
K27972 L75_80 L131_136 0.0385
K27973 L75_80 L196_200 0.1405
K27974 L75_80 L92_96 0.0244
K27975 L75_80 L120_125 0.0276
K27976 L75_80 L7_12 0.0197
K27977 L75_80 L167_172 0.0297
K27978 L75_80 L134_139 0.0243
K27979 L75_80 L9_14 0.0186
K27980 L75_80 L33_38 0.0298
K27981 L75_80 L124_129 0.0362
K27982 L75_80 L78_83 0.056
K27983 L75_80 L112_117 0.0405
K27984 L75_80 L40_45 0.0268
K27985 L75_80 L59_63 0.0455
K27986 L75_80 L15_20 0.0155
K27987 L75_80 L98_102 0.0271
K27988 L75_80 L178_182 0.0147
K27989 L75_80 L3_8 0.0187
K27990 L75_80 L149_154 0.0243
K27991 L75_80 L38_43 0.0315
K27992 L75_80 L115_120 0.0268
K27993 L75_80 L16_21 0.0286
K27994 L75_80 L96_100 0.0245
K27995 L75_80 L125_130 0.0285
K27996 L75_80 L159_164 0.0226
K27997 L75_80 L44_92 0.0243
K27998 L75_80 L21_26 0.0253
K27999 L75_80 L165_170 0.0296
K28000 L75_80 L56_60 0.0393
K28001 L75_80 L93_97 0.0195
K28002 L75_80 L90_94 0.0271
K28003 L75_80 L134_173 0.0299
K28004 L75_80 L139_144 0.0243
K28005 L75_80 L177_181 0.0181
K28006 L75_80 L179_183 0.0197
K28007 L75_80 L162_167 0.0278
K28008 L75_80 L43_91 0.0256
K28009 L75_80 L142_147 0.0271
K28010 L75_80 L39_44 0.03
K28011 L75_80 L123_128 0.041
K28012 L75_80 L12_17 0.0203
K28013 L75_80 L146_151 0.0387
K28014 L75_80 L61_65 0.0364
K28015 L199_200 L115_179 0.0225
K28016 L199_200 L196_197 0.1933
K28017 L199_200 L91_92 0.0287
K28018 L199_200 L4_5 0.017
K28019 L199_200 L41_42 0.0378
K28020 L199_200 L191_192 0.2809
K28021 L199_200 L36_37 0.0395
K28022 L199_200 L131_132 0.038
K28023 L199_200 L92_93 0.0274
K28024 L199_200 L187_188 0.0231
K28025 L199_200 L21_65 0.0386
K28026 L199_200 L121_122 0.0491
K28027 L199_200 L9_10 0.0206
K28028 L199_200 L134_135 0.0327
K28029 L199_200 L104_105 0.0264
K28030 L199_200 L151_210 0.0608
K28031 L199_200 L98_99 0.0361
K28032 L199_200 L112_113 0.0427
K28033 L199_200 L59_60 0.0474
K28034 L199_200 L38_39 0.0361
K28035 L199_200 L44_45 0.0326
K28036 L199_200 L47_48 0.0391
K28037 L199_200 L6_53 0.0364
K28038 L199_200 L149_150 0.0321
K28039 L199_200 L80_81 0.2659
K28040 L199_200 L129_130 0.0387
K28041 L199_200 L117_118 0.045
K28042 L199_200 L116_117 0.0462
K28043 L199_200 L58_59 0.0488
K28044 L199_200 L70_71 0.2659
K28045 L199_200 L68_69 0.0896
K28046 L199_200 L89_102 0.0316
K28047 L199_200 L50_51 0.0435
K28048 L199_200 L90_91 0.0303
K28049 L199_200 L139_140 0.0275
K28050 L199_200 L111_112 0.0437
K28051 L199_200 L162_163 0.0318
K28052 L199_200 L137_138 0.0304
K28053 L199_200 L179_180 0.0219
K28054 L199_200 L12_13 0.0224
K28055 L199_200 L123_124 0.0441
K28056 L199_200 L39_40 0.0346
K28057 L199_200 L156_157 0.0284
K28058 L58_59 L115_179 0.0317
K28059 L58_59 L196_197 0.0504
K28060 L58_59 L91_92 0.0253
K28061 L58_59 L4_5 0.0226
K28062 L58_59 L41_42 0.0346
K28063 L58_59 L200_201 0.0474
K28064 L58_59 L36_37 0.0419
K28065 L58_59 L131_132 0.0345
K28066 L58_59 L92_93 0.0245
K28067 L58_59 L21_65 0.0618
K28068 L58_59 L9_10 0.0273
K28069 L58_59 L134_135 0.0309
K28070 L58_59 L104_105 0.0187
K28071 L58_59 L151_210 0.0342
K28072 L58_59 L112_113 0.1537
K28073 L58_59 L38_39 0.0385
K28074 L58_59 L44_45 0.031
K28075 L58_59 L47_48 0.1475
K28076 L58_59 L191_192 0.051
K28077 L58_59 L6_53 0.0648
K28078 L58_59 L149_150 0.0231
K28079 L58_59 L98_99 0.0245
K28080 L58_59 L80_81 0.0462
K28081 L58_59 L129_130 0.0611
K28082 L58_59 L117_118 0.1743
K28083 L58_59 L116_117 0.2659
K28084 L58_59 L70_71 0.0523
K28085 L58_59 L68_69 0.045
K28086 L58_59 L89_102 0.0204
K28087 L58_59 L50_51 0.2392
K28088 L58_59 L90_91 0.0262
K28089 L58_59 L139_140 0.0244
K28090 L58_59 L111_112 0.2117
K28091 L58_59 L162_163 0.0441
K28092 L58_59 L137_138 0.0261
K28093 L58_59 L179_180 0.0301
K28094 L58_59 L12_13 0.0304
K28095 L58_59 L142_143 0.0253
K28096 L58_59 L39_40 0.0369
K28097 L58_59 L156_157 0.0435
K28098 L58_59 L201_202 0.0439
K28099 L70_71 L115_179 0.0231
K28100 L70_71 L4_5 0.0174
K28101 L70_71 L41_42 0.0385
K28102 L70_71 L201_202 0.0969
K28103 L70_71 L191_192 0.2931
K28104 L70_71 L200_201 0.1743
K28105 L70_71 L36_37 0.0405
K28106 L70_71 L131_132 0.0383
K28107 L70_71 L187_188 0.0236
K28108 L70_71 L21_65 0.0404
K28109 L70_71 L121_122 0.052
K28110 L70_71 L9_10 0.0212
K28111 L70_71 L134_135 0.0329
K28112 L70_71 L104_105 0.0262
K28113 L70_71 L151_210 0.0588
K28114 L70_71 L112_113 0.0448
K28115 L70_71 L59_60 0.0506
K28116 L70_71 L38_39 0.0369
K28117 L70_71 L44_45 0.033
K28118 L70_71 L47_48 0.0414
K28119 L70_71 L6_53 0.0379
K28120 L70_71 L149_150 0.0317
K28121 L70_71 L98_99 0.0359
K28122 L70_71 L80_81 0.2392
K28123 L70_71 L129_130 0.0402
K28124 L70_71 L117_118 0.0474
K28125 L70_71 L116_117 0.0488
K28126 L70_71 L68_69 0.0947
K28127 L70_71 L89_102 0.0314
K28128 L70_71 L50_51 0.0462
K28129 L70_71 L111_112 0.046
K28130 L70_71 L162_163 0.0325
K28131 L70_71 L179_180 0.0224
K28132 L70_71 L12_13 0.0231
K28133 L70_71 L142_143 0.0361
K28134 L70_71 L123_124 0.0461
K28135 L70_71 L39_40 0.0352
K28136 L70_71 L156_157 0.0291
K28137 L70_75 L91_95 0.0257
K28138 L70_75 L4_9 0.0186
K28139 L70_75 L202_206 0.0554
K28140 L70_75 L109_114 0.0336
K28141 L70_75 L57_61 0.0364
K28142 L70_75 L53_57 0.035
K28143 L70_75 L69_73 0.0558
K28144 L70_75 L200_204 0.1405
K28145 L70_75 L145_150 0.0194
K28146 L70_75 L131_136 0.0387
K28147 L70_75 L196_200 0.1437
K28148 L70_75 L92_96 0.0245
K28149 L70_75 L120_125 0.0285
K28150 L70_75 L7_12 0.0203
K28151 L70_75 L167_172 0.0303
K28152 L70_75 L134_139 0.0243
K28153 L70_75 L9_14 0.0191
K28154 L70_75 L33_38 0.0304
K28155 L70_75 L124_129 0.0376
K28156 L70_75 L78_83 0.0558
K28157 L70_75 L112_117 0.0427
K28158 L70_75 L40_45 0.0271
K28159 L70_75 L59_63 0.0484
K28160 L70_75 L15_20 0.0158
K28161 L70_75 L98_102 0.027
K28162 L70_75 L178_182 0.0151
K28163 L70_75 L3_8 0.0192
K28164 L70_75 L149_154 0.0243
K28165 L70_75 L38_43 0.0319
K28166 L70_75 L115_120 0.0276
K28167 L70_75 L16_21 0.0295
K28168 L70_75 L96_100 0.0244
K28169 L70_75 L125_130 0.0294
K28170 L70_75 L159_164 0.0231
K28171 L70_75 L44_92 0.0244
K28172 L70_75 L21_26 0.0261
K28173 L70_75 L165_170 0.0303
K28174 L70_75 L56_60 0.0412
K28175 L70_75 L93_97 0.0195
K28176 L70_75 L90_94 0.0272
K28177 L70_75 L134_173 0.0303
K28178 L70_75 L139_144 0.0244
K28179 L70_75 L177_181 0.0186
K28180 L70_75 L179_183 0.0203
K28181 L70_75 L162_167 0.0285
K28182 L70_75 L43_91 0.0257
K28183 L70_75 L142_147 0.027
K28184 L70_75 L39_44 0.0304
K28185 L70_75 L123_128 0.0431
K28186 L70_75 L12_17 0.0209
K28187 L70_75 L146_151 0.0385
K28188 L70_75 L61_65 0.0378
K28189 L89_102 L115_179 0.0168
K28190 L89_102 L196_197 0.0418
K28191 L89_102 L91_92 0.0787
K28192 L89_102 L4_5 0.0137
K28193 L89_102 L41_42 0.0652
K28194 L89_102 L200_201 0.0429
K28195 L89_102 L36_37 0.0466
K28196 L89_102 L131_132 0.0629
K28197 L89_102 L92_93 0.0696
K28198 L89_102 L187_188 0.0187
K28199 L89_102 L21_65 0.026
K28200 L89_102 L121_122 0.0203
K28201 L89_102 L9_10 0.0167
K28202 L89_102 L134_135 0.057
K28203 L89_102 L112_113 0.0208
K28204 L89_102 L59_60 0.0226
K28205 L89_102 L38_39 0.0456
K28206 L89_102 L44_45 0.0587
K28207 L89_102 L47_48 0.0193
K28208 L89_102 L6_53 0.0234
K28209 L89_102 L149_150 0.0867
K28210 L89_102 L98_99 0.1673
K28211 L89_102 L80_81 0.0322
K28212 L89_102 L129_130 0.0259
K28213 L89_102 L117_118 0.0217
K28214 L89_102 L116_117 0.0197
K28215 L89_102 L68_69 0.0579
K28216 L89_102 L50_51 0.0191
K28217 L89_102 L90_91 0.0861
K28218 L89_102 L139_140 0.0657
K28219 L89_102 L111_112 0.019
K28220 L89_102 L162_163 0.0283
K28221 L89_102 L137_138 0.0789
K28222 L89_102 L179_180 0.0168
K28223 L89_102 L12_13 0.0178
K28224 L89_102 L142_143 0.0988
K28225 L89_102 L123_124 0.0246
K28226 L89_102 L191_192 0.0289
K28227 L89_102 L39_40 0.0445
K28228 L89_102 L156_157 0.0233
K28229 L89_102 L201_202 0.0656
K28230 L56_60 L91_95 0.029
K28231 L56_60 L4_9 0.0395
K28232 L56_60 L202_206 0.0487
K28233 L56_60 L109_114 0.1076
K28234 L56_60 L57_61 0.1145
K28235 L56_60 L53_57 0.1134
K28236 L56_60 L69_73 0.0543
K28237 L56_60 L200_204 0.0487
K28238 L56_60 L145_150 0.0219
K28239 L56_60 L131_136 0.0426
K28240 L56_60 L46_50 0.0796
K28241 L56_60 L196_200 0.0513
K28242 L56_60 L92_96 0.028
K28243 L56_60 L120_125 0.0684
K28244 L56_60 L7_12 0.0459
K28245 L56_60 L167_172 0.0457
K28246 L56_60 L121_126 0.0797
K28247 L56_60 L134_139 0.0289
K28248 L56_60 L9_14 0.0398
K28249 L56_60 L33_38 0.0459
K28250 L56_60 L124_129 0.1104
K28251 L56_60 L78_83 0.0489
K28252 L56_60 L112_117 0.1104
K28253 L56_60 L40_45 0.0356
K28254 L56_60 L59_63 0.1134
K28255 L56_60 L15_20 0.0314
K28256 L56_60 L179_183 0.0455
K28257 L56_60 L66_70 0.0433
K28258 L56_60 L98_102 0.0278
K28259 L56_60 L142_147 0.0287
K28260 L56_60 L178_182 0.031
K28261 L56_60 L3_8 0.0423
K28262 L56_60 L149_154 0.0261
K28263 L56_60 L38_43 0.0414
K28264 L56_60 L115_120 0.0681
K28265 L56_60 L80_85 0.0375
K28266 L56_60 L16_21 0.069
K28267 L56_60 L96_100 0.0271
K28268 L56_60 L125_130 0.0681
K28269 L56_60 L159_164 0.0438
K28270 L56_60 L44_92 0.029
K28271 L56_60 L21_26 0.0561
K28272 L56_60 L165_170 0.0461
K28273 L56_60 L50_54 0.0812
K28274 L56_60 L93_97 0.0227
K28275 L56_60 L90_94 0.03
K28276 L56_60 L134_173 0.0396
K28277 L56_60 L139_144 0.0279
K28278 L56_60 L177_181 0.0392
K28279 L56_60 L111_116 0.0797
K28280 L56_60 L162_167 0.0499
K28281 L56_60 L43_91 0.03
K28282 L56_60 L39_44 0.0397
K28283 L56_60 L12_17 0.0461
K28284 L56_60 L146_151 0.0375
K28285 L56_60 L61_65 0.1134
K28286 L90_94 L91_95 0.2054
K28287 L90_94 L4_9 0.0233
K28288 L90_94 L202_206 0.0655
K28289 L90_94 L109_114 0.0308
K28290 L90_94 L57_61 0.034
K28291 L90_94 L53_57 0.0324
K28292 L90_94 L69_73 0.0667
K28293 L90_94 L200_204 0.0349
K28294 L90_94 L145_150 0.0789
K28295 L90_94 L131_136 0.1131
K28296 L90_94 L46_50 0.0197
K28297 L90_94 L196_200 0.0349
K28298 L90_94 L92_96 0.1354
K28299 L90_94 L120_125 0.0332
K28300 L90_94 L167_172 0.0619
K28301 L90_94 L121_126 0.0214
K28302 L90_94 L9_14 0.0247
K28303 L90_94 L33_38 0.0633
K28304 L90_94 L134_139 0.1127
K28305 L90_94 L124_129 0.0355
K28306 L90_94 L78_83 0.0667
K28307 L90_94 L112_117 0.0254
K28308 L90_94 L40_45 0.077
K28309 L90_94 L59_63 0.027
K28310 L90_94 L15_20 0.0216
K28311 L90_94 L178_182 0.0191
K28312 L90_94 L3_8 0.0235
K28313 L90_94 L149_154 0.1015
K28314 L90_94 L66_70 0.0271
K28315 L90_94 L38_43 0.098
K28316 L90_94 L115_120 0.0313
K28317 L90_94 L80_85 0.027
K28318 L90_94 L16_21 0.0356
K28319 L90_94 L96_100 0.1284
K28320 L90_94 L125_130 0.0353
K28321 L90_94 L159_164 0.0328
K28322 L90_94 L44_92 0.1284
K28323 L90_94 L21_26 0.0397
K28324 L90_94 L165_170 0.0763
K28325 L90_94 L50_54 0.0203
K28326 L90_94 L93_97 0.0891
K28327 L90_94 L134_173 0.086
K28328 L90_94 L139_144 0.1173
K28329 L90_94 L177_181 0.0232
K28330 L90_94 L111_116 0.0203
K28331 L90_94 L162_167 0.0459
K28332 L90_94 L43_91 0.1832
K28333 L90_94 L39_44 0.0898
K28334 L90_94 L123_128 0.031
K28335 L90_94 L146_151 0.1056
K28336 L90_94 L61_65 0.0357
K28337 L139_144 L91_95 0.1536
K28338 L139_144 L202_206 0.0544
K28339 L139_144 L109_114 0.0293
K28340 L139_144 L57_61 0.0318
K28341 L139_144 L53_57 0.0305
K28342 L139_144 L69_73 0.0537
K28343 L139_144 L200_204 0.0313
K28344 L139_144 L145_150 0.1673
K28345 L139_144 L131_136 0.0833
K28346 L139_144 L46_50 0.0186
K28347 L139_144 L196_200 0.0314
K28348 L139_144 L120_125 0.032
K28349 L139_144 L7_12 0.0246
K28350 L139_144 L167_172 0.083
K28351 L139_144 L121_126 0.02
K28352 L139_144 L33_38 0.08
K28353 L139_144 L124_129 0.0334
K28354 L139_144 L78_83 0.0537
K28355 L139_144 L112_117 0.0239
K28356 L139_144 L40_45 0.0874
K28357 L139_144 L59_63 0.0251
K28358 L139_144 L15_20 0.022
K28359 L139_144 L179_183 0.0247
K28360 L139_144 L98_102 0.1015
K28361 L139_144 L178_182 0.0195
K28362 L139_144 L3_8 0.0234
K28363 L139_144 L66_70 0.0243
K28364 L139_144 L38_43 0.1319
K28365 L139_144 L115_120 0.0303
K28366 L139_144 L80_85 0.0243
K28367 L139_144 L16_21 0.0337
K28368 L139_144 L125_130 0.0339
K28369 L139_144 L159_164 0.0339
K28370 L139_144 L21_26 0.0382
K28371 L139_144 L165_170 0.0707
K28372 L139_144 L50_54 0.019
K28373 L139_144 L93_97 0.1363
K28374 L139_144 L111_116 0.0191
K28375 L139_144 L162_167 0.0565
K28376 L139_144 L43_91 0.1438
K28377 L139_144 L142_147 0.1284
K28378 L139_144 L123_128 0.029
K28379 L139_144 L12_17 0.0262
K28380 L139_144 L146_151 0.0802
K28381 L139_144 L61_65 0.0332
K28382 L90_91 L115_179 0.0235
K28383 L90_91 L4_5 0.0192
K28384 L90_91 L41_42 0.1375
K28385 L90_91 L201_202 0.0527
K28386 L90_91 L191_192 0.0338
K28387 L90_91 L200_201 0.0385
K28388 L90_91 L36_37 0.0781
K28389 L90_91 L131_132 0.1234
K28390 L90_91 L187_188 0.0267
K28391 L90_91 L21_65 0.037
K28392 L90_91 L121_122 0.0261
K28393 L90_91 L9_10 0.0235
K28394 L90_91 L134_135 0.1128
K28395 L90_91 L104_105 0.0787
K28396 L90_91 L151_210 0.0693
K28397 L90_91 L112_113 0.0274
K28398 L90_91 L59_60 0.0298
K28399 L90_91 L38_39 0.0781
K28400 L90_91 L44_45 0.1231
K28401 L90_91 L47_48 0.0254
K28402 L90_91 L6_53 0.0324
K28403 L90_91 L149_150 0.1015
K28404 L90_91 L98_99 0.1354
K28405 L90_91 L80_81 0.0302
K28406 L90_91 L129_130 0.0367
K28407 L90_91 L117_118 0.0285
K28408 L90_91 L116_117 0.0253
K28409 L90_91 L68_69 0.0708
K28410 L90_91 L50_51 0.0245
K28411 L90_91 L111_112 0.0245
K28412 L90_91 L162_163 0.0416
K28413 L90_91 L179_180 0.0236
K28414 L90_91 L12_13 0.0252
K28415 L90_91 L142_143 0.1536
K28416 L90_91 L123_124 0.0334
K28417 L90_91 L39_40 0.0757
K28418 L90_91 L156_157 0.0335
K28419 L139_140 L115_179 0.0233
K28420 L139_140 L4_5 0.0192
K28421 L139_140 L41_42 0.1001
K28422 L139_140 L201_202 0.0449
K28423 L139_140 L191_192 0.0301
K28424 L139_140 L200_201 0.0341
K28425 L139_140 L36_37 0.0704
K28426 L139_140 L131_132 0.1069
K28427 L139_140 L187_188 0.0266
K28428 L139_140 L21_65 0.0352
K28429 L139_140 L121_122 0.0245
K28430 L139_140 L9_10 0.0236
K28431 L139_140 L134_135 0.1436
K28432 L139_140 L104_105 0.0811
K28433 L139_140 L151_210 0.0573
K28434 L139_140 L112_113 0.026
K28435 L139_140 L59_60 0.0279
K28436 L139_140 L38_39 0.0758
K28437 L139_140 L44_45 0.1276
K28438 L139_140 L47_48 0.0239
K28439 L139_140 L6_53 0.0314
K28440 L139_140 L149_150 0.1354
K28441 L139_140 L98_99 0.1015
K28442 L139_140 L80_81 0.0272
K28443 L139_140 L129_130 0.0354
K28444 L139_140 L117_118 0.0269
K28445 L139_140 L116_117 0.0238
K28446 L139_140 L68_69 0.0548
K28447 L139_140 L50_51 0.0231
K28448 L139_140 L111_112 0.0231
K28449 L139_140 L162_163 0.0419
K28450 L139_140 L179_180 0.0235
K28451 L139_140 L12_13 0.0248
K28452 L139_140 L142_143 0.1439
K28453 L139_140 L123_124 0.0317
K28454 L139_140 L39_40 0.0766
K28455 L139_140 L156_157 0.0334
K28456 L179_183 L91_95 0.0248
K28457 L179_183 L4_9 0.1127
K28458 L179_183 L202_206 0.0309
K28459 L179_183 L109_114 0.0667
K28460 L179_183 L57_61 0.0655
K28461 L179_183 L53_57 0.0659
K28462 L179_183 L69_73 0.0338
K28463 L179_183 L200_204 0.0247
K28464 L179_183 L145_150 0.0192
K28465 L179_183 L131_136 0.0334
K28466 L179_183 L46_50 0.027
K28467 L179_183 L196_200 0.0255
K28468 L179_183 L92_96 0.0246
K28469 L179_183 L120_125 0.1224
K28470 L179_183 L167_172 0.051
K28471 L179_183 L121_126 0.027
K28472 L179_183 L9_14 0.1173
K28473 L179_183 L33_38 0.0503
K28474 L179_183 L134_139 0.0263
K28475 L179_183 L124_129 0.0654
K28476 L179_183 L78_83 0.0308
K28477 L179_183 L112_117 0.0351
K28478 L179_183 L40_45 0.0351
K28479 L179_183 L59_63 0.0347
K28480 L179_183 L15_20 0.0789
K28481 L179_183 L178_182 0.0861
K28482 L179_183 L3_8 0.1438
K28483 L179_183 L149_154 0.0221
K28484 L179_183 L66_70 0.0208
K28485 L179_183 L38_43 0.0391
K28486 L179_183 L115_120 0.1262
K28487 L179_183 L80_85 0.0192
K28488 L179_183 L16_21 0.1056
K28489 L179_183 L96_100 0.0232
K28490 L179_183 L125_130 0.1129
K28491 L179_183 L159_164 0.0877
K28492 L179_183 L44_92 0.0262
K28493 L179_183 L21_26 0.1665
K28494 L179_183 L165_170 0.0596
K28495 L179_183 L50_54 0.0271
K28496 L179_183 L93_97 0.0202
K28497 L179_183 L134_173 0.0389
K28498 L179_183 L177_181 0.1284
K28499 L179_183 L111_116 0.0272
K28500 L179_183 L162_167 0.0718
K28501 L179_183 L43_91 0.0265
K28502 L179_183 L39_44 0.0385
K28503 L179_183 L123_128 0.0455
K28504 L179_183 L146_151 0.0281
K28505 L179_183 L61_65 0.0643
K28506 L179_180 L196_197 0.0252
K28507 L179_180 L91_92 0.0235
K28508 L179_180 L4_5 0.1153
K28509 L179_180 L41_42 0.0313
K28510 L179_180 L200_201 0.0244
K28511 L179_180 L131_132 0.0315
K28512 L179_180 L92_93 0.0234
K28513 L179_180 L187_188 0.1354
K28514 L179_180 L21_65 0.0693
K28515 L179_180 L121_122 0.0302
K28516 L179_180 L134_135 0.0313
K28517 L179_180 L104_105 0.0167
K28518 L179_180 L151_210 0.0253
K28519 L179_180 L59_60 0.038
K28520 L179_180 L38_39 0.0416
K28521 L179_180 L44_45 0.0311
K28522 L179_180 L47_48 0.0454
K28523 L179_180 L149_150 0.0211
K28524 L179_180 L98_99 0.0211
K28525 L179_180 L80_81 0.0212
K28526 L179_180 L129_130 0.0711
K28527 L179_180 L117_118 0.0387
K28528 L179_180 L116_117 0.0304
K28529 L179_180 L68_69 0.0271
K28530 L179_180 L36_37 0.0416
K28531 L179_180 L162_163 0.0781
K28532 L179_180 L137_138 0.0237
K28533 L179_180 L12_13 0.1536
K28534 L179_180 L142_143 0.0224
K28535 L179_180 L123_124 0.0521
K28536 L179_180 L191_192 0.0214
K28537 L179_180 L39_40 0.0412
K28538 L179_180 L156_157 0.1104
K28539 L179_180 L201_202 0.027
K28540 L123_124 L115_179 0.0573
K28541 L123_124 L196_197 0.0506
K28542 L123_124 L91_92 0.0325
K28543 L123_124 L4_5 0.0361
K28544 L123_124 L41_42 0.0454
K28545 L123_124 L200_201 0.0477
K28546 L123_124 L36_37 0.0592
K28547 L123_124 L131_132 0.0457
K28548 L123_124 L92_93 0.0316
K28549 L123_124 L21_65 0.1674
K28550 L123_124 L9_10 0.0438
K28551 L123_124 L134_135 0.0415
K28552 L123_124 L104_105 0.0231
K28553 L123_124 L151_210 0.0403
K28554 L123_124 L112_113 0.1646
K28555 L123_124 L38_39 0.0545
K28556 L123_124 L44_45 0.0413
K28557 L123_124 L47_48 0.1387
K28558 L123_124 L191_192 0.045
K28559 L123_124 L6_53 0.1537
K28560 L123_124 L149_150 0.0289
K28561 L123_124 L98_99 0.0302
K28562 L123_124 L80_81 0.0418
K28563 L123_124 L129_130 0.1877
K28564 L123_124 L117_118 0.1933
K28565 L123_124 L116_117 0.0993
K28566 L123_124 L68_69 0.051
K28567 L123_124 L50_51 0.0931
K28568 L123_124 L111_112 0.0952
K28569 L123_124 L162_163 0.0779
K28570 L123_124 L137_138 0.0336
K28571 L123_124 L12_13 0.0527
K28572 L123_124 L142_143 0.0319
K28573 L123_124 L39_40 0.0522
K28574 L123_124 L156_157 0.0881
K28575 L123_124 L201_202 0.0491
K28576 L123_128 L91_95 0.0299
K28577 L123_128 L4_9 0.0388
K28578 L123_128 L202_206 0.0515
K28579 L123_128 L109_114 0.1057
K28580 L123_128 L57_61 0.1104
K28581 L123_128 L53_57 0.1076
K28582 L123_128 L69_73 0.057
K28583 L123_128 L200_204 0.0515
K28584 L123_128 L145_150 0.0227
K28585 L123_128 L131_136 0.0447
K28586 L123_128 L46_50 0.0759
K28587 L123_128 L196_200 0.0543
K28588 L123_128 L92_96 0.0289
K28589 L123_128 L120_125 0.069
K28590 L123_128 L7_12 0.0451
K28591 L123_128 L167_172 0.0474
K28592 L123_128 L121_126 0.0818
K28593 L123_128 L134_139 0.03
K28594 L123_128 L9_14 0.0392
K28595 L123_128 L33_38 0.0471
K28596 L123_128 L124_129 0.1145
K28597 L123_128 L78_83 0.0513
K28598 L123_128 L112_117 0.1103
K28599 L123_128 L40_45 0.0365
K28600 L123_128 L59_63 0.1114
K28601 L123_128 L15_20 0.0312
K28602 L123_128 L66_70 0.0454
K28603 L123_128 L98_102 0.0287
K28604 L123_128 L142_147 0.03
K28605 L123_128 L178_182 0.0308
K28606 L123_128 L3_8 0.0415
K28607 L123_128 L149_154 0.0271
K28608 L123_128 L38_43 0.0427
K28609 L123_128 L115_120 0.0681
K28610 L123_128 L80_85 0.0391
K28611 L123_128 L16_21 0.0684
K28612 L123_128 L96_100 0.0279
K28613 L123_128 L125_130 0.0692
K28614 L123_128 L159_164 0.0445
K28615 L123_128 L44_92 0.0299
K28616 L123_128 L21_26 0.0565
K28617 L123_128 L165_170 0.0482
K28618 L123_128 L50_54 0.0782
K28619 L123_128 L93_97 0.0233
K28620 L123_128 L134_173 0.041
K28621 L123_128 L177_181 0.0391
K28622 L123_128 L111_116 0.0796
K28623 L123_128 L162_167 0.0515
K28624 L123_128 L43_91 0.031
K28625 L123_128 L39_44 0.0409
K28626 L123_128 L12_17 0.0455
K28627 L123_128 L146_151 0.0393
K28628 L123_128 L61_65 0.1114
K28629 L156_157 L115_179 0.1076
K28630 L156_157 L196_197 0.0334
K28631 L156_157 L91_92 0.0335
K28632 L156_157 L4_5 0.0752
K28633 L156_157 L41_42 0.0453
K28634 L156_157 L200_201 0.0323
K28635 L156_157 L36_37 0.0624
K28636 L156_157 L131_132 0.0457
K28637 L156_157 L92_93 0.0332
K28638 L156_157 L187_188 0.2069
K28639 L156_157 L121_122 0.0438
K28640 L156_157 L134_135 0.0453
K28641 L156_157 L104_105 0.0232
K28642 L156_157 L151_210 0.0346
K28643 L156_157 L112_113 0.0558
K28644 L156_157 L59_60 0.058
K28645 L156_157 L38_39 0.0624
K28646 L156_157 L44_45 0.0449
K28647 L156_157 L47_48 0.0511
K28648 L156_157 L6_53 0.1157
K28649 L156_157 L149_150 0.0294
K28650 L156_157 L98_99 0.0295
K28651 L156_157 L80_81 0.0276
K28652 L156_157 L9_10 0.0947
K28653 L156_157 L117_118 0.0574
K28654 L156_157 L116_117 0.0433
K28655 L156_157 L68_69 0.0367
K28656 L156_157 L50_51 0.0423
K28657 L156_157 L111_112 0.0426
K28658 L156_157 L162_163 0.1502
K28659 L156_157 L137_138 0.0338
K28660 L156_157 L12_13 0.1276
K28661 L156_157 L142_143 0.0316
K28662 L156_157 L191_192 0.0277
K28663 L156_157 L39_40 0.0615
K28664 L156_157 L201_202 0.0366
K28665 L12_13 L115_179 0.1438
K28666 L12_13 L196_197 0.026
K28667 L12_13 L91_92 0.0251
K28668 L12_13 L4_5 0.1116
K28669 L12_13 L41_42 0.0337
K28670 L12_13 L200_201 0.0252
K28671 L12_13 L36_37 0.0454
K28672 L12_13 L131_132 0.0335
K28673 L12_13 L92_93 0.025
K28674 L12_13 L187_188 0.1536
K28675 L12_13 L21_65 0.0761
K28676 L12_13 L121_122 0.0303
K28677 L12_13 L9_10 0.1439
K28678 L12_13 L134_135 0.0332
K28679 L12_13 L104_105 0.0177
K28680 L12_13 L151_210 0.0264
K28681 L12_13 L112_113 0.0482
K28682 L12_13 L59_60 0.0387
K28683 L12_13 L129_130 0.0738
K28684 L12_13 L38_39 0.0454
K28685 L12_13 L44_45 0.0334
K28686 L12_13 L47_48 0.0453
K28687 L12_13 L149_150 0.0221
K28688 L12_13 L98_99 0.0224
K28689 L12_13 L6_53 0.1476
K28690 L12_13 L80_81 0.0219
K28691 L12_13 L68_69 0.0284
K28692 L12_13 L50_51 0.0363
K28693 L12_13 L111_112 0.0361
K28694 L12_13 L162_163 0.0876
K28695 L12_13 L137_138 0.025
K28696 L12_13 L142_143 0.0236
K28697 L12_13 L191_192 0.0219
K28698 L12_13 L39_40 0.045
K28699 L12_13 L201_202 0.0281
K28700 L12_17 L91_95 0.0266
K28701 L12_17 L4_9 0.1124
K28702 L12_17 L202_206 0.0322
K28703 L12_17 L109_114 0.0643
K28704 L12_17 L57_61 0.0671
K28705 L12_17 L53_57 0.0667
K28706 L12_17 L69_73 0.0357
K28707 L12_17 L200_204 0.0254
K28708 L12_17 L145_150 0.0202
K28709 L12_17 L131_136 0.0353
K28710 L12_17 L46_50 0.027
K28711 L12_17 L196_200 0.0262
K28712 L12_17 L92_96 0.0263
K28713 L12_17 L120_125 0.1161
K28714 L12_17 L167_172 0.0555
K28715 L12_17 L121_126 0.027
K28716 L12_17 L9_14 0.1284
K28717 L12_17 L33_38 0.0565
K28718 L12_17 L134_139 0.0279
K28719 L12_17 L124_129 0.0655
K28720 L12_17 L78_83 0.0324
K28721 L12_17 L112_117 0.0349
K28722 L12_17 L40_45 0.0381
K28723 L12_17 L59_63 0.0351
K28724 L12_17 L15_20 0.0891
K28725 L12_17 L178_182 0.073
K28726 L12_17 L3_8 0.1439
K28727 L12_17 L149_154 0.0232
K28728 L12_17 L66_70 0.0214
K28729 L12_17 L38_43 0.0427
K28730 L12_17 L115_120 0.1131
K28731 L12_17 L80_85 0.0197
K28732 L12_17 L16_21 0.1224
K28733 L12_17 L96_100 0.0247
K28734 L12_17 L125_130 0.1131
K28735 L12_17 L159_164 0.0938
K28736 L12_17 L44_92 0.0281
K28737 L12_17 L21_26 0.2987
K28738 L12_17 L165_170 0.0661
K28739 L12_17 L50_54 0.0271
K28740 L12_17 L93_97 0.0216
K28741 L12_17 L134_173 0.0415
K28742 L12_17 L177_181 0.1015
K28743 L12_17 L111_116 0.027
K28744 L12_17 L162_167 0.08
K28745 L12_17 L43_91 0.0285
K28746 L12_17 L39_44 0.0419
K28747 L12_17 L146_151 0.0296
K28748 L12_17 L61_65 0.0667
K28749 L201_202 L115_179 0.0277
K28750 L201_202 L196_197 0.1933
K28751 L201_202 L91_92 0.0482
K28752 L201_202 L4_5 0.0211
K28753 L201_202 L41_42 0.0648
K28754 L201_202 L191_192 0.0917
K28755 L201_202 L36_37 0.061
K28756 L201_202 L131_132 0.0656
K28757 L201_202 L92_93 0.0445
K28758 L201_202 L187_188 0.0295
K28759 L201_202 L21_65 0.0477
K28760 L201_202 L121_122 0.0441
K28761 L201_202 L9_10 0.0257
K28762 L201_202 L134_135 0.0518
K28763 L201_202 L104_105 0.0471
K28764 L201_202 L151_210 0.1593
K28765 L201_202 L98_99 0.0723
K28766 L201_202 L112_113 0.0427
K28767 L201_202 L59_60 0.0474
K28768 L201_202 L38_39 0.0542
K28769 L201_202 L44_45 0.0514
K28770 L201_202 L47_48 0.0391
K28771 L201_202 L6_53 0.0425
K28772 L201_202 L149_150 0.0589
K28773 L201_202 L80_81 0.0969
K28774 L201_202 L129_130 0.0479
K28775 L201_202 L117_118 0.045
K28776 L201_202 L116_117 0.0419
K28777 L201_202 L68_69 0.2334
K28778 L201_202 L50_51 0.0399
K28779 L201_202 L111_112 0.04
K28780 L201_202 L162_163 0.0421
K28781 L201_202 L137_138 0.0533
K28782 L201_202 L39_40 0.0512
K28783 L115_179 L196_197 0.026
K28784 L115_179 L91_92 0.0234
K28785 L115_179 L4_5 0.0915
K28786 L115_179 L41_42 0.0314
K28787 L115_179 L200_201 0.0251
K28788 L115_179 L131_132 0.0316
K28789 L115_179 L92_93 0.0232
K28790 L115_179 L187_188 0.1284
K28791 L115_179 L21_65 0.0776
K28792 L115_179 L121_122 0.0319
K28793 L115_179 L134_135 0.031
K28794 L115_179 L104_105 0.0166
K28795 L115_179 L151_210 0.0256
K28796 L115_179 L59_60 0.0407
K28797 L115_179 L38_39 0.0412
K28798 L115_179 L44_45 0.0308
K28799 L115_179 L47_48 0.0496
K28800 L115_179 L149_150 0.0209
K28801 L115_179 L98_99 0.0211
K28802 L115_179 L80_81 0.0218
K28803 L115_179 L129_130 0.0803
K28804 L115_179 L117_118 0.0416
K28805 L115_179 L116_117 0.0321
K28806 L115_179 L68_69 0.0278
K28807 L115_179 L36_37 0.0417
K28808 L115_179 L162_163 0.0757
K28809 L115_179 L137_138 0.0237
K28810 L115_179 L142_143 0.0223
K28811 L115_179 L191_192 0.022
K28812 L115_179 L39_40 0.0406
K28813 L196_197 L4_5 0.0195
K28814 L196_197 L41_42 0.049
K28815 L196_197 L191_192 0.2045
K28816 L196_197 L200_201 0.3334
K28817 L196_197 L36_37 0.05
K28818 L196_197 L131_132 0.0493
K28819 L196_197 L187_188 0.027
K28820 L196_197 L21_65 0.0459
K28821 L196_197 L121_122 0.0506
K28822 L196_197 L9_10 0.0238
K28823 L196_197 L134_135 0.0407
K28824 L196_197 L104_105 0.0333
K28825 L196_197 L151_210 0.0854
K28826 L196_197 L112_113 0.0462
K28827 L196_197 L59_60 0.052
K28828 L196_197 L38_39 0.0447
K28829 L196_197 L44_45 0.0405
K28830 L196_197 L47_48 0.0423
K28831 L196_197 L6_53 0.0418
K28832 L196_197 L149_150 0.041
K28833 L196_197 L98_99 0.0474
K28834 L196_197 L80_81 0.1537
K28835 L196_197 L129_130 0.0462
K28836 L196_197 L117_118 0.0491
K28837 L196_197 L116_117 0.0477
K28838 L196_197 L68_69 0.1765
K28839 L196_197 L50_51 0.0448
K28840 L196_197 L111_112 0.045
K28841 L196_197 L162_163 0.0377
K28842 L196_197 L142_143 0.0488
K28843 L196_197 L39_40 0.0424
K28844 L91_92 L4_5 0.0193
K28845 L91_92 L41_42 0.1231
K28846 L91_92 L191_192 0.0318
K28847 L91_92 L200_201 0.0361
K28848 L91_92 L36_37 0.0757
K28849 L91_92 L131_132 0.1128
K28850 L91_92 L187_188 0.0266
K28851 L91_92 L21_65 0.0363
K28852 L91_92 L121_122 0.0252
K28853 L91_92 L9_10 0.0237
K28854 L91_92 L134_135 0.1234
K28855 L91_92 L104_105 0.0861
K28856 L91_92 L151_210 0.0622
K28857 L91_92 L112_113 0.0266
K28858 L91_92 L59_60 0.0289
K28859 L91_92 L38_39 0.079
K28860 L91_92 L44_45 0.1375
K28861 L91_92 L47_48 0.0247
K28862 L91_92 L6_53 0.032
K28863 L91_92 L149_150 0.1127
K28864 L91_92 L98_99 0.1284
K28865 L91_92 L80_81 0.0287
K28866 L91_92 L129_130 0.036
K28867 L91_92 L117_118 0.0277
K28868 L91_92 L116_117 0.0245
K28869 L91_92 L68_69 0.0623
K28870 L91_92 L50_51 0.0238
K28871 L91_92 L111_112 0.0238
K28872 L91_92 L162_163 0.0417
K28873 L91_92 L142_143 0.1438
K28874 L91_92 L39_40 0.0781
K28875 L91_95 L4_9 0.0235
K28876 L91_95 L202_206 0.059
K28877 L91_95 L109_114 0.03
K28878 L91_95 L57_61 0.033
K28879 L91_95 L53_57 0.0315
K28880 L91_95 L69_73 0.0599
K28881 L91_95 L200_204 0.0329
K28882 L91_95 L145_150 0.0988
K28883 L91_95 L131_136 0.0941
K28884 L91_95 L46_50 0.0192
K28885 L91_95 L196_200 0.033
K28886 L91_95 L92_96 0.2054
K28887 L91_95 L120_125 0.0326
K28888 L91_95 L7_12 0.025
K28889 L91_95 L121_126 0.0207
K28890 L91_95 L9_14 0.025
K28891 L91_95 L134_139 0.1438
K28892 L91_95 L124_129 0.0344
K28893 L91_95 L78_83 0.0599
K28894 L91_95 L112_117 0.0246
K28895 L91_95 L40_45 0.0849
K28896 L91_95 L59_63 0.0261
K28897 L91_95 L15_20 0.0219
K28898 L91_95 L66_70 0.0257
K28899 L91_95 L98_102 0.1439
K28900 L91_95 L142_147 0.1438
K28901 L91_95 L178_182 0.0193
K28902 L91_95 L149_154 0.1226
K28903 L91_95 L115_120 0.0307
K28904 L91_95 L80_85 0.0256
K28905 L91_95 L16_21 0.0348
K28906 L91_95 L96_100 0.1832
K28907 L91_95 L125_130 0.0346
K28908 L91_95 L159_164 0.0333
K28909 L91_95 L44_92 0.1832
K28910 L91_95 L21_26 0.0392
K28911 L91_95 L165_170 0.0729
K28912 L91_95 L50_54 0.0197
K28913 L91_95 L93_97 0.1216
K28914 L91_95 L134_173 0.093
K28915 L91_95 L177_181 0.0234
K28916 L91_95 L111_116 0.0196
K28917 L91_95 L39_44 0.098
K28918 L91_95 L146_151 0.0897
K28919 L91_95 L61_65 0.0345
K28920 L4_9 L202_206 0.0281
K28921 L4_9 L109_114 0.054
K28922 L4_9 L57_61 0.0537
K28923 L4_9 L53_57 0.0544
K28924 L4_9 L69_73 0.0306
K28925 L4_9 L200_204 0.0227
K28926 L4_9 L145_150 0.0184
K28927 L4_9 L131_136 0.0301
K28928 L4_9 L46_50 0.0245
K28929 L4_9 L196_200 0.0233
K28930 L4_9 L120_125 0.0775
K28931 L4_9 L7_12 0.1284
K28932 L4_9 L167_172 0.0555
K28933 L4_9 L121_126 0.0241
K28934 L4_9 L33_38 0.0565
K28935 L4_9 L124_129 0.052
K28936 L4_9 L78_83 0.0282
K28937 L4_9 L112_117 0.0312
K28938 L4_9 L40_45 0.0339
K28939 L4_9 L59_63 0.031
K28940 L4_9 L15_20 0.1268
K28941 L4_9 L98_102 0.0209
K28942 L4_9 L178_182 0.1363
K28943 L4_9 L3_8 0.2054
K28944 L4_9 L66_70 0.0191
K28945 L4_9 L38_43 0.0427
K28946 L4_9 L115_120 0.0803
K28947 L4_9 L80_85 0.0177
K28948 L4_9 L16_21 0.0757
K28949 L4_9 L125_130 0.0735
K28950 L4_9 L159_164 0.0874
K28951 L4_9 L21_26 0.1087
K28952 L4_9 L165_170 0.0494
K28953 L4_9 L50_54 0.0244
K28954 L4_9 L93_97 0.0195
K28955 L4_9 L111_116 0.0243
K28956 L4_9 L162_167 0.08
K28957 L4_9 L43_91 0.025
K28958 L4_9 L142_147 0.022
K28959 L4_9 L146_151 0.0259
K28960 L4_9 L61_65 0.0526
K28961 L57_61 L9_14 0.0544
K28962 L57_61 L200_204 0.0437
K28963 L57_61 L145_150 0.0247
K28964 L57_61 L131_136 0.0484
K28965 L57_61 L46_50 0.0553
K28966 L57_61 L196_200 0.0455
K28967 L57_61 L92_96 0.032
K28968 L57_61 L120_125 0.1064
K28969 L57_61 L7_12 0.0667
K28970 L57_61 L167_172 0.0564
K28971 L57_61 L121_126 0.0554
K28972 L57_61 L134_139 0.0332
K28973 L57_61 L33_38 0.0568
K28974 L57_61 L112_117 0.0734
K28975 L57_61 L40_45 0.042
K28976 L57_61 L59_63 0.0741
K28977 L57_61 L15_20 0.0423
K28978 L57_61 L66_70 0.0378
K28979 L57_61 L98_102 0.0309
K28980 L57_61 L142_147 0.0322
K28981 L57_61 L178_182 0.0412
K28982 L57_61 L3_8 0.059
K28983 L57_61 L149_154 0.0292
K28984 L57_61 L38_43 0.0489
K28985 L57_61 L115_120 0.1053
K28986 L57_61 L80_85 0.0337
K28987 L57_61 L16_21 0.1086
K28988 L57_61 L96_100 0.0306
K28989 L57_61 L165_170 0.0573
K28990 L57_61 L125_130 0.1053
K28991 L57_61 L159_164 0.0578
K28992 L57_61 L44_92 0.0334
K28993 L57_61 L21_26 0.081
K28994 L57_61 L50_54 0.0558
K28995 L57_61 L93_97 0.0258
K28996 L57_61 L134_173 0.0466
K28997 L57_61 L177_181 0.0531
K28998 L57_61 L111_116 0.0554
K28999 L57_61 L162_167 0.065
K29000 L57_61 L43_91 0.0345
K29001 L57_61 L39_44 0.0469
K29002 L57_61 L146_151 0.0413
K29003 L4_5 L41_42 0.0253
K29004 L4_5 L200_201 0.0189
K29005 L4_5 L36_37 0.0333
K29006 L4_5 L131_132 0.0251
K29007 L4_5 L92_93 0.0193
K29008 L4_5 L187_188 0.0801
K29009 L4_5 L21_65 0.0469
K29010 L4_5 L121_122 0.0225
K29011 L4_5 L9_10 0.2697
K29012 L4_5 L134_135 0.0256
K29013 L4_5 L104_105 0.0138
K29014 L4_5 L151_210 0.02
K29015 L4_5 L112_113 0.0282
K29016 L4_5 L59_60 0.0279
K29017 L4_5 L38_39 0.0341
K29018 L4_5 L44_45 0.0257
K29019 L4_5 L6_53 0.0554
K29020 L4_5 L149_150 0.0173
K29021 L4_5 L98_99 0.0172
K29022 L4_5 L80_81 0.0166
K29023 L4_5 L129_130 0.0461
K29024 L4_5 L117_118 0.028
K29025 L4_5 L116_117 0.0226
K29026 L4_5 L68_69 0.021
K29027 L4_5 L50_51 0.0228
K29028 L4_5 L111_112 0.0227
K29029 L4_5 L162_163 0.0607
K29030 L4_5 L137_138 0.0191
K29031 L4_5 L142_143 0.0181
K29032 L4_5 L191_192 0.0165
K29033 L4_5 L39_40 0.0342
K29034 L41_42 L200_201 0.048
K29035 L41_42 L36_37 0.1244
K29036 L41_42 L92_93 0.1069
K29037 L41_42 L187_188 0.0359
K29038 L41_42 L21_65 0.0509
K29039 L41_42 L121_122 0.0345
K29040 L41_42 L9_10 0.031
K29041 L41_42 L104_105 0.0587
K29042 L41_42 L151_210 0.0754
K29043 L41_42 L112_113 0.0364
K29044 L41_42 L59_60 0.04
K29045 L41_42 L38_39 0.1157
K29046 L41_42 L47_48 0.0337
K29047 L41_42 L6_53 0.0435
K29048 L41_42 L149_150 0.0757
K29049 L41_42 L98_99 0.0883
K29050 L41_42 L80_81 0.0374
K29051 L41_42 L129_130 0.0505
K29052 L41_42 L117_118 0.0381
K29053 L41_42 L116_117 0.0333
K29054 L41_42 L50_51 0.0323
K29055 L41_42 L111_112 0.0322
K29056 L41_42 L162_163 0.0564
K29057 L41_42 L137_138 0.1234
K29058 L41_42 L142_143 0.1006
K29059 L41_42 L39_40 0.1073
K29060 L53_57 L9_14 0.0546
K29061 L53_57 L200_204 0.042
K29062 L53_57 L145_150 0.0237
K29063 L53_57 L131_136 0.0458
K29064 L53_57 L46_50 0.0558
K29065 L53_57 L196_200 0.0437
K29066 L53_57 L92_96 0.0306
K29067 L53_57 L120_125 0.1053
K29068 L53_57 L7_12 0.0671
K29069 L53_57 L167_172 0.0536
K29070 L53_57 L121_126 0.0549
K29071 L53_57 L134_139 0.0318
K29072 L53_57 L33_38 0.054
K29073 L53_57 L112_117 0.0736
K29074 L53_57 L40_45 0.0402
K29075 L53_57 L59_63 0.0733
K29076 L53_57 L15_20 0.0421
K29077 L53_57 L66_70 0.0364
K29078 L53_57 L98_102 0.0295
K29079 L53_57 L142_147 0.0308
K29080 L53_57 L178_182 0.0417
K29081 L53_57 L3_8 0.0599
K29082 L53_57 L149_154 0.0281
K29083 L53_57 L38_43 0.0465
K29084 L53_57 L115_120 0.1064
K29085 L53_57 L80_85 0.0325
K29086 L53_57 L16_21 0.1051
K29087 L53_57 L96_100 0.0293
K29088 L53_57 L165_170 0.054
K29089 L53_57 L125_130 0.1022
K29090 L53_57 L159_164 0.0565
K29091 L53_57 L44_92 0.032
K29092 L53_57 L21_26 0.0775
K29093 L53_57 L50_54 0.056
K29094 L53_57 L93_97 0.0248
K29095 L53_57 L134_173 0.0446
K29096 L53_57 L177_181 0.0537
K29097 L53_57 L111_116 0.0555
K29098 L53_57 L162_167 0.0621
K29099 L53_57 L43_91 0.033
K29100 L53_57 L39_44 0.0448
K29101 L53_57 L146_151 0.0394
K29102 L69_73 L9_14 0.032
K29103 L69_73 L200_204 0.0726
K29104 L69_73 L145_150 0.0412
K29105 L69_73 L131_136 0.1064
K29106 L69_73 L46_50 0.035
K29107 L69_73 L196_200 0.0734
K29108 L69_73 L92_96 0.0544
K29109 L69_73 L120_125 0.0484
K29110 L69_73 L7_12 0.034
K29111 L69_73 L167_172 0.0621
K29112 L69_73 L121_126 0.0391
K29113 L69_73 L134_139 0.054
K29114 L69_73 L33_38 0.0627
K29115 L69_73 L112_117 0.0455
K29116 L69_73 L40_45 0.057
K29117 L69_73 L59_63 0.0496
K29118 L69_73 L15_20 0.0269
K29119 L69_73 L66_70 0.056
K29120 L69_73 L98_102 0.0634
K29121 L69_73 L142_147 0.0643
K29122 L69_73 L178_182 0.0247
K29123 L69_73 L3_8 0.0315
K29124 L69_73 L149_154 0.052
K29125 L69_73 L38_43 0.0713
K29126 L69_73 L115_120 0.0458
K29127 L69_73 L80_85 0.0545
K29128 L69_73 L16_21 0.0516
K29129 L69_73 L96_100 0.0537
K29130 L69_73 L165_170 0.0646
K29131 L69_73 L125_130 0.0512
K29132 L69_73 L159_164 0.04
K29133 L69_73 L44_92 0.0546
K29134 L69_73 L21_26 0.0458
K29135 L69_73 L50_54 0.0364
K29136 L69_73 L93_97 0.0421
K29137 L69_73 L134_173 0.0648
K29138 L69_73 L177_181 0.0305
K29139 L69_73 L111_116 0.0362
K29140 L69_73 L162_167 0.0536
K29141 L69_73 L43_91 0.0602
K29142 L69_73 L39_44 0.0655
K29143 L69_73 L146_151 0.0977
K29144 L200_204 L202_206 0.0744
K29145 L200_204 L109_114 0.0405
K29146 L200_204 L9_14 0.0233
K29147 L200_204 L145_150 0.025
K29148 L200_204 L131_136 0.0503
K29149 L200_204 L46_50 0.0384
K29150 L200_204 L92_96 0.0312
K29151 L200_204 L120_125 0.0348
K29152 L200_204 L7_12 0.0247
K29153 L200_204 L167_172 0.0379
K29154 L200_204 L121_126 0.0455
K29155 L200_204 L33_38 0.0378
K29156 L200_204 L124_129 0.0457
K29157 L200_204 L78_83 0.0736
K29158 L200_204 L134_139 0.0312
K29159 L200_204 L40_45 0.034
K29160 L200_204 L15_20 0.0193
K29161 L200_204 L66_70 0.1322
K29162 L200_204 L98_102 0.0349
K29163 L200_204 L178_182 0.0184
K29164 L200_204 L3_8 0.0233
K29165 L200_204 L149_154 0.0313
K29166 L200_204 L38_43 0.0401
K29167 L200_204 L115_120 0.0336
K29168 L200_204 L80_85 0.1405
K29169 L200_204 L16_21 0.0358
K29170 L200_204 L96_100 0.0313
K29171 L200_204 L125_130 0.0359
K29172 L200_204 L159_164 0.0284
K29173 L200_204 L44_92 0.0311
K29174 L200_204 L21_26 0.0318
K29175 L200_204 L165_170 0.038
K29176 L200_204 L50_54 0.0405
K29177 L200_204 L93_97 0.0249
K29178 L200_204 L134_173 0.0383
K29179 L200_204 L177_181 0.0227
K29180 L200_204 L111_116 0.0406
K29181 L200_204 L162_167 0.0353
K29182 L200_204 L43_91 0.0328
K29183 L200_204 L142_147 0.0351
K29184 L200_204 L39_44 0.0382
K29185 L200_204 L146_151 0.0506
K29186 L200_204 L61_65 0.0455
K29187 L145_150 L109_114 0.0229
K29188 L145_150 L131_136 0.0597
K29189 L145_150 L46_50 0.0147
K29190 L145_150 L196_200 0.025
K29191 L145_150 L92_96 0.1266
K29192 L145_150 L120_125 0.0247
K29193 L145_150 L7_12 0.0191
K29194 L145_150 L167_172 0.0575
K29195 L145_150 L121_126 0.0158
K29196 L145_150 L134_139 0.1268
K29197 L145_150 L9_14 0.0194
K29198 L145_150 L33_38 0.0561
K29199 L145_150 L124_129 0.0258
K29200 L145_150 L78_83 0.0418
K29201 L145_150 L112_117 0.0189
K29202 L145_150 L59_63 0.0198
K29203 L145_150 L66_70 0.0194
K29204 L145_150 L98_102 0.0789
K29205 L145_150 L142_147 0.0891
K29206 L145_150 L3_8 0.0182
K29207 L145_150 L149_154 0.1673
K29208 L145_150 L38_43 0.0843
K29209 L145_150 L115_120 0.0234
K29210 L145_150 L80_85 0.0194
K29211 L145_150 L16_21 0.0259
K29212 L145_150 L96_100 0.1363
K29213 L145_150 L125_130 0.026
K29214 L145_150 L202_206 0.0423
K29215 L145_150 L44_92 0.1062
K29216 L145_150 L21_26 0.0289
K29217 L145_150 L165_170 0.0494
K29218 L145_150 L50_54 0.0151
K29219 L145_150 L134_173 0.1012
K29220 L145_150 L177_181 0.0185
K29221 L145_150 L111_116 0.0151
K29222 L145_150 L162_167 0.0415
K29223 L145_150 L43_91 0.088
K29224 L145_150 L39_44 0.0934
K29225 L145_150 L146_151 0.0615
K29226 L145_150 L61_65 0.0257
K29227 L191_192 L200_201 0.1727
K29228 L191_192 L36_37 0.0382
K29229 L191_192 L92_93 0.0299
K29230 L191_192 L187_188 0.0225
K29231 L191_192 L21_65 0.0387
K29232 L191_192 L121_122 0.0513
K29233 L191_192 L9_10 0.0201
K29234 L191_192 L104_105 0.0242
K29235 L191_192 L151_210 0.055
K29236 L191_192 L112_113 0.0438
K29237 L191_192 L59_60 0.0492
K29238 L191_192 L38_39 0.0346
K29239 L191_192 L47_48 0.0401
K29240 L191_192 L6_53 0.0363
K29241 L191_192 L149_150 0.0296
K29242 L191_192 L98_99 0.0332
K29243 L191_192 L80_81 0.1866
K29244 L191_192 L129_130 0.0388
K29245 L191_192 L117_118 0.0465
K29246 L191_192 L116_117 0.048
K29247 L191_192 L50_51 0.0448
K29248 L191_192 L111_112 0.0451
K29249 L191_192 L162_163 0.0309
K29250 L191_192 L137_138 0.034
K29251 L191_192 L142_143 0.0337
K29252 L191_192 L39_40 0.0331
K29253 L200_201 L36_37 0.0484
K29254 L200_201 L131_132 0.0483
K29255 L200_201 L92_93 0.0339
K29256 L200_201 L187_188 0.0261
K29257 L200_201 L21_65 0.0436
K29258 L200_201 L121_122 0.0477
K29259 L200_201 L9_10 0.023
K29260 L200_201 L134_135 0.0402
K29261 L200_201 L104_105 0.0339
K29262 L200_201 L151_210 0.0898
K29263 L200_201 L98_99 0.0482
K29264 L200_201 L112_113 0.0437
K29265 L200_201 L59_60 0.0488
K29266 L200_201 L38_39 0.0436
K29267 L200_201 L44_45 0.04
K29268 L200_201 L47_48 0.04
K29269 L200_201 L6_53 0.0399
K29270 L200_201 L149_150 0.0416
K29271 L200_201 L80_81 0.1743
K29272 L200_201 L129_130 0.0438
K29273 L200_201 L117_118 0.0462
K29274 L200_201 L116_117 0.045
K29275 L200_201 L68_69 0.1576
K29276 L200_201 L50_51 0.0425
K29277 L200_201 L111_112 0.0427
K29278 L200_201 L162_163 0.0365
K29279 L200_201 L137_138 0.0387
K29280 L200_201 L39_40 0.0415
K29281 L36_37 L131_132 0.118
K29282 L36_37 L92_93 0.0722
K29283 L36_37 L187_188 0.049
K29284 L36_37 L21_65 0.0707
K29285 L36_37 L121_122 0.0418
K29286 L36_37 L9_10 0.0409
K29287 L36_37 L134_135 0.1033
K29288 L36_37 L104_105 0.0445
K29289 L36_37 L151_210 0.0629
K29290 L36_37 L112_113 0.0454
K29291 L36_37 L59_60 0.0502
K29292 L36_37 L44_45 0.1073
K29293 L36_37 L47_48 0.0421
K29294 L36_37 L6_53 0.0576
K29295 L36_37 L149_150 0.0569
K29296 L36_37 L98_99 0.0606
K29297 L36_37 L80_81 0.0388
K29298 L36_37 L129_130 0.0697
K29299 L36_37 L117_118 0.0476
K29300 L36_37 L116_117 0.0404
K29301 L36_37 L68_69 0.0628
K29302 L36_37 L50_51 0.0392
K29303 L36_37 L111_112 0.039
K29304 L36_37 L162_163 0.0796
K29305 L36_37 L137_138 0.0758
K29306 L36_37 L142_143 0.0668
K29307 L131_132 L92_93 0.1001
K29308 L131_132 L187_188 0.0362
K29309 L131_132 L21_65 0.0505
K29310 L131_132 L121_122 0.0346
K29311 L131_132 L9_10 0.0308
K29312 L131_132 L104_105 0.057
K29313 L131_132 L151_210 0.077
K29314 L131_132 L112_113 0.0366
K29315 L131_132 L59_60 0.0399
K29316 L131_132 L38_39 0.1106
K29317 L131_132 L47_48 0.0336
K29318 L131_132 L6_53 0.0433
K29319 L131_132 L149_150 0.0785
K29320 L131_132 L98_99 0.0844
K29321 L131_132 L80_81 0.0373
K29322 L131_132 L129_130 0.0509
K29323 L131_132 L117_118 0.0382
K29324 L131_132 L116_117 0.0334
K29325 L131_132 L50_51 0.0322
K29326 L131_132 L111_112 0.0323
K29327 L131_132 L162_163 0.057
K29328 L131_132 L137_138 0.1375
K29329 L131_132 L142_143 0.1076
K29330 L131_132 L39_40 0.1033
K29331 L131_136 L202_206 0.1051
K29332 L131_136 L109_114 0.0437
K29333 L131_136 L46_50 0.0276
K29334 L131_136 L196_200 0.0506
K29335 L131_136 L92_96 0.0803
K29336 L131_136 L7_12 0.0332
K29337 L131_136 L167_172 0.0767
K29338 L131_136 L121_126 0.0304
K29339 L131_136 L134_139 0.0844
K29340 L131_136 L33_38 0.0753
K29341 L131_136 L124_129 0.0516
K29342 L131_136 L78_83 0.1022
K29343 L131_136 L112_117 0.0359
K29344 L131_136 L40_45 0.075
K29345 L131_136 L59_63 0.0383
K29346 L131_136 L15_20 0.0274
K29347 L131_136 L66_70 0.0388
K29348 L131_136 L98_102 0.0959
K29349 L131_136 L142_147 0.1129
K29350 L131_136 L178_182 0.0247
K29351 L131_136 L3_8 0.0307
K29352 L131_136 L149_154 0.0757
K29353 L131_136 L38_43 0.0985
K29354 L131_136 L80_85 0.0381
K29355 L131_136 L96_100 0.0775
K29356 L131_136 L159_164 0.0418
K29357 L131_136 L9_14 0.0319
K29358 L131_136 L44_92 0.0813
K29359 L131_136 L50_54 0.0285
K29360 L131_136 L93_97 0.0598
K29361 L131_136 L134_173 0.0904
K29362 L131_136 L177_181 0.0303
K29363 L131_136 L111_116 0.0286
K29364 L131_136 L162_167 0.0593
K29365 L131_136 L43_91 0.0958
K29366 L131_136 L39_44 0.0881
K29367 L131_136 L61_65 0.0512
K29368 L46_50 L202_206 0.0324
K29369 L46_50 L109_114 0.0555
K29370 L46_50 L196_200 0.0405
K29371 L46_50 L92_96 0.0186
K29372 L46_50 L120_125 0.0385
K29373 L46_50 L7_12 0.0271
K29374 L46_50 L167_172 0.0285
K29375 L46_50 L134_139 0.019
K29376 L46_50 L9_14 0.0244
K29377 L46_50 L33_38 0.0286
K29378 L46_50 L124_129 0.0541
K29379 L46_50 L78_83 0.0325
K29380 L46_50 L112_117 0.1405
K29381 L46_50 L40_45 0.0231
K29382 L46_50 L59_63 0.1273
K29383 L46_50 L15_20 0.0194
K29384 L46_50 L98_102 0.0187
K29385 L46_50 L178_182 0.0195
K29386 L46_50 L3_8 0.0257
K29387 L46_50 L149_154 0.0177
K29388 L46_50 L38_43 0.0266
K29389 L46_50 L115_120 0.0387
K29390 L46_50 L16_21 0.0383
K29391 L46_50 L96_100 0.0182
K29392 L46_50 L125_130 0.0381
K29393 L46_50 L159_164 0.027
K29394 L46_50 L44_92 0.0191
K29395 L46_50 L21_26 0.0322
K29396 L46_50 L165_170 0.0282
K29397 L46_50 L93_97 0.0151
K29398 L46_50 L134_173 0.0256
K29399 L46_50 L177_181 0.0244
K29400 L46_50 L162_167 0.0303
K29401 L46_50 L43_91 0.0197
K29402 L46_50 L142_147 0.0192
K29403 L46_50 L39_44 0.0257
K29404 L46_50 L146_151 0.0252
K29405 L46_50 L61_65 0.0545
K29406 L196_200 L202_206 0.0741
K29407 L196_200 L109_114 0.0421
K29408 L196_200 L9_14 0.0239
K29409 L196_200 L92_96 0.0313
K29410 L196_200 L120_125 0.0359
K29411 L196_200 L7_12 0.0254
K29412 L196_200 L167_172 0.0388
K29413 L196_200 L121_126 0.0484
K29414 L196_200 L33_38 0.0386
K29415 L196_200 L124_129 0.0476
K29416 L196_200 L78_83 0.0734
K29417 L196_200 L134_139 0.0313
K29418 L196_200 L40_45 0.0345
K29419 L196_200 L15_20 0.0198
K29420 L196_200 L66_70 0.1405
K29421 L196_200 L98_102 0.0347
K29422 L196_200 L178_182 0.0189
K29423 L196_200 L3_8 0.024
K29424 L196_200 L149_154 0.0312
K29425 L196_200 L38_43 0.0407
K29426 L196_200 L115_120 0.0348
K29427 L196_200 L80_85 0.1322
K29428 L196_200 L16_21 0.037
K29429 L196_200 L96_100 0.0312
K29430 L196_200 L125_130 0.0371
K29431 L196_200 L159_164 0.0291
K29432 L196_200 L44_92 0.0312
K29433 L196_200 L21_26 0.0327
K29434 L196_200 L165_170 0.0389
K29435 L196_200 L50_54 0.0427
K29436 L196_200 L93_97 0.0249
K29437 L196_200 L134_173 0.0389
K29438 L196_200 L177_181 0.0233
K29439 L196_200 L111_116 0.043
K29440 L196_200 L162_167 0.0362
K29441 L196_200 L43_91 0.0329
K29442 L196_200 L142_147 0.0351
K29443 L196_200 L39_44 0.0387
K29444 L196_200 L146_151 0.0503
K29445 L196_200 L61_65 0.0474
K29446 L92_93 L187_188 0.0265
K29447 L92_93 L21_65 0.0354
K29448 L92_93 L121_122 0.0244
K29449 L92_93 L9_10 0.0237
K29450 L92_93 L134_135 0.1276
K29451 L92_93 L104_105 0.0891
K29452 L92_93 L151_210 0.0563
K29453 L92_93 L112_113 0.0259
K29454 L92_93 L59_60 0.028
K29455 L92_93 L38_39 0.0781
K29456 L92_93 L44_45 0.1436
K29457 L92_93 L47_48 0.024
K29458 L92_93 L6_53 0.0315
K29459 L92_93 L149_150 0.1173
K29460 L92_93 L98_99 0.1124
K29461 L92_93 L80_81 0.0273
K29462 L92_93 L129_130 0.0352
K29463 L92_93 L117_118 0.0269
K29464 L92_93 L116_117 0.0237
K29465 L92_93 L68_69 0.0557
K29466 L92_93 L50_51 0.0231
K29467 L92_93 L111_112 0.0231
K29468 L92_93 L162_163 0.0416
K29469 L92_93 L142_143 0.1226
K29470 L92_93 L39_40 0.079
K29471 L92_96 L202_206 0.0537
K29472 L92_96 L109_114 0.0292
K29473 L92_96 L120_125 0.0319
K29474 L92_96 L7_12 0.0247
K29475 L92_96 L167_172 0.08
K29476 L92_96 L121_126 0.02
K29477 L92_96 L33_38 0.083
K29478 L92_96 L124_129 0.0332
K29479 L92_96 L78_83 0.0544
K29480 L92_96 L112_117 0.0239
K29481 L92_96 L40_45 0.0922
K29482 L92_96 L59_63 0.0252
K29483 L92_96 L15_20 0.0221
K29484 L92_96 L98_102 0.1124
K29485 L92_96 L178_182 0.0194
K29486 L92_96 L3_8 0.0235
K29487 L92_96 L66_70 0.0244
K29488 L92_96 L38_43 0.1482
K29489 L92_96 L115_120 0.0301
K29490 L92_96 L80_85 0.0243
K29491 L92_96 L16_21 0.0339
K29492 L92_96 L125_130 0.0337
K29493 L92_96 L159_164 0.0337
K29494 L92_96 L21_26 0.0385
K29495 L92_96 L165_170 0.0685
K29496 L92_96 L50_54 0.0191
K29497 L92_96 L93_97 0.1916
K29498 L92_96 L111_116 0.019
K29499 L92_96 L162_167 0.0555
K29500 L92_96 L43_91 0.1832
K29501 L92_96 L142_147 0.1127
K29502 L92_96 L146_151 0.0775
K29503 L92_96 L61_65 0.0334
K29504 L120_125 L202_206 0.0437
K29505 L120_125 L109_114 0.1051
K29506 L120_125 L7_12 0.1131
K29507 L120_125 L167_172 0.0643
K29508 L120_125 L121_126 0.0389
K29509 L120_125 L134_139 0.0339
K29510 L120_125 L33_38 0.0635
K29511 L120_125 L124_129 0.1086
K29512 L120_125 L78_83 0.0435
K29513 L120_125 L112_117 0.0506
K29514 L120_125 L40_45 0.0441
K29515 L120_125 L59_63 0.0503
K29516 L120_125 L15_20 0.0604
K29517 L120_125 L66_70 0.0294
K29518 L120_125 L98_102 0.0296
K29519 L120_125 L142_147 0.0314
K29520 L120_125 L178_182 0.0597
K29521 L120_125 L3_8 0.0897
K29522 L120_125 L149_154 0.0287
K29523 L120_125 L38_43 0.0507
K29524 L120_125 L80_85 0.0268
K29525 L120_125 L96_100 0.0301
K29526 L120_125 L159_164 0.0812
K29527 L120_125 L9_14 0.0803
K29528 L120_125 L44_92 0.0337
K29529 L120_125 L50_54 0.0387
K29530 L120_125 L93_97 0.0259
K29531 L120_125 L134_173 0.0495
K29532 L120_125 L177_181 0.0802
K29533 L120_125 L111_116 0.0389
K29534 L120_125 L162_167 0.0842
K29535 L120_125 L43_91 0.0346
K29536 L120_125 L39_44 0.0491
K29537 L120_125 L61_65 0.1053
K29538 L109_114 L9_14 0.0537
K29539 L109_114 L7_12 0.0655
K29540 L109_114 L167_172 0.0514
K29541 L109_114 L121_126 0.0545
K29542 L109_114 L134_139 0.0306
K29543 L109_114 L33_38 0.051
K29544 L109_114 L112_117 0.0741
K29545 L109_114 L40_45 0.0384
K29546 L109_114 L59_63 0.0713
K29547 L109_114 L15_20 0.0412
K29548 L109_114 L66_70 0.0349
K29549 L109_114 L98_102 0.0282
K29550 L109_114 L142_147 0.0295
K29551 L109_114 L178_182 0.0423
K29552 L109_114 L3_8 0.0593
K29553 L109_114 L149_154 0.0271
K29554 L109_114 L38_43 0.0441
K29555 L109_114 L115_120 0.1086
K29556 L109_114 L80_85 0.0312
K29557 L109_114 L16_21 0.0977
K29558 L109_114 L96_100 0.0281
K29559 L109_114 L165_170 0.0513
K29560 L109_114 L125_130 0.1002
K29561 L109_114 L159_164 0.0554
K29562 L109_114 L44_92 0.0305
K29563 L109_114 L21_26 0.0724
K29564 L109_114 L50_54 0.0554
K29565 L109_114 L93_97 0.0237
K29566 L109_114 L134_173 0.0429
K29567 L109_114 L177_181 0.0546
K29568 L109_114 L111_116 0.0558
K29569 L109_114 L162_167 0.0597
K29570 L109_114 L43_91 0.0314
K29571 L109_114 L39_44 0.0427
K29572 L109_114 L146_151 0.0377
K29573 L21_65 L187_188 0.0776
K29574 L21_65 L121_122 0.0611
K29575 L21_65 L134_135 0.0471
K29576 L21_65 L104_105 0.025
K29577 L21_65 L151_210 0.0412
K29578 L21_65 L112_113 0.0837
K29579 L21_65 L59_60 0.0934
K29580 L21_65 L38_39 0.0663
K29581 L21_65 L44_45 0.0475
K29582 L21_65 L47_48 0.0785
K29583 L21_65 L6_53 0.1829
K29584 L21_65 L149_150 0.0313
K29585 L21_65 L98_99 0.0325
K29586 L21_65 L80_81 0.0372
K29587 L21_65 L9_10 0.0573
K29588 L21_65 L117_118 0.0878
K29589 L21_65 L116_117 0.0602
K29590 L21_65 L68_69 0.0502
K29591 L21_65 L50_51 0.0594
K29592 L21_65 L111_112 0.0588
K29593 L21_65 L162_163 0.1182
K29594 L21_65 L137_138 0.0367
K29595 L21_65 L142_143 0.0344
K29596 L21_65 L39_40 0.0636
K29597 L7_12 L202_206 0.0308
K29598 L7_12 L167_172 0.0503
K29599 L7_12 L121_126 0.0269
K29600 L7_12 L9_14 0.1354
K29601 L7_12 L33_38 0.051
K29602 L7_12 L134_139 0.0262
K29603 L7_12 L124_129 0.0643
K29604 L7_12 L78_83 0.0309
K29605 L7_12 L112_117 0.0349
K29606 L7_12 L40_45 0.0354
K29607 L7_12 L59_63 0.0349
K29608 L7_12 L15_20 0.0861
K29609 L7_12 L178_182 0.0789
K29610 L7_12 L3_8 0.1832
K29611 L7_12 L149_154 0.022
K29612 L7_12 L66_70 0.0209
K29613 L7_12 L38_43 0.0394
K29614 L7_12 L115_120 0.1161
K29615 L7_12 L80_85 0.0192
K29616 L7_12 L16_21 0.1129
K29617 L7_12 L96_100 0.0233
K29618 L7_12 L125_130 0.1056
K29619 L7_12 L159_164 0.0836
K29620 L7_12 L44_92 0.0263
K29621 L7_12 L21_26 0.2195
K29622 L7_12 L165_170 0.0583
K29623 L7_12 L50_54 0.0272
K29624 L7_12 L93_97 0.0203
K29625 L7_12 L134_173 0.0385
K29626 L7_12 L177_181 0.1127
K29627 L7_12 L111_116 0.0271
K29628 L7_12 L162_167 0.0699
K29629 L7_12 L43_91 0.0266
K29630 L7_12 L39_44 0.0389
K29631 L7_12 L146_151 0.028
K29632 L7_12 L61_65 0.0654
K29633 L121_122 L9_10 0.0272
K29634 L121_122 L134_135 0.031
K29635 L121_122 L104_105 0.0187
K29636 L121_122 L151_210 0.0343
K29637 L121_122 L112_113 0.1646
K29638 L121_122 L38_39 0.0384
K29639 L121_122 L44_45 0.0309
K29640 L121_122 L47_48 0.1387
K29641 L121_122 L6_53 0.0642
K29642 L121_122 L149_150 0.0231
K29643 L121_122 L98_99 0.0245
K29644 L121_122 L80_81 0.046
K29645 L121_122 L129_130 0.0618
K29646 L121_122 L117_118 0.1933
K29647 L121_122 L116_117 0.3334
K29648 L121_122 L68_69 0.0447
K29649 L121_122 L50_51 0.2117
K29650 L121_122 L111_112 0.2392
K29651 L121_122 L162_163 0.0443
K29652 L121_122 L137_138 0.0262
K29653 L121_122 L142_143 0.0253
K29654 L121_122 L39_40 0.0368
K29655 L167_172 L202_206 0.0568
K29656 L167_172 L121_126 0.0304
K29657 L167_172 L9_14 0.0619
K29658 L167_172 L134_139 0.098
K29659 L167_172 L124_129 0.0597
K29660 L167_172 L78_83 0.0564
K29661 L167_172 L112_117 0.0371
K29662 L167_172 L40_45 0.1403
K29663 L167_172 L59_63 0.0386
K29664 L167_172 L15_20 0.0561
K29665 L167_172 L66_70 0.0309
K29666 L167_172 L98_102 0.0503
K29667 L167_172 L142_147 0.0565
K29668 L167_172 L178_182 0.0458
K29669 L167_172 L149_154 0.0633
K29670 L167_172 L115_120 0.0593
K29671 L167_172 L80_85 0.0291
K29672 L167_172 L16_21 0.069
K29673 L167_172 L96_100 0.0699
K29674 L167_172 L125_130 0.0701
K29675 L167_172 L159_164 0.095
K29676 L167_172 L44_92 0.093
K29677 L167_172 L21_26 0.0946
K29678 L167_172 L165_170 0.2473
K29679 L167_172 L50_54 0.0291
K29680 L167_172 L93_97 0.0635
K29681 L167_172 L134_173 0.1944
K29682 L167_172 L177_181 0.0565
K29683 L167_172 L111_116 0.0292
K29684 L167_172 L39_44 0.1706
K29685 L167_172 L146_151 0.0593
K29686 L167_172 L61_65 0.0592
K29687 L121_126 L202_206 0.0364
K29688 L121_126 L134_139 0.0205
K29689 L121_126 L9_14 0.0243
K29690 L121_126 L33_38 0.0303
K29691 L121_126 L124_129 0.056
K29692 L121_126 L78_83 0.0362
K29693 L121_126 L112_117 0.1402
K29694 L121_126 L40_45 0.0246
K29695 L121_126 L59_63 0.1437
K29696 L121_126 L15_20 0.0194
K29697 L121_126 L98_102 0.0203
K29698 L121_126 L178_182 0.0193
K29699 L121_126 L3_8 0.0253
K29700 L121_126 L149_154 0.0191
K29701 L121_126 L38_43 0.0285
K29702 L121_126 L115_120 0.0387
K29703 L121_126 L16_21 0.0388
K29704 L121_126 L96_100 0.0195
K29705 L121_126 L125_130 0.039
K29706 L121_126 L159_164 0.0278
K29707 L121_126 L44_92 0.0204
K29708 L121_126 L21_26 0.0332
K29709 L121_126 L165_170 0.0304
K29710 L121_126 L93_97 0.0161
K29711 L121_126 L134_173 0.0275
K29712 L121_126 L177_181 0.0242
K29713 L121_126 L162_167 0.0319
K29714 L121_126 L43_91 0.0212
K29715 L121_126 L142_147 0.0209
K29716 L121_126 L39_44 0.0274
K29717 L121_126 L146_151 0.0277
K29718 L121_126 L61_65 0.0555
K29719 L187_188 L9_10 0.1015
K29720 L187_188 L134_135 0.0359
K29721 L187_188 L104_105 0.0186
K29722 L187_188 L151_210 0.0278
K29723 L187_188 L112_113 0.0478
K29724 L187_188 L38_39 0.049
K29725 L187_188 L44_45 0.0356
K29726 L187_188 L47_48 0.0439
K29727 L187_188 L6_53 0.1165
K29728 L187_188 L149_150 0.0235
K29729 L187_188 L98_99 0.0236
K29730 L187_188 L80_81 0.0224
K29731 L187_188 L129_130 0.0803
K29732 L187_188 L117_118 0.0488
K29733 L187_188 L116_117 0.0363
K29734 L187_188 L68_69 0.0296
K29735 L187_188 L50_51 0.0357
K29736 L187_188 L111_112 0.0359
K29737 L187_188 L162_163 0.1098
K29738 L187_188 L137_138 0.0269
K29739 L187_188 L142_143 0.0252
K29740 L187_188 L39_40 0.0484
K29741 L134_135 L9_10 0.0314
K29742 L134_135 L104_105 0.0629
K29743 L134_135 L151_210 0.0608
K29744 L134_135 L112_113 0.0333
K29745 L134_135 L59_60 0.0357
K29746 L134_135 L38_39 0.116
K29747 L134_135 L47_48 0.0307
K29748 L134_135 L6_53 0.0414
K29749 L134_135 L149_150 0.0898
K29750 L134_135 L98_99 0.0808
K29751 L134_135 L80_81 0.0322
K29752 L134_135 L129_130 0.0475
K29753 L134_135 L117_118 0.0346
K29754 L134_135 L116_117 0.0301
K29755 L134_135 L50_51 0.0292
K29756 L134_135 L111_112 0.0293
K29757 L134_135 L162_163 0.0577
K29758 L134_135 L137_138 0.1231
K29759 L134_135 L142_143 0.1004
K29760 L134_135 L39_40 0.118
K29761 L33_38 L202_206 0.0564
K29762 L33_38 L9_14 0.0633
K29763 L33_38 L134_139 0.093
K29764 L33_38 L124_129 0.0592
K29765 L33_38 L78_83 0.0568
K29766 L33_38 L112_117 0.0369
K29767 L33_38 L40_45 0.1538
K29768 L33_38 L59_63 0.0388
K29769 L33_38 L15_20 0.0575
K29770 L33_38 L66_70 0.031
K29771 L33_38 L98_102 0.051
K29772 L33_38 L142_147 0.0555
K29773 L33_38 L178_182 0.0451
K29774 L33_38 L149_154 0.0619
K29775 L33_38 L115_120 0.0586
K29776 L33_38 L80_85 0.0292
K29777 L33_38 L16_21 0.0701
K29778 L33_38 L96_100 0.0718
K29779 L33_38 L125_130 0.069
K29780 L33_38 L159_164 0.0917
K29781 L33_38 L44_92 0.098
K29782 L33_38 L21_26 0.0983
K29783 L33_38 L165_170 0.2027
K29784 L33_38 L50_54 0.0292
K29785 L33_38 L93_97 0.0657
K29786 L33_38 L134_173 0.1706
K29787 L33_38 L177_181 0.0555
K29788 L33_38 L111_116 0.0291
K29789 L33_38 L39_44 0.1944
K29790 L33_38 L146_151 0.0586
K29791 L33_38 L61_65 0.0597
K29792 L134_139 L202_206 0.0537
K29793 L134_139 L124_129 0.0349
K29794 L134_139 L78_83 0.0531
K29795 L134_139 L112_117 0.0246
K29796 L134_139 L40_45 0.1041
K29797 L134_139 L59_63 0.0258
K29798 L134_139 L15_20 0.0235
K29799 L134_139 L98_102 0.0884
K29800 L134_139 L178_182 0.0207
K29801 L134_139 L3_8 0.0248
K29802 L134_139 L66_70 0.0244
K29803 L134_139 L38_43 0.1572
K29804 L134_139 L115_120 0.032
K29805 L134_139 L80_85 0.0241
K29806 L134_139 L16_21 0.0358
K29807 L134_139 L125_130 0.0361
K29808 L134_139 L159_164 0.0365
K29809 L134_139 L21_26 0.0413
K29810 L134_139 L165_170 0.081
K29811 L134_139 L50_54 0.0195
K29812 L134_139 L93_97 0.1266
K29813 L134_139 L111_116 0.0196
K29814 L134_139 L162_167 0.0633
K29815 L134_139 L43_91 0.1536
K29816 L134_139 L142_147 0.1124
K29817 L134_139 L146_151 0.0757
K29818 L134_139 L61_65 0.0347
K29819 L104_105 L9_10 0.0169
K29820 L104_105 L112_113 0.0195
K29821 L104_105 L59_60 0.0209
K29822 L104_105 L38_39 0.0463
K29823 L104_105 L44_45 0.0652
K29824 L104_105 L47_48 0.018
K29825 L104_105 L6_53 0.0228
K29826 L104_105 L149_150 0.1363
K29827 L104_105 L98_99 0.1268
K29828 L104_105 L80_81 0.0267
K29829 L104_105 L129_130 0.0249
K29830 L104_105 L117_118 0.0202
K29831 L104_105 L116_117 0.0182
K29832 L104_105 L68_69 0.0427
K29833 L104_105 L50_51 0.0177
K29834 L104_105 L111_112 0.0177
K29835 L104_105 L162_163 0.0285
K29836 L104_105 L137_138 0.073
K29837 L104_105 L142_143 0.088
K29838 L104_105 L39_40 0.0466
K29839 L151_210 L9_10 0.0244
K29840 L151_210 L112_113 0.0345
K29841 L151_210 L59_60 0.0376
K29842 L151_210 L38_39 0.0574
K29843 L151_210 L44_45 0.06
K29844 L151_210 L47_48 0.0317
K29845 L151_210 L6_53 0.037
K29846 L151_210 L149_150 0.0616
K29847 L151_210 L98_99 0.0776
K29848 L151_210 L80_81 0.0611
K29849 L151_210 L129_130 0.0414
K29850 L151_210 L117_118 0.036
K29851 L151_210 L116_117 0.033
K29852 L151_210 L68_69 0.1173
K29853 L151_210 L50_51 0.0317
K29854 L151_210 L111_112 0.0318
K29855 L151_210 L162_163 0.0408
K29856 L151_210 L137_138 0.0711
K29857 L151_210 L142_143 0.0761
K29858 L151_210 L39_40 0.0546
K29859 L78_83 L9_14 0.0293
K29860 L78_83 L112_117 0.042
K29861 L78_83 L40_45 0.0536
K29862 L78_83 L59_63 0.0457
K29863 L78_83 L15_20 0.0248
K29864 L78_83 L66_70 0.0553
K29865 L78_83 L98_102 0.0667
K29866 L78_83 L142_147 0.0659
K29867 L78_83 L178_182 0.0228
K29868 L78_83 L3_8 0.0288
K29869 L78_83 L149_154 0.0537
K29870 L78_83 L38_43 0.0657
K29871 L78_83 L115_120 0.0413
K29872 L78_83 L80_85 0.0558
K29873 L78_83 L16_21 0.046
K29874 L78_83 L96_100 0.0546
K29875 L78_83 L165_170 0.0573
K29876 L78_83 L125_130 0.0458
K29877 L78_83 L159_164 0.0368
K29878 L78_83 L44_92 0.0537
K29879 L78_83 L21_26 0.0411
K29880 L78_83 L50_54 0.0337
K29881 L78_83 L93_97 0.0421
K29882 L78_83 L134_173 0.0606
K29883 L78_83 L177_181 0.0281
K29884 L78_83 L111_116 0.0336
K29885 L78_83 L162_167 0.0486
K29886 L78_83 L43_91 0.059
K29887 L78_83 L39_44 0.0611
K29888 L78_83 L146_151 0.1053
K29889 L112_117 L202_206 0.0421
K29890 L112_117 L9_14 0.0313
K29891 L112_117 L124_129 0.0733
K29892 L112_117 L40_45 0.0297
K29893 L112_117 L15_20 0.0249
K29894 L112_117 L66_70 0.0453
K29895 L112_117 L98_102 0.024
K29896 L112_117 L178_182 0.025
K29897 L112_117 L3_8 0.0329
K29898 L112_117 L149_154 0.0227
K29899 L112_117 L38_43 0.0343
K29900 L112_117 L115_120 0.0507
K29901 L112_117 L80_85 0.0384
K29902 L112_117 L16_21 0.05
K29903 L112_117 L96_100 0.0233
K29904 L112_117 L125_130 0.0503
K29905 L112_117 L159_164 0.035
K29906 L112_117 L44_92 0.0245
K29907 L112_117 L21_26 0.042
K29908 L112_117 L165_170 0.0369
K29909 L112_117 L50_54 0.1437
K29910 L112_117 L93_97 0.0193
K29911 L112_117 L134_173 0.0331
K29912 L112_117 L177_181 0.0313
K29913 L112_117 L111_116 0.1548
K29914 L112_117 L162_167 0.0395
K29915 L112_117 L43_91 0.0253
K29916 L112_117 L142_147 0.0247
K29917 L112_117 L39_44 0.0331
K29918 L112_117 L146_151 0.0326
K29919 L112_117 L61_65 0.0726
K29920 L98_99 L9_10 0.0211
K29921 L98_99 L112_113 0.0253
K29922 L98_99 L59_60 0.0275
K29923 L98_99 L38_39 0.0606
K29924 L98_99 L44_45 0.0842
K29925 L98_99 L47_48 0.0234
K29926 L98_99 L6_53 0.0291
K29927 L98_99 L129_130 0.0323
K29928 L98_99 L117_118 0.0263
K29929 L98_99 L116_117 0.0237
K29930 L98_99 L68_69 0.0653
K29931 L98_99 L50_51 0.023
K29932 L98_99 L111_112 0.0229
K29933 L98_99 L162_163 0.0361
K29934 L98_99 L137_138 0.1173
K29935 L98_99 L142_143 0.1536
K29936 L98_99 L39_40 0.0595
K29937 L40_45 L9_14 0.0365
K29938 L40_45 L124_129 0.0436
K29939 L40_45 L59_63 0.0312
K29940 L40_45 L66_70 0.0274
K29941 L40_45 L98_102 0.0606
K29942 L40_45 L142_147 0.0661
K29943 L40_45 L3_8 0.0335
K29944 L40_45 L149_154 0.0651
K29945 L40_45 L38_43 0.2076
K29946 L40_45 L115_120 0.0416
K29947 L40_45 L80_85 0.0264
K29948 L40_45 L16_21 0.0474
K29949 L40_45 L96_100 0.0777
K29950 L40_45 L125_130 0.047
K29951 L40_45 L202_206 0.0531
K29952 L40_45 L44_92 0.1128
K29953 L40_45 L21_26 0.058
K29954 L40_45 L165_170 0.1068
K29955 L40_45 L50_54 0.0236
K29956 L40_45 L134_173 0.2296
K29957 L40_45 L177_181 0.0337
K29958 L40_45 L111_116 0.0236
K29959 L40_45 L162_167 0.0917
K29960 L40_45 L43_91 0.1
K29961 L40_45 L39_44 0.305
K29962 L40_45 L146_151 0.0616
K29963 L40_45 L61_65 0.0438
K29964 L165_170 L202_206 0.0578
K29965 L165_170 L124_129 0.0615
K29966 L165_170 L59_63 0.0388
K29967 L165_170 L15_20 0.0483
K29968 L165_170 L66_70 0.031
K29969 L165_170 L98_102 0.0583
K29970 L165_170 L142_147 0.0681
K29971 L165_170 L178_182 0.0404
K29972 L165_170 L3_8 0.051
K29973 L165_170 L149_154 0.0557
K29974 L165_170 L38_43 0.1517
K29975 L165_170 L80_85 0.0289
K29976 L165_170 L96_100 0.0609
K29977 L165_170 L159_164 0.0795
K29978 L165_170 L9_14 0.0546
K29979 L165_170 L44_92 0.0777
K29980 L165_170 L50_54 0.0289
K29981 L165_170 L93_97 0.0537
K29982 L165_170 L134_173 0.1398
K29983 L165_170 L177_181 0.0502
K29984 L165_170 L111_116 0.029
K29985 L165_170 L162_167 0.17
K29986 L165_170 L43_91 0.0844
K29987 L165_170 L39_44 0.1298
K29988 L165_170 L61_65 0.0608
K29989 L59_63 L202_206 0.0455
K29990 L59_63 L9_14 0.0312
K29991 L59_63 L124_129 0.0736
K29992 L59_63 L15_20 0.025
K29993 L59_63 L66_70 0.0517
K29994 L59_63 L98_102 0.0255
K29995 L59_63 L178_182 0.0246
K29996 L59_63 L3_8 0.0327
K29997 L59_63 L149_154 0.0239
K29998 L59_63 L38_43 0.0362
K29999 L59_63 L115_120 0.05
K30000 L59_63 L80_85 0.043
K30001 L59_63 L16_21 0.0507
K30002 L59_63 L96_100 0.0246
K30003 L59_63 L125_130 0.0504
K30004 L59_63 L159_164 0.0354
K30005 L59_63 L44_92 0.0258
K30006 L59_63 L21_26 0.0431
K30007 L59_63 L50_54 0.1402
K30008 L59_63 L93_97 0.0204
K30009 L59_63 L134_173 0.0347
K30010 L59_63 L177_181 0.0309
K30011 L59_63 L111_116 0.1322
K30012 L59_63 L162_167 0.0407
K30013 L59_63 L43_91 0.0268
K30014 L59_63 L142_147 0.0262
K30015 L59_63 L39_44 0.0348
K30016 L59_63 L146_151 0.0347
K30017 L59_63 L61_65 0.0744
K30018 L59_60 L9_10 0.0338
K30019 L59_60 L112_113 0.2117
K30020 L59_60 L38_39 0.0459
K30021 L59_60 L44_45 0.0359
K30022 L59_60 L47_48 0.2072
K30023 L59_60 L6_53 0.0952
K30024 L59_60 L149_150 0.0259
K30025 L59_60 L80_81 0.045
K30026 L59_60 L129_130 0.0911
K30027 L59_60 L117_118 0.2659
K30028 L59_60 L116_117 0.1743
K30029 L59_60 L68_69 0.0495
K30030 L59_60 L50_51 0.1646
K30031 L59_60 L111_112 0.1537
K30032 L59_60 L162_163 0.0564
K30033 L59_60 L137_138 0.0297
K30034 L59_60 L142_143 0.0285
K30035 L59_60 L39_40 0.0438
K30036 L129_130 L112_113 0.0854
K30037 L129_130 L38_39 0.0655
K30038 L129_130 L44_45 0.0471
K30039 L129_130 L47_48 0.077
K30040 L129_130 L6_53 0.1684
K30041 L129_130 L149_150 0.0315
K30042 L129_130 L80_81 0.037
K30043 L129_130 L9_10 0.0563
K30044 L129_130 L117_118 0.0898
K30045 L129_130 L116_117 0.0608
K30046 L129_130 L68_69 0.0498
K30047 L129_130 L50_51 0.0588
K30048 L129_130 L111_112 0.0594
K30049 L129_130 L162_163 0.1237
K30050 L129_130 L137_138 0.037
K30051 L129_130 L142_143 0.0346
K30052 L129_130 L39_40 0.0629
K30053 L38_39 L9_10 0.0419
K30054 L38_39 L112_113 0.0421
K30055 L38_39 L44_45 0.122
K30056 L38_39 L47_48 0.0391
K30057 L38_39 L6_53 0.0554
K30058 L38_39 L149_150 0.0596
K30059 L38_39 L80_81 0.0355
K30060 L38_39 L117_118 0.0438
K30061 L38_39 L116_117 0.0373
K30062 L38_39 L68_69 0.0545
K30063 L38_39 L50_51 0.0363
K30064 L38_39 L111_112 0.0362
K30065 L38_39 L162_163 0.0817
K30066 L38_39 L137_138 0.0758
K30067 L38_39 L142_143 0.0668
K30068 L15_20 L9_14 0.1673
K30069 L15_20 L124_129 0.0417
K30070 L15_20 L66_70 0.0162
K30071 L15_20 L98_102 0.0192
K30072 L15_20 L142_147 0.0202
K30073 L15_20 L3_8 0.0985
K30074 L15_20 L149_154 0.0194
K30075 L15_20 L38_43 0.0415
K30076 L15_20 L115_120 0.0598
K30077 L15_20 L80_85 0.0151
K30078 L15_20 L16_21 0.0615
K30079 L15_20 L96_100 0.0207
K30080 L15_20 L125_130 0.0598
K30081 L15_20 L202_206 0.0247
K30082 L15_20 L44_92 0.0237
K30083 L15_20 L21_26 0.0941
K30084 L15_20 L50_54 0.0195
K30085 L15_20 L134_173 0.0419
K30086 L15_20 L177_181 0.1062
K30087 L15_20 L111_116 0.0194
K30088 L15_20 L162_167 0.0843
K30089 L15_20 L43_91 0.0234
K30090 L15_20 L39_44 0.0424
K30091 L15_20 L146_151 0.0234
K30092 L15_20 L61_65 0.0421
K30093 L44_45 L9_10 0.0316
K30094 L44_45 L112_113 0.0332
K30095 L44_45 L47_48 0.0308
K30096 L44_45 L6_53 0.0416
K30097 L44_45 L149_150 0.0857
K30098 L44_45 L80_81 0.0323
K30099 L44_45 L117_118 0.0344
K30100 L44_45 L116_117 0.0301
K30101 L44_45 L50_51 0.0293
K30102 L44_45 L111_112 0.0292
K30103 L44_45 L162_163 0.057
K30104 L44_45 L137_138 0.1128
K30105 L44_45 L142_143 0.0947
K30106 L44_45 L39_40 0.1244
K30107 L47_48 L9_10 0.0391
K30108 L47_48 L112_113 0.2931
K30109 L47_48 L6_53 0.0947
K30110 L47_48 L149_150 0.0223
K30111 L47_48 L80_81 0.0373
K30112 L47_48 L117_118 0.2334
K30113 L47_48 L116_117 0.1576
K30114 L47_48 L68_69 0.0403
K30115 L47_48 L50_51 0.2045
K30116 L47_48 L111_112 0.1765
K30117 L47_48 L162_163 0.049
K30118 L47_48 L137_138 0.0253
K30119 L47_48 L142_143 0.0243
K30120 L47_48 L39_40 0.0376
K30121 L111_116 L202_206 0.0337
K30122 L111_116 L9_14 0.0244
K30123 L111_116 L124_129 0.0553
K30124 L111_116 L98_102 0.0192
K30125 L111_116 L178_182 0.0195
K30126 L111_116 L3_8 0.0256
K30127 L111_116 L149_154 0.0182
K30128 L111_116 L38_43 0.0272
K30129 L111_116 L115_120 0.039
K30130 L111_116 L16_21 0.0385
K30131 L111_116 L96_100 0.0186
K30132 L111_116 L125_130 0.0387
K30133 L111_116 L159_164 0.0274
K30134 L111_116 L44_92 0.0195
K30135 L111_116 L21_26 0.0325
K30136 L111_116 L93_97 0.0154
K30137 L111_116 L134_173 0.0263
K30138 L111_116 L177_181 0.0244
K30139 L111_116 L162_167 0.031
K30140 L111_116 L43_91 0.0201
K30141 L111_116 L142_147 0.0197
K30142 L111_116 L39_44 0.0262
K30143 L111_116 L146_151 0.0261
K30144 L111_116 L61_65 0.0549
K30145 L98_102 L202_206 0.0655
K30146 L98_102 L9_14 0.0221
K30147 L98_102 L124_129 0.0322
K30148 L98_102 L178_182 0.0172
K30149 L98_102 L3_8 0.0211
K30150 L98_102 L149_154 0.1173
K30151 L98_102 L66_70 0.0268
K30152 L98_102 L38_43 0.0718
K30153 L98_102 L115_120 0.028
K30154 L98_102 L80_85 0.0272
K30155 L98_102 L16_21 0.0314
K30156 L98_102 L96_100 0.1284
K30157 L98_102 L125_130 0.0313
K30158 L98_102 L159_164 0.0289
K30159 L98_102 L44_92 0.0953
K30160 L98_102 L21_26 0.0341
K30161 L98_102 L50_54 0.0192
K30162 L98_102 L93_97 0.0787
K30163 L98_102 L134_173 0.0668
K30164 L98_102 L177_181 0.0209
K30165 L98_102 L162_167 0.0391
K30166 L98_102 L43_91 0.1124
K30167 L98_102 L39_44 0.0685
K30168 L98_102 L146_151 0.1161
K30169 L98_102 L61_65 0.0324
K30170 L178_182 L9_14 0.1266
K30171 L178_182 L124_129 0.0409
K30172 L178_182 L66_70 0.0154
K30173 L178_182 L142_147 0.0181
K30174 L178_182 L3_8 0.1033
K30175 L178_182 L149_154 0.0175
K30176 L178_182 L38_43 0.0346
K30177 L178_182 L115_120 0.0615
K30178 L178_182 L80_85 0.0144
K30179 L178_182 L16_21 0.0556
K30180 L178_182 L96_100 0.0184
K30181 L178_182 L125_130 0.057
K30182 L178_182 L202_206 0.0229
K30183 L178_182 L44_92 0.0206
K30184 L178_182 L21_26 0.0748
K30185 L178_182 L50_54 0.0194
K30186 L178_182 L134_173 0.0355
K30187 L178_182 L177_181 0.1916
K30188 L178_182 L162_167 0.0657
K30189 L178_182 L43_91 0.0204
K30190 L178_182 L39_44 0.0351
K30191 L178_182 L146_151 0.0213
K30192 L178_182 L61_65 0.0405
K30193 L6_53 L149_150 0.0284
K30194 L6_53 L80_81 0.0351
K30195 L6_53 L117_118 0.0969
K30196 L6_53 L116_117 0.0653
K30197 L6_53 L68_69 0.0438
K30198 L6_53 L162_163 0.0902
K30199 L6_53 L137_138 0.0323
K30200 L6_53 L142_143 0.0306
K30201 L6_53 L39_40 0.054
K30202 L149_150 L9_10 0.0211
K30203 L149_150 L112_113 0.0242
K30204 L149_150 L117_118 0.0251
K30205 L149_150 L116_117 0.0225
K30206 L149_150 L68_69 0.0522
K30207 L149_150 L50_51 0.0218
K30208 L149_150 L111_112 0.0218
K30209 L149_150 L162_163 0.0363
K30210 L149_150 L137_138 0.1124
K30211 L149_150 L142_143 0.1439
K30212 L149_150 L39_40 0.0599
K30213 L3_8 L202_206 0.0288
K30214 L3_8 L9_14 0.1832
K30215 L3_8 L124_129 0.0568
K30216 L3_8 L66_70 0.0197
K30217 L3_8 L142_147 0.0221
K30218 L3_8 L149_154 0.021
K30219 L3_8 L115_120 0.0941
K30220 L3_8 L80_85 0.0182
K30221 L3_8 L16_21 0.0869
K30222 L3_8 L96_100 0.0222
K30223 L3_8 L125_130 0.0836
K30224 L3_8 L159_164 0.0812
K30225 L3_8 L44_92 0.025
K30226 L3_8 L21_26 0.1305
K30227 L3_8 L50_54 0.0257
K30228 L3_8 L93_97 0.0194
K30229 L3_8 L134_173 0.0364
K30230 L3_8 L177_181 0.1536
K30231 L3_8 L39_44 0.0366
K30232 L3_8 L146_151 0.0263
K30233 L3_8 L61_65 0.0575
K30234 L149_154 L202_206 0.0544
K30235 L149_154 L124_129 0.0306
K30236 L149_154 L66_70 0.0241
K30237 L149_154 L38_43 0.093
K30238 L149_154 L115_120 0.0273
K30239 L149_154 L80_85 0.0244
K30240 L149_154 L16_21 0.0301
K30241 L149_154 L125_130 0.0303
K30242 L149_154 L159_164 0.0297
K30243 L149_154 L21_26 0.0331
K30244 L149_154 L50_54 0.0181
K30245 L149_154 L93_97 0.1062
K30246 L149_154 L162_167 0.0465
K30247 L149_154 L43_91 0.1015
K30248 L149_154 L142_147 0.1284
K30249 L149_154 L146_151 0.0844
K30250 L149_154 L61_65 0.0305
K30251 L66_70 L202_206 0.0549
K30252 L66_70 L9_14 0.0196
K30253 L66_70 L124_129 0.0391
K30254 L66_70 L38_43 0.0323
K30255 L66_70 L115_120 0.0285
K30256 L66_70 L16_21 0.0304
K30257 L66_70 L96_100 0.0243
K30258 L66_70 L125_130 0.0303
K30259 L66_70 L159_164 0.0236
K30260 L66_70 L44_92 0.0245
K30261 L66_70 L21_26 0.0268
K30262 L66_70 L93_97 0.0195
K30263 L66_70 L134_173 0.0306
K30264 L66_70 L177_181 0.019
K30265 L66_70 L162_167 0.0291
K30266 L66_70 L43_91 0.0257
K30267 L66_70 L142_147 0.0269
K30268 L66_70 L39_44 0.0307
K30269 L66_70 L146_151 0.0381
K30270 L66_70 L61_65 0.0393
K30271 L38_43 L202_206 0.065
K30272 L38_43 L9_14 0.0465
K30273 L38_43 L124_129 0.051
K30274 L38_43 L142_147 0.08
K30275 L38_43 L115_120 0.0474
K30276 L38_43 L80_85 0.031
K30277 L38_43 L16_21 0.0549
K30278 L38_43 L96_100 0.1187
K30279 L38_43 L125_130 0.0544
K30280 L38_43 L159_164 0.0648
K30281 L38_43 L44_92 0.1879
K30282 L38_43 L21_26 0.067
K30283 L38_43 L50_54 0.0272
K30284 L38_43 L93_97 0.1068
K30285 L38_43 L134_173 0.2341
K30286 L38_43 L177_181 0.0422
K30287 L38_43 L39_44 0.2991
K30288 L38_43 L146_151 0.0753
K30289 L38_43 L61_65 0.0514
K30290 L80_81 L9_10 0.0202
K30291 L80_81 L112_113 0.0404
K30292 L80_81 L117_118 0.0425
K30293 L80_81 L116_117 0.0435
K30294 L80_81 L68_69 0.0877
K30295 L80_81 L50_51 0.0414
K30296 L80_81 L111_112 0.0412
K30297 L80_81 L162_163 0.0309
K30298 L80_81 L137_138 0.0301
K30299 L80_81 L142_143 0.0303
K30300 L80_81 L39_40 0.0341
K30301 L115_120 L202_206 0.0415
K30302 L115_120 L124_129 0.1051
K30303 L115_120 L142_147 0.0297
K30304 L115_120 L80_85 0.026
K30305 L115_120 L96_100 0.0286
K30306 L115_120 L159_164 0.0767
K30307 L115_120 L9_14 0.0813
K30308 L115_120 L44_92 0.0319
K30309 L115_120 L50_54 0.0388
K30310 L115_120 L93_97 0.0246
K30311 L115_120 L134_173 0.0464
K30312 L115_120 L177_181 0.0833
K30313 L115_120 L162_167 0.0767
K30314 L115_120 L43_91 0.0326
K30315 L115_120 L39_44 0.0461
K30316 L115_120 L61_65 0.1022
K30317 L80_85 L202_206 0.0554
K30318 L80_85 L9_14 0.0182
K30319 L80_85 L124_129 0.0349
K30320 L80_85 L16_21 0.0277
K30321 L80_85 L96_100 0.0244
K30322 L80_85 L125_130 0.0276
K30323 L80_85 L159_164 0.022
K30324 L80_85 L44_92 0.0242
K30325 L80_85 L21_26 0.0246
K30326 L80_85 L93_97 0.0194
K30327 L80_85 L134_173 0.0295
K30328 L80_85 L177_181 0.0177
K30329 L80_85 L162_167 0.0272
K30330 L80_85 L43_91 0.0254
K30331 L80_85 L142_147 0.027
K30332 L80_85 L39_44 0.0296
K30333 L80_85 L146_151 0.0388
K30334 L80_85 L61_65 0.035
K30335 L16_21 L202_206 0.0458
K30336 L16_21 L124_129 0.1064
K30337 L16_21 L142_147 0.0332
K30338 L16_21 L96_100 0.032
K30339 L16_21 L159_164 0.0826
K30340 L16_21 L9_14 0.0802
K30341 L16_21 L44_92 0.0361
K30342 L16_21 L50_54 0.0387
K30343 L16_21 L93_97 0.0275
K30344 L16_21 L134_173 0.0524
K30345 L16_21 L177_181 0.0735
K30346 L16_21 L162_167 0.0902
K30347 L16_21 L43_91 0.0371
K30348 L16_21 L39_44 0.0529
K30349 L16_21 L61_65 0.1098
K30350 L96_100 L202_206 0.054
K30351 L96_100 L124_129 0.0318
K30352 L96_100 L125_130 0.0319
K30353 L96_100 L159_164 0.0315
K30354 L96_100 L21_26 0.0357
K30355 L96_100 L50_54 0.0186
K30356 L96_100 L93_97 0.1673
K30357 L96_100 L162_167 0.0503
K30358 L96_100 L43_91 0.1439
K30359 L96_100 L142_147 0.1173
K30360 L96_100 L146_151 0.0803
K30361 L96_100 L61_65 0.032
K30362 L9_10 L117_118 0.0339
K30363 L9_10 L116_117 0.0274
K30364 L9_10 L68_69 0.0256
K30365 L9_10 L162_163 0.0758
K30366 L9_10 L137_138 0.0234
K30367 L9_10 L142_143 0.0221
K30368 L9_10 L39_40 0.042
K30369 L125_130 L202_206 0.046
K30370 L125_130 L124_129 0.1098
K30371 L125_130 L142_147 0.0334
K30372 L125_130 L159_164 0.0849
K30373 L125_130 L9_14 0.0775
K30374 L125_130 L44_92 0.0358
K30375 L125_130 L50_54 0.0385
K30376 L125_130 L93_97 0.0274
K30377 L125_130 L134_173 0.0529
K30378 L125_130 L177_181 0.0757
K30379 L125_130 L162_167 0.0927
K30380 L125_130 L43_91 0.0368
K30381 L125_130 L39_44 0.0524
K30382 L125_130 L61_65 0.1064
K30383 L117_118 L112_113 0.3334
K30384 L117_118 L68_69 0.0462
K30385 L117_118 L50_51 0.1743
K30386 L117_118 L111_112 0.1933
K30387 L117_118 L162_163 0.0552
K30388 L117_118 L137_138 0.0286
K30389 L117_118 L142_143 0.0275
K30390 L117_118 L39_40 0.0421
K30391 L159_164 L9_14 0.1041
K30392 L159_164 L124_129 0.0594
K30393 L159_164 L142_147 0.0309
K30394 L159_164 L202_206 0.037
K30395 L159_164 L44_92 0.0362
K30396 L159_164 L21_26 0.1257
K30397 L159_164 L50_54 0.0273
K30398 L159_164 L134_173 0.0678
K30399 L159_164 L177_181 0.0922
K30400 L159_164 L162_167 0.1538
K30401 L159_164 L43_91 0.0357
K30402 L159_164 L39_44 0.0666
K30403 L159_164 L146_151 0.0353
K30404 L159_164 L61_65 0.0588
K30405 L9_14 L202_206 0.0292
K30406 L9_14 L124_129 0.0531
K30407 L9_14 L21_26 0.1247
K30408 L9_14 L50_54 0.0245
K30409 L9_14 L93_97 0.0207
K30410 L9_14 L162_167 0.093
K30411 L9_14 L43_91 0.0266
K30412 L9_14 L142_147 0.0232
K30413 L9_14 L146_151 0.0272
K30414 L9_14 L61_65 0.0537
K30415 L116_117 L112_113 0.1933
K30416 L116_117 L68_69 0.0425
K30417 L116_117 L50_51 0.2659
K30418 L116_117 L111_112 0.3334
K30419 L116_117 L162_163 0.0435
K30420 L116_117 L137_138 0.0253
K30421 L116_117 L142_143 0.0245
K30422 L116_117 L39_40 0.0359
K30423 L202_206 L142_147 0.0671
K30424 L202_206 L44_92 0.0531
K30425 L202_206 L21_26 0.0409
K30426 L202_206 L50_54 0.0336
K30427 L202_206 L93_97 0.0417
K30428 L202_206 L134_173 0.0611
K30429 L202_206 L177_181 0.0282
K30430 L202_206 L162_167 0.0489
K30431 L202_206 L43_91 0.0581
K30432 L202_206 L39_44 0.0606
K30433 L202_206 L146_151 0.1086
K30434 L44_92 L124_129 0.0347
K30435 L44_92 L21_26 0.0418
K30436 L44_92 L50_54 0.0196
K30437 L44_92 L93_97 0.1673
K30438 L44_92 L162_167 0.0619
K30439 L44_92 L43_91 0.2054
K30440 L44_92 L142_147 0.1015
K30441 L44_92 L146_151 0.0735
K30442 L44_92 L61_65 0.0349
K30443 L21_26 L124_129 0.0822
K30444 L21_26 L142_147 0.0364
K30445 L21_26 L50_54 0.0327
K30446 L21_26 L93_97 0.0314
K30447 L21_26 L134_173 0.0637
K30448 L21_26 L177_181 0.1012
K30449 L21_26 L162_167 0.1517
K30450 L21_26 L43_91 0.0427
K30451 L21_26 L39_44 0.0648
K30452 L21_26 L61_65 0.0839
K30453 L50_54 L124_129 0.0549
K30454 L50_54 L93_97 0.0155
K30455 L50_54 L134_173 0.0262
K30456 L50_54 L177_181 0.0243
K30457 L50_54 L162_167 0.0309
K30458 L50_54 L43_91 0.0202
K30459 L50_54 L142_147 0.0197
K30460 L50_54 L39_44 0.0263
K30461 L50_54 L146_151 0.026
K30462 L50_54 L61_65 0.0553
K30463 L50_51 L68_69 0.0406
K30464 L50_51 L162_163 0.0424
K30465 L50_51 L137_138 0.0245
K30466 L50_51 L142_143 0.0237
K30467 L50_51 L39_40 0.035
K30468 L93_97 L124_129 0.0268
K30469 L93_97 L142_147 0.0789
K30470 L93_97 L134_173 0.1131
K30471 L93_97 L177_181 0.0194
K30472 L93_97 L162_167 0.0451
K30473 L93_97 L43_91 0.1144
K30474 L93_97 L39_44 0.1284
K30475 L93_97 L146_151 0.0581
K30476 L93_97 L61_65 0.0269
K30477 L134_173 L124_129 0.0491
K30478 L134_173 L162_167 0.1081
K30479 L134_173 L43_91 0.1101
K30480 L134_173 L142_147 0.0779
K30481 L134_173 L146_151 0.0714
K30482 L134_173 L61_65 0.0488
K30483 L177_181 L124_129 0.0526
K30484 L177_181 L162_167 0.083
K30485 L177_181 L43_91 0.0248
K30486 L177_181 L142_147 0.0221
K30487 L177_181 L146_151 0.026
K30488 L177_181 L61_65 0.052
K30489 L111_112 L68_69 0.0404
K30490 L111_112 L162_163 0.0426
K30491 L111_112 L137_138 0.0245
K30492 L111_112 L142_143 0.0237
K30493 L111_112 L39_40 0.0349
K30494 L162_163 L112_113 0.0534
K30495 L162_163 L68_69 0.0421
K30496 L162_163 L137_138 0.0419
K30497 L162_163 L142_143 0.0389
K30498 L162_163 L39_40 0.0811
K30499 L137_138 L112_113 0.0275
K30500 L137_138 L68_69 0.0689
K30501 L137_138 L142_143 0.2054
K30502 L137_138 L39_40 0.0736
K30503 L124_129 L142_147 0.034
K30504 L124_129 L162_167 0.0686
K30505 L124_129 L43_91 0.0361
K30506 L124_129 L39_44 0.0488
K30507 L124_129 L146_151 0.0437
K30508 L162_167 L142_147 0.0427
K30509 L162_167 L39_44 0.1038
K30510 L162_167 L146_151 0.0477
K30511 L162_167 L61_65 0.0678
K30512 L43_91 L142_147 0.1226
K30513 L43_91 L39_44 0.1187
K30514 L43_91 L146_151 0.0836
K30515 L43_91 L61_65 0.0362
K30516 L142_147 L39_44 0.0754
K30517 L142_147 L146_151 0.1224
K30518 L142_147 L61_65 0.0338
K30519 L68_69 L112_113 0.0436
K30520 L68_69 L142_143 0.0668
K30521 L68_69 L39_40 0.051
K30522 L112_113 L142_143 0.0264
K30523 L112_113 L39_40 0.0406
K30524 L142_143 L39_40 0.0653
K30525 L39_44 L146_151 0.0703
K30526 L39_44 L61_65 0.0491
K30527 L146_151 L61_65 0.0435
Rin205 205 gnd 50.0
Rin313 313 gnd 50.0
Rin159 159 gnd 50.0
Vs 579 gnd DC 0 AC 1.0
Rin547 579 547 50.0
.ac lin 1 464159.0Hz 464159.0Hz
.option post=2
.probe i(L1_49) i(L1_2) i(L1_6) i(L2_3) i(L2_7) i(L3_8) i(L3_4) i(L4_9) i(L4_5) i(L5_10) i(L6_11) i(L6_53) i(L6_7) i(L7_8) i(L7_12) i(L8_9) i(L8_13) i(L9_10) i(L9_14) i(L10_15) i(L11_16) i(L11_57) i(L11_12) i(L12_17) i(L12_13) i(L13_18) i(L13_14) i(L14_19) i(L14_15) i(L15_20) i(L16_17) i(L16_21) i(L16_61) i(L17_18) i(L17_22) i(L18_19) i(L18_23) i(L19_24) i(L19_20) i(L20_25) i(L21_65) i(L21_26) i(L21_22) i(L22_27) i(L22_23) i(L23_24) i(L23_28) i(L24_25) i(L24_29) i(L25_30) i(L26_27) i(L26_31) i(L27_32) i(L27_28) i(L28_33) i(L28_29) i(L29_34) i(L29_30) i(L30_35) i(L31_32) i(L31_36) i(L32_33) i(L32_37) i(L33_34) i(L33_38) i(L34_35) i(L34_39) i(L35_40) i(L36_41) i(L36_37) i(L37_42) i(L37_38) i(L38_43) i(L38_39) i(L39_40) i(L39_44) i(L40_45) i(L41_74) i(L41_42) i(L41_69) i(L42_90) i(L42_43) i(L43_91) i(L43_44) i(L44_92) i(L44_45) i(L45_93) i(L46_50) i(L46_47) i(L47_48) i(L47_51) i(L48_49) i(L48_52) i(L49_53) i(L50_51) i(L50_54) i(L51_55) i(L51_52) i(L52_56) i(L52_53) i(L53_57) i(L54_58) i(L54_55) i(L55_56) i(L55_59) i(L56_60) i(L56_57) i(L57_61) i(L58_59) i(L58_62) i(L59_63) i(L59_60) i(L60_64) i(L60_61) i(L61_65) i(L62_63) i(L63_64) i(L64_65) i(L66_67) i(L66_70) i(L67_68) i(L67_71) i(L68_72) i(L68_69) i(L69_73) i(L70_75) i(L70_71) i(L71_72) i(L71_76) i(L72_73) i(L72_77) i(L73_74) i(L73_78) i(L74_90) i(L74_79) i(L75_80) i(L75_76) i(L76_81) i(L76_77) i(L77_82) i(L77_78) i(L78_83) i(L78_79) i(L79_84) i(L79_94) i(L80_81) i(L80_85) i(L81_82) i(L81_86) i(L82_83) i(L82_87) i(L83_88) i(L83_84) i(L84_89) i(L84_98) i(L85_86) i(L86_87) i(L87_88) i(L88_89) i(L89_102) i(L90_91) i(L90_94) i(L91_92) i(L91_95) i(L92_96) i(L92_93) i(L93_97) i(L94_95) i(L94_98) i(L95_99) i(L95_96) i(L96_100) i(L96_97) i(L97_101) i(L98_99) i(L98_102) i(L99_103) i(L99_100) i(L100_104) i(L100_101) i(L101_105) i(L102_103) i(L103_104) i(L104_105) i(L106_107) i(L106_111) i(L107_112) i(L107_108) i(L108_113) i(L108_109) i(L109_114) i(L109_110) i(L110_115) i(L110_175) i(L111_112) i(L111_116) i(L112_113) i(L112_117) i(L113_114) i(L113_118) i(L114_115) i(L114_119) i(L115_120) i(L115_179) i(L116_121) i(L116_117) i(L117_122) i(L117_118) i(L118_123) i(L118_119) i(L119_120) i(L119_124) i(L120_183) i(L120_125) i(L121_122) i(L121_126) i(L122_123) i(L122_127) i(L123_128) i(L123_124) i(L124_129) i(L124_125) i(L125_130) i(L125_187) i(L126_127) i(L127_128) i(L128_129) i(L129_130) i(L130_160) i(L130_156) i(L131_136) i(L131_170) i(L131_132) i(L131_194) i(L132_137) i(L132_171) i(L132_133) i(L133_172) i(L133_138) i(L133_134) i(L134_139) i(L134_135) i(L134_173) i(L135_140) i(L135_174) i(L136_137) i(L136_141) i(L136_198) i(L137_138) i(L137_142) i(L138_139) i(L138_143) i(L139_144) i(L139_140) i(L140_145) i(L141_146) i(L141_202) i(L141_142) i(L142_147) i(L142_143) i(L143_144) i(L143_148) i(L144_145) i(L144_149) i(L145_150) i(L146_147) i(L146_206) i(L146_151) i(L147_152) i(L147_148) i(L148_153) i(L148_149) i(L149_154) i(L149_150) i(L150_155) i(L151_152) i(L151_210) i(L152_153) i(L153_154) i(L154_155) i(L156_161) i(L156_187) i(L156_157) i(L157_188) i(L157_162) i(L157_158) i(L158_163) i(L158_159) i(L158_189) i(L159_164) i(L159_190) i(L160_161) i(L160_165) i(L161_162) i(L161_166) i(L162_163) i(L162_167) i(L163_168) i(L163_164) i(L164_169) i(L165_170) i(L165_166) i(L166_171) i(L166_167) i(L167_168) i(L167_172) i(L168_169) i(L168_173) i(L169_174) i(L170_171) i(L171_172) i(L172_173) i(L173_174) i(L175_176) i(L175_179) i(L176_177) i(L176_180) i(L177_178) i(L177_181) i(L178_182) i(L179_180) i(L179_183) i(L180_184) i(L180_181) i(L181_182) i(L181_185) i(L182_186) i(L183_184) i(L183_187) i(L184_188) i(L184_185) i(L185_186) i(L185_189) i(L186_190) i(L187_188) i(L188_189) i(L189_190) i(L191_192) i(L191_195) i(L192_193) i(L192_196) i(L193_194) i(L193_197) i(L194_198) i(L195_199) i(L195_196) i(L196_200) i(L196_197) i(L197_198) i(L197_201) i(L198_202) i(L199_200) i(L199_203) i(L200_204) i(L200_201) i(L201_202) i(L201_205) i(L202_206) i(L203_207) i(L203_204) i(L204_208) i(L204_205) i(L205_206) i(L205_209) i(L206_210) i(L207_208) i(L208_209) i(L209_210)
.option GENK=0
.end
