* 2018-11-02 03:38:08
R1_17 1 2 0.00114790072935
L1_17 2 3 5.56279401881e-09
R1_2 3 4 0.00028117003147
L1_2 4 5 8.73672053554e-10
R1_4 3 6 5.43155860415e-05
L1_4 6 7 4.29767461022e-10
R2_3 5 8 0.00028117003147
L2_3 8 9 8.73672053554e-10
R2_5 5 10 0.000140299314904
L2_5 10 11 6.73667238217e-10
R3_6 9 12 0.00028117003147
L3_6 12 13 8.73672053554e-10
R4_19 14 15 0.000543049949291
L4_19 15 7 4.64999886262e-09
R4_5 7 16 0.000140299314904
L4_5 16 11 6.73667238217e-10
R4_7 7 17 5.43155860415e-05
L4_7 17 18 4.29767461022e-10
R5_8 11 19 0.000140299314904
L5_8 19 20 6.73667238217e-10
R5_6 11 21 0.000140299314904
L5_6 21 13 6.73667238217e-10
R6_9 13 22 0.00028117003147
L6_9 22 23 8.73672053554e-10
R7_8 18 24 6.71478190441e-05
L7_8 24 20 4.84531835125e-10
R7_10 18 25 0.000850617903234
L7_10 25 26 3.82443312023e-09
R7_21 27 28 0.00114790072935
L7_21 28 18 5.56279401881e-09
R8_9 20 29 6.71478190441e-05
L8_9 29 23 4.84531835125e-10
R8_11 20 30 0.000413310549139
L8_11 30 31 3.17076627907e-09
R9_12 23 32 0.000850617903234
L9_12 32 33 3.82443312023e-09
R10_11 26 34 4.5093325701e-05
L10_11 34 31 3.84893259591e-10
R10_13 26 35 0.000850617903234
L10_13 35 36 3.82443312023e-09
R11_12 31 37 4.5093325701e-05
L11_12 37 33 3.84893259591e-10
R11_14 31 38 0.000413310549139
L11_14 38 39 3.17076627907e-09
R12_15 33 40 0.000850617903234
L12_15 40 41 3.82443312023e-09
R13_26 36 42 5.43155860415e-05
L13_26 42 43 4.29767461022e-10
R13_14 36 44 6.71478190441e-05
L13_14 44 39 4.84531835125e-10
R13_23 45 46 0.00114790072935
L13_23 46 36 5.56279401881e-09
R14_30 39 47 0.000140299314904
L14_30 47 48 6.73667238217e-10
R14_15 39 49 6.71478190441e-05
L14_15 49 41 4.84531835125e-10
R15_31 41 50 0.00028117003147
L15_31 50 51 8.73672053554e-10
R16_17 52 53 0.00114790072935
L16_17 53 1 5.56279401881e-09
R16_18 52 54 6.71478190441e-05
L16_18 54 55 4.84531835125e-10
R17_19 1 56 5.521860038e-05
L17_19 56 14 4.58383687922e-10
R18_19 55 57 0.000543049949291
L18_19 57 14 4.64999886262e-09
R18_20 55 58 6.71478190441e-05
L18_20 58 59 4.84531835125e-10
R19_21 14 60 5.521860038e-05
L19_21 60 27 4.58383687922e-10
R20_21 59 61 0.00114790072935
L20_21 61 27 5.56279401881e-09
R22_24 62 63 6.71478190441e-05
L22_24 63 64 4.84531835125e-10
R22_23 62 65 0.00114790072935
L22_23 65 45 5.56279401881e-09
R23_25 45 66 5.521860038e-05
L23_25 66 67 4.58383687922e-10
R24_25 64 68 0.000543049949291
L24_25 68 67 4.64999886262e-09
R24_27 64 69 6.71478190441e-05
L24_27 69 70 4.84531835125e-10
R25_26 67 71 0.000543049949291
L25_26 71 43 4.64999886262e-09
R25_28 67 72 5.521860038e-05
L25_28 72 73 4.58383687922e-10
R26_30 43 74 0.000140299314904
L26_30 74 48 6.73667238217e-10
R26_29 43 75 5.43155860415e-05
L26_29 75 76 4.29767461022e-10
R27_28 70 77 0.00114790072935
L27_28 77 73 5.56279401881e-09
R28_29 73 78 0.00114790072935
L28_29 78 76 5.56279401881e-09
R29_32 76 79 0.00028117003147
L29_32 79 80 8.73672053554e-10
R30_32 48 81 0.000140299314904
L30_32 81 80 6.73667238217e-10
R30_31 48 82 0.000140299314904
L30_31 82 51 6.73667238217e-10
R31_33 51 83 0.00028117003147
L31_33 83 84 8.73672053554e-10
R32_33 80 85 0.00028117003147
L32_33 85 84 8.73672053554e-10
R34_35 86 87 0.000283525326975
L34_35 87 88 4.61505034914e-09
R34_39 86 89 0.000283525326975
L34_39 89 90 4.61505034914e-09
R35_40 88 91 0.000274163462879
L35_40 91 92 3.26061412891e-09
R35_36 88 93 0.000283525326975
L35_36 93 94 4.61505034914e-09
R36_41 94 95 0.000274163462879
L36_41 95 96 3.26061412891e-09
R36_37 94 97 0.000283525326975
L36_37 97 98 4.61505034914e-09
R37_42 98 99 0.000274163462879
L37_42 99 100 3.26061412891e-09
R37_38 98 101 0.000283525326975
L37_38 101 102 4.61505034914e-09
R38_43 102 103 0.000283525326975
L38_43 103 104 4.61505034914e-09
R39_40 90 105 0.000274163462879
L39_40 105 92 3.26061412891e-09
R39_44 90 106 0.000283525326975
L39_44 106 107 4.61505034914e-09
R40_41 92 108 0.000274163462879
L40_41 108 96 3.26061412891e-09
R40_45 92 109 0.000274163462879
L40_45 109 110 3.26061412891e-09
R41_42 96 111 0.000274163462879
L41_42 111 100 3.26061412891e-09
R41_46 96 112 0.000274163462879
L41_46 112 113 3.26061412891e-09
R42_43 100 114 0.000274163462879
L42_43 114 104 3.26061412891e-09
R42_47 100 115 0.000274163462879
L42_47 115 116 3.26061412891e-09
R43_48 104 117 0.000283525326975
L43_48 117 118 4.61505034914e-09
R44_49 107 119 0.000283525326975
L44_49 119 120 4.61505034914e-09
R44_45 107 121 0.000274163462879
L44_45 121 110 3.26061412891e-09
R45_50 110 122 0.000274163462879
L45_50 122 123 3.26061412891e-09
R45_46 110 124 0.000274163462879
L45_46 124 113 3.26061412891e-09
R46_51 113 125 0.000274163462879
L46_51 125 126 3.26061412891e-09
R46_47 113 127 0.000274163462879
L46_47 127 116 3.26061412891e-09
R47_48 116 128 0.000274163462879
L47_48 128 118 3.26061412891e-09
R47_52 116 129 0.000274163462879
L47_52 129 130 3.26061412891e-09
R48_53 118 131 0.000283525326975
L48_53 131 132 4.61505034914e-09
R49_50 120 133 0.000274163462879
L49_50 133 123 3.26061412891e-09
R49_54 120 134 0.000283525326975
L49_54 134 135 4.61505034914e-09
R50_51 123 136 0.000274163462879
L50_51 136 126 3.26061412891e-09
R50_55 123 137 0.000274163462879
L50_55 137 138 3.26061412891e-09
R51_56 126 139 0.000274163462879
L51_56 139 140 3.26061412891e-09
R51_52 126 141 0.000274163462879
L51_52 141 130 3.26061412891e-09
R52_57 130 142 0.000274163462879
L52_57 142 143 3.26061412891e-09
R52_53 130 144 0.000274163462879
L52_53 144 132 3.26061412891e-09
R53_58 132 145 0.000283525326975
L53_58 145 146 4.61505034914e-09
R54_55 135 147 0.000283525326975
L54_55 147 138 4.61505034914e-09
R55_56 138 148 0.000283525326975
L55_56 148 140 4.61505034914e-09
R56_57 140 149 0.000283525326975
L56_57 149 143 4.61505034914e-09
R57_58 143 150 0.000283525326975
L57_58 150 146 4.61505034914e-09
R59_60 151 152 0.00114790072935
L59_60 152 153 5.56279401881e-09
R59_62 151 154 6.71478190441e-05
L59_62 154 155 4.84531835125e-10
R60_61 153 156 0.00114790072935
L60_61 156 157 5.56279401881e-09
R60_63 153 158 5.521860038e-05
L60_63 158 159 4.58383687922e-10
R61_64 157 160 5.43155860415e-05
L61_64 160 161 4.29767461022e-10
R61_77 157 162 0.00028117003147
L61_77 162 163 8.73672053554e-10
R62_65 155 164 6.71478190441e-05
L62_65 164 165 4.84531835125e-10
R62_63 155 166 0.000543049949291
L62_63 166 159 4.64999886262e-09
R63_64 159 167 0.000543049949291
L63_64 167 161 4.64999886262e-09
R63_66 159 168 5.521860038e-05
L63_66 168 169 4.58383687922e-10
R64_79 161 170 0.000140299314904
L64_79 170 171 6.73667238217e-10
R64_67 161 172 5.43155860415e-05
L64_67 172 173 4.29767461022e-10
R65_66 165 174 0.00114790072935
L65_66 174 169 5.56279401881e-09
R66_67 169 175 0.00114790072935
L66_67 175 173 5.56279401881e-09
R67_81 173 176 6.71478190441e-05
L67_81 176 177 4.84531835125e-10
R67_83 173 178 0.000850617903234
L67_83 178 179 3.82443312023e-09
R68_69 180 181 0.00114790072935
L68_69 181 182 5.56279401881e-09
R68_71 180 183 6.71478190441e-05
L68_71 183 184 4.84531835125e-10
R69_72 182 185 5.521860038e-05
L69_72 185 186 4.58383687922e-10
R69_70 182 187 0.00114790072935
L69_70 187 188 5.56279401881e-09
R70_73 188 189 5.43155860415e-05
L70_73 189 190 4.29767461022e-10
R70_83 179 191 0.000850617903234
L70_83 191 188 3.82443312023e-09
R70_86 188 192 6.71478190441e-05
L70_86 192 193 4.84531835125e-10
R71_72 184 194 0.000543049949291
L71_72 194 186 4.64999886262e-09
R71_74 184 195 6.71478190441e-05
L71_74 195 196 4.84531835125e-10
R72_73 186 197 0.000543049949291
L72_73 197 190 4.64999886262e-09
R72_75 186 198 5.521860038e-05
L72_75 198 199 4.58383687922e-10
R73_88 190 200 0.000140299314904
L73_88 200 201 6.73667238217e-10
R73_76 190 202 5.43155860415e-05
L73_76 202 203 4.29767461022e-10
R74_75 196 204 0.00114790072935
L74_75 204 199 5.56279401881e-09
R75_76 199 205 0.00114790072935
L75_76 205 203 5.56279401881e-09
R76_90 203 206 0.00028117003147
L76_90 206 207 8.73672053554e-10
R77_78 163 208 0.00028117003147
L77_78 208 209 8.73672053554e-10
R77_79 163 210 0.000140299314904
L77_79 210 171 6.73667238217e-10
R78_80 209 211 0.00028117003147
L78_80 211 212 8.73672053554e-10
R79_81 171 213 0.000140299314904
L79_81 213 177 6.73667238217e-10
R79_80 171 214 0.000140299314904
L79_80 214 212 6.73667238217e-10
R80_82 212 215 0.00028117003147
L80_82 215 216 8.73672053554e-10
R81_82 177 217 6.71478190441e-05
L81_82 217 216 4.84531835125e-10
R81_84 177 218 0.000413310549139
L81_84 218 219 3.17076627907e-09
R82_85 216 220 0.000850617903234
L82_85 220 221 3.82443312023e-09
R83_84 179 222 4.5093325701e-05
L83_84 222 219 3.84893259591e-10
R84_85 219 223 4.5093325701e-05
L84_85 223 221 3.84893259591e-10
R84_86 219 224 0.000413310549139
L84_86 224 193 3.17076627907e-09
R85_87 221 225 0.000850617903234
L85_87 225 226 3.82443312023e-09
R86_88 193 227 0.000140299314904
L86_88 227 201 6.73667238217e-10
R86_87 193 228 6.71478190441e-05
L86_87 228 226 4.84531835125e-10
R87_89 226 229 0.00028117003147
L87_89 229 230 8.73672053554e-10
R88_90 201 231 0.000140299314904
L88_90 231 207 6.73667238217e-10
R88_89 201 232 0.000140299314904
L88_89 232 230 6.73667238217e-10
R89_91 230 233 0.00028117003147
L89_91 233 234 8.73672053554e-10
R90_91 207 235 0.00028117003147
L90_91 235 234 8.73672053554e-10
K0 L1_4 L37_42 0.1067
K1 L1_4 L19_21 0.0735
K2 L1_4 L8_11 0.1094
K3 L1_4 L6_9 0.0688
K4 L1_4 L60_63 0.0738
K5 L1_4 L14_30 0.0423
K6 L1_4 L23_25 0.0447
K7 L1_4 L77_79 0.1
K8 L1_4 L35_40 0.0741
K9 L1_4 L72_75 0.0412
K10 L1_4 L16_18 0.0587
K11 L1_4 L44_49 0.0544
K12 L1_4 L63_66 0.0728
K13 L1_4 L3_6 0.0704
K14 L1_4 L15_31 0.0353
K15 L1_4 L48_53 0.0624
K16 L1_4 L84_86 0.0732
K17 L1_4 L2_5 0.1028
K18 L1_4 L22_24 0.04
K19 L1_4 L38_43 0.0624
K20 L1_4 L88_90 0.0381
K21 L1_4 L50_55 0.0623
K22 L1_4 L47_52 0.1067
K23 L1_4 L5_8 0.099
K24 L1_4 L45_50 0.0741
K25 L1_4 L79_81 0.0965
K26 L1_4 L80_82 0.0678
K27 L1_4 L62_65 0.0579
K28 L1_4 L89_91 0.0321
K29 L1_4 L17_19 0.0746
K30 L1_4 L52_57 0.0674
K31 L1_4 L87_89 0.0351
K32 L1_4 L41_46 0.134
K33 L1_4 L18_20 0.0582
K34 L1_4 L86_88 0.0421
K35 L1_4 L34_39 0.0544
K36 L1_4 L53_58 0.0475
K37 L1_4 L42_47 0.192
K38 L1_4 L78_80 0.0693
K39 L1_4 L59_62 0.0584
K40 L1_4 L49_54 0.0474
K41 L1_4 L40_45 0.0756
K42 L1_4 L69_72 0.0445
K43 L1_4 L43_48 0.0765
K44 L1_4 L31_33 0.0322
K45 L1_4 L82_85 0.0836
K46 L1_4 L30_32 0.0383
K47 L1_4 L71_74 0.0373
K48 L1_4 L51_56 0.0853
K49 L1_4 L85_87 0.0616
K50 L1_4 L81_84 0.1076
K51 L1_4 L9_12 0.0846
K52 L1_4 L36_41 0.1268
K53 L1_4 L46_51 0.1268
K54 L1_4 L25_28 0.0413
K55 L1_4 L68_71 0.0399
K56 L1_4 L24_27 0.0374
K57 L1_4 L11_14 0.0738
K58 L1_4 L39_44 0.0552
K59 L1_4 L12_15 0.062
K60 L13_14 L2_3 0.0416
K61 L13_14 L52_53 0.1585
K62 L13_14 L54_55 0.0391
K63 L13_14 L32_33 0.0749
K64 L13_14 L81_82 0.0641
K65 L13_14 L16_17 0.0499
K66 L13_14 L41_42 0.0699
K67 L13_14 L4_19 0.0713
K68 L13_14 L77_78 0.0413
K69 L13_14 L65_66 0.0566
K70 L13_14 L63_64 0.0708
K71 L13_14 L8_9 0.0647
K72 L13_14 L40_41 0.0621
K73 L13_14 L83_84 0.0993
K74 L13_14 L57_58 0.0721
K75 L13_14 L64_79 0.0497
K76 L13_14 L20_21 0.0569
K77 L13_14 L74_75 0.0476
K78 L13_14 L72_73 0.0862
K79 L13_14 L73_88 0.1133
K80 L13_14 L55_56 0.0516
K81 L13_14 L50_51 0.0764
K82 L13_14 L5_6 0.0496
K83 L13_14 L46_47 0.1238
K84 L13_14 L67_81 0.0649
K85 L13_14 L36_37 0.0511
K86 L13_14 L79_80 0.0493
K87 L13_14 L4_5 0.0501
K88 L13_14 L34_35 0.0393
K89 L13_14 L25_26 0.0871
K90 L13_14 L60_61 0.0622
K91 L13_14 L62_63 0.0558
K92 L13_14 L1_17 0.0625
K93 L13_14 L10_11 0.1011
K94 L13_14 L56_57 0.0687
K95 L13_14 L66_67 0.0774
K96 L13_14 L76_90 0.0755
K97 L13_14 L35_36 0.0466
K98 L13_14 L42_43 0.0701
K99 L13_14 L37_38 0.0512
K100 L13_14 L49_50 0.0521
K101 L13_14 L28_29 0.0727
K102 L13_14 L1_2 0.042
K103 L13_14 L75_76 0.0721
K104 L13_14 L88_89 0.1078
K105 L13_14 L26_30 0.118
K106 L13_14 L7_21 0.0782
K107 L13_14 L45_46 0.0921
K108 L13_14 L59_60 0.0497
K109 L13_14 L30_31 0.1118
K110 L13_14 L51_52 0.1366
K111 L13_14 L71_72 0.0539
K112 L13_14 L39_40 0.0505
K113 L13_14 L27_28 0.0477
K114 L13_14 L61_77 0.0417
K115 L13_14 L44_45 0.0631
K116 L13_14 L84_85 0.0971
K117 L13_14 L47_48 0.1252
K118 L13_14 L29_32 0.0772
K119 L13_14 L11_12 0.0987
K120 L13_14 L90_91 0.0733
K121 L13_14 L24_25 0.0541
K122 L13_14 L18_19 0.056
K123 L13_14 L7_8 0.0655
K124 L23_25 L62_65 0.0524
K125 L23_25 L8_11 0.0464
K126 L23_25 L82_85 0.0393
K127 L23_25 L6_9 0.0275
K128 L23_25 L26_29 0.0735
K129 L23_25 L14_30 0.0444
K130 L23_25 L37_42 0.0476
K131 L23_25 L77_79 0.0314
K132 L23_25 L35_40 0.0618
K133 L23_25 L16_18 0.0474
K134 L23_25 L44_49 0.0743
K135 L23_25 L48_53 0.0477
K136 L23_25 L3_6 0.026
K137 L23_25 L15_31 0.0347
K138 L23_25 L7_10 0.0443
K139 L23_25 L84_86 0.0547
K140 L23_25 L2_5 0.0315
K141 L23_25 L22_24 0.1108
K142 L23_25 L70_73 0.0738
K143 L23_25 L49_54 0.0747
K144 L23_25 L38_43 0.0341
K145 L23_25 L50_55 0.1097
K146 L23_25 L47_52 0.0835
K147 L23_25 L5_8 0.0335
K148 L23_25 L4_7 0.0484
K149 L23_25 L45_50 0.1088
K150 L23_25 L79_81 0.0334
K151 L23_25 L80_82 0.0274
K152 L23_25 L52_57 0.0876
K153 L23_25 L89_91 0.0343
K154 L23_25 L34_39 0.0482
K155 L23_25 L87_89 0.0345
K156 L23_25 L41_46 0.0781
K157 L23_25 L18_20 0.0526
K158 L23_25 L86_88 0.0442
K159 L23_25 L10_13 0.0535
K160 L23_25 L53_58 0.0488
K161 L23_25 L42_47 0.0627
K162 L23_25 L78_80 0.026
K163 L23_25 L81_84 0.0463
K164 L23_25 L59_62 0.0472
K165 L23_25 L13_26 0.0746
K166 L23_25 L40_45 0.0859
K167 L23_25 L43_48 0.041
K168 L23_25 L31_33 0.0345
K169 L23_25 L64_67 0.0482
K170 L23_25 L30_32 0.0441
K171 L23_25 L71_74 0.1042
K172 L23_25 L51_56 0.16
K173 L23_25 L85_87 0.0453
K174 L23_25 L61_64 0.0445
K175 L23_25 L9_12 0.0394
K176 L23_25 L36_41 0.0534
K177 L23_25 L73_76 0.0728
K178 L23_25 L67_83 0.0442
K179 L23_25 L46_51 0.1381
K180 L23_25 L88_90 0.0439
K181 L23_25 L68_71 0.1079
K182 L23_25 L24_27 0.1069
K183 L23_25 L11_14 0.0549
K184 L23_25 L39_44 0.0629
K185 L23_25 L70_83 0.0532
K186 L23_25 L12_15 0.0454
K187 L77_79 L37_42 0.1665
K188 L77_79 L19_21 0.0439
K189 L77_79 L82_85 0.1139
K190 L77_79 L6_9 0.1228
K191 L77_79 L26_29 0.0381
K192 L77_79 L85_87 0.0612
K193 L77_79 L35_40 0.0505
K194 L77_79 L72_75 0.0296
K195 L77_79 L16_18 0.0367
K196 L77_79 L63_66 0.0441
K197 L77_79 L3_6 0.1377
K198 L77_79 L15_31 0.0318
K199 L77_79 L7_10 0.2209
K200 L77_79 L48_53 0.062
K201 L77_79 L69_72 0.0315
K202 L77_79 L22_24 0.0281
K203 L77_79 L70_73 0.0423
K204 L77_79 L49_54 0.0339
K205 L77_79 L38_43 0.062
K206 L77_79 L50_55 0.0443
K207 L77_79 L47_52 0.1665
K208 L77_79 L43_48 0.0883
K209 L77_79 L4_7 0.0965
K210 L77_79 L45_50 0.0505
K211 L77_79 L80_82 0.1344
K212 L77_79 L62_65 0.0367
K213 L77_79 L89_91 0.0285
K214 L77_79 L17_19 0.0442
K215 L77_79 L52_57 0.0805
K216 L77_79 L87_89 0.032
K217 L77_79 L41_46 0.0817
K218 L77_79 L18_20 0.0365
K219 L77_79 L34_39 0.0378
K220 L77_79 L53_58 0.0426
K221 L77_79 L42_47 0.1928
K222 L77_79 L78_80 0.1544
K223 L77_79 L59_62 0.0369
K224 L77_79 L10_13 0.0925
K225 L77_79 L13_26 0.0421
K226 L77_79 L40_45 0.0512
K227 L77_79 L64_67 0.099
K228 L77_79 L31_33 0.0284
K229 L77_79 L60_63 0.0444
K230 L77_79 L39_44 0.0382
K231 L77_79 L71_74 0.0268
K232 L77_79 L51_56 0.06
K233 L77_79 L9_12 0.1098
K234 L77_79 L36_41 0.079
K235 L77_79 L73_76 0.0383
K236 L77_79 L67_83 0.268
K237 L77_79 L46_51 0.079
K238 L77_79 L25_28 0.0296
K239 L77_79 L68_71 0.0282
K240 L77_79 L24_27 0.0267
K241 L77_79 L44_49 0.0378
K242 L77_79 L61_64 0.1028
K243 L77_79 L70_83 0.0949
K244 L77_79 L12_15 0.0606
K245 L77_78 L52_53 0.0604
K246 L77_78 L54_55 0.0232
K247 L77_78 L32_33 0.0228
K248 L77_78 L81_82 0.1335
K249 L77_78 L70_86 0.0416
K250 L77_78 L4_19 0.0618
K251 L77_78 L86_87 0.042
K252 L77_78 L65_66 0.0344
K253 L77_78 L14_15 0.0417
K254 L77_78 L8_9 0.1248
K255 L77_78 L28_29 0.0303
K256 L77_78 L83_84 0.0731
K257 L77_78 L57_58 0.0339
K258 L77_78 L74_75 0.0251
K259 L77_78 L20_21 0.0342
K260 L77_78 L72_73 0.0358
K261 L77_78 L73_88 0.0288
K262 L77_78 L55_56 0.0276
K263 L77_78 L75_76 0.0304
K264 L77_78 L50_51 0.0412
K265 L77_78 L5_6 0.1927
K266 L77_78 L22_23 0.0271
K267 L77_78 L67_81 0.1226
K268 L77_78 L36_37 0.0775
K269 L77_78 L79_80 0.2525
K270 L77_78 L4_5 0.1588
K271 L77_78 L34_35 0.0374
K272 L77_78 L25_26 0.0357
K273 L77_78 L63_64 0.0623
K274 L77_78 L62_63 0.0381
K275 L77_78 L46_47 0.0816
K276 L77_78 L10_11 0.0719
K277 L77_78 L90_91 0.0229
K278 L77_78 L66_67 0.0548
K279 L77_78 L76_90 0.0228
K280 L77_78 L35_36 0.0545
K281 L77_78 L56_57 0.032
K282 L77_78 L37_38 0.0801
K283 L77_78 L49_50 0.0321
K284 L77_78 L13_23 0.0343
K285 L77_78 L64_79 0.1891
K286 L77_78 L68_69 0.0272
K287 L77_78 L88_89 0.029
K288 L77_78 L26_30 0.0287
K289 L77_78 L7_21 0.0544
K290 L77_78 L69_70 0.0344
K291 L77_78 L45_46 0.0506
K292 L77_78 L7_8 0.1158
K293 L77_78 L30_31 0.0288
K294 L77_78 L51_52 0.0535
K295 L77_78 L71_72 0.0288
K296 L77_78 L27_28 0.025
K297 L77_78 L44_45 0.0359
K298 L77_78 L84_85 0.0748
K299 L77_78 L47_48 0.114
K300 L77_78 L29_32 0.0227
K301 L77_78 L11_12 0.0735
K302 L77_78 L24_25 0.0287
K303 L77_78 L18_19 0.038
K304 L35_40 L37_42 0.1149
K305 L35_40 L19_21 0.097
K306 L35_40 L8_11 0.0651
K307 L35_40 L6_9 0.0407
K308 L35_40 L26_29 0.0521
K309 L35_40 L14_30 0.0397
K310 L35_40 L72_75 0.0581
K311 L35_40 L86_88 0.0397
K312 L35_40 L44_49 0.1179
K313 L35_40 L48_53 0.0617
K314 L35_40 L63_66 0.097
K315 L35_40 L3_6 0.0413
K316 L35_40 L15_31 0.0333
K317 L35_40 L7_10 0.0619
K318 L35_40 L2_5 0.0505
K319 L35_40 L82_85 0.0557
K320 L35_40 L70_73 0.0545
K321 L35_40 L49_54 0.0826
K322 L35_40 L38_43 0.0701
K323 L35_40 L47_52 0.0923
K324 L35_40 L5_8 0.0496
K325 L35_40 L4_7 0.0723
K326 L35_40 L67_83 0.0619
K327 L35_40 L79_81 0.0496
K328 L35_40 L80_82 0.0407
K329 L35_40 L52_57 0.0767
K330 L35_40 L89_91 0.0322
K331 L35_40 L17_19 0.102
K332 L35_40 L34_39 0.2499
K333 L35_40 L87_89 0.0333
K334 L35_40 L41_46 0.159
K335 L35_40 L25_28 0.0581
K336 L35_40 L10_13 0.0557
K337 L35_40 L53_58 0.0545
K338 L35_40 L42_47 0.1078
K339 L35_40 L78_80 0.0413
K340 L35_40 L81_84 0.0651
K341 L35_40 L13_26 0.0545
K342 L35_40 L64_67 0.0723
K343 L35_40 L43_48 0.0677
K344 L35_40 L31_33 0.0322
K345 L35_40 L60_63 0.102
K346 L35_40 L30_32 0.0382
K347 L35_40 L51_56 0.0901
K348 L35_40 L85_87 0.0511
K349 L35_40 L61_64 0.0741
K350 L35_40 L9_12 0.0557
K351 L35_40 L36_41 0.1835
K352 L35_40 L73_76 0.0521
K353 L35_40 L46_51 0.1191
K354 L35_40 L88_90 0.0382
K355 L35_40 L84_86 0.0591
K356 L35_40 L69_72 0.0618
K357 L35_40 L11_14 0.0591
K358 L35_40 L39_44 0.1871
K359 L35_40 L70_83 0.0557
K360 L35_40 L12_15 0.0511
K361 L65_66 L52_53 0.0729
K362 L65_66 L54_55 0.0569
K363 L65_66 L32_33 0.0323
K364 L65_66 L16_17 0.2236
K365 L65_66 L41_42 0.1262
K366 L65_66 L4_19 0.1571
K367 L65_66 L86_87 0.0522
K368 L65_66 L84_85 0.0688
K369 L65_66 L14_15 0.052
K370 L65_66 L70_86 0.0569
K371 L65_66 L13_23 0.0731
K372 L65_66 L40_41 0.1527
K373 L65_66 L57_58 0.048
K374 L65_66 L74_75 0.0678
K375 L65_66 L2_3 0.0342
K376 L65_66 L72_73 0.0748
K377 L65_66 L73_88 0.0423
K378 L65_66 L55_56 0.0617
K379 L65_66 L75_76 0.0618
K380 L65_66 L50_51 0.1206
K381 L65_66 L5_6 0.0392
K382 L65_66 L22_23 0.0833
K383 L65_66 L36_37 0.0883
K384 L65_66 L79_80 0.0393
K385 L65_66 L4_5 0.0433
K386 L65_66 L34_35 0.0883
K387 L65_66 L25_26 0.0745
K388 L65_66 L60_61 0.1405
K389 L65_66 L63_64 0.1626
K390 L65_66 L62_63 0.299
K391 L65_66 L46_47 0.1636
K392 L65_66 L1_17 0.1366
K393 L65_66 L10_11 0.0773
K394 L65_66 L56_57 0.0569
K395 L65_66 L83_84 0.0778
K396 L65_66 L88_89 0.0395
K397 L65_66 L76_90 0.0344
K398 L65_66 L35_36 0.1003
K399 L65_66 L42_43 0.0848
K400 L65_66 L37_38 0.0652
K401 L65_66 L49_50 0.1
K402 L65_66 L28_29 0.0615
K403 L65_66 L64_79 0.0435
K404 L65_66 L68_69 0.084
K405 L65_66 L26_30 0.0421
K406 L65_66 L69_70 0.0736
K407 L65_66 L45_46 0.3211
K408 L65_66 L59_60 0.238
K409 L65_66 L30_31 0.0394
K410 L65_66 L51_52 0.1
K411 L65_66 L71_72 0.0839
K412 L65_66 L39_40 0.1262
K413 L65_66 L27_28 0.0675
K414 L65_66 L61_77 0.0379
K415 L65_66 L44_45 0.1636
K416 L65_66 L47_48 0.0887
K417 L65_66 L29_32 0.0343
K418 L65_66 L11_12 0.0684
K419 L65_66 L90_91 0.0324
K420 L65_66 L24_25 0.0834
K421 L65_66 L18_19 0.2746
K422 L65_66 L1_2 0.0378
K423 L72_73 L2_3 0.0357
K424 L72_73 L52_53 0.1731
K425 L72_73 L54_55 0.078
K426 L72_73 L32_33 0.1061
K427 L72_73 L81_82 0.0518
K428 L72_73 L16_17 0.0632
K429 L72_73 L60_61 0.0689
K430 L72_73 L4_19 0.0778
K431 L72_73 L86_87 0.0759
K432 L72_73 L14_15 0.0754
K433 L72_73 L8_9 0.0516
K434 L72_73 L28_29 0.2746
K435 L72_73 L40_41 0.0761
K436 L72_73 L57_58 0.0987
K437 L72_73 L64_79 0.044
K438 L72_73 L20_21 0.0745
K439 L72_73 L74_75 0.1626
K440 L72_73 L55_56 0.1152
K441 L72_73 L68_69 0.1825
K442 L72_73 L5_6 0.0416
K443 L72_73 L22_23 0.1727
K444 L72_73 L67_81 0.0549
K445 L72_73 L36_37 0.0584
K446 L72_73 L79_80 0.0418
K447 L72_73 L4_5 0.0439
K448 L72_73 L34_35 0.0509
K449 L72_73 L41_42 0.0786
K450 L72_73 L63_64 0.0781
K451 L72_73 L62_63 0.0716
K452 L72_73 L46_47 0.1266
K453 L72_73 L1_17 0.0686
K454 L72_73 L10_11 0.0713
K455 L72_73 L56_57 0.1354
K456 L72_73 L83_84 0.0716
K457 L72_73 L66_67 0.0839
K458 L72_73 L76_90 0.1419
K459 L72_73 L35_36 0.0569
K460 L72_73 L42_43 0.0727
K461 L72_73 L37_38 0.0549
K462 L72_73 L49_50 0.1176
K463 L72_73 L13_23 0.351
K464 L72_73 L1_2 0.0375
K465 L72_73 L75_76 0.299
K466 L72_73 L7_21 0.0834
K467 L72_73 L69_70 0.4206
K468 L72_73 L70_86 0.0871
K469 L72_73 L59_60 0.0635
K470 L72_73 L50_51 0.236
K471 L72_73 L51_52 0.3174
K472 L72_73 L39_40 0.0662
K473 L72_73 L27_28 0.1571
K474 L72_73 L61_77 0.0376
K475 L72_73 L44_45 0.0887
K476 L72_73 L84_85 0.0663
K477 L72_73 L47_48 0.1062
K478 L72_73 L29_32 0.1342
K479 L72_73 L11_12 0.066
K480 L72_73 L90_91 0.1096
K481 L72_73 L45_46 0.1172
K482 L72_73 L18_19 0.0713
K483 L72_73 L7_8 0.0547
K484 L88_90 L37_42 0.0551
K485 L88_90 L19_21 0.0314
K486 L88_90 L82_85 0.0463
K487 L88_90 L6_9 0.0318
K488 L88_90 L26_29 0.1
K489 L88_90 L85_87 0.0728
K490 L88_90 L72_75 0.0444
K491 L88_90 L16_18 0.0267
K492 L88_90 L63_66 0.0315
K493 L88_90 L3_6 0.0284
K494 L88_90 L15_31 0.1228
K495 L88_90 L7_10 0.0621
K496 L88_90 L48_53 0.0673
K497 L88_90 L69_72 0.0441
K498 L88_90 L22_24 0.0365
K499 L88_90 L70_73 0.099
K500 L88_90 L49_54 0.0384
K501 L88_90 L38_43 0.0334
K502 L88_90 L50_55 0.0517
K503 L88_90 L47_52 0.1928
K504 L88_90 L43_48 0.0456
K505 L88_90 L4_7 0.0421
K506 L88_90 L45_50 0.0512
K507 L88_90 L80_82 0.032
K508 L88_90 L62_65 0.0282
K509 L88_90 L89_91 0.1544
K510 L88_90 L17_19 0.0296
K511 L88_90 L52_57 0.2115
K512 L88_90 L87_89 0.1344
K513 L88_90 L41_46 0.0638
K514 L88_90 L18_20 0.0281
K515 L88_90 L34_39 0.0299
K516 L88_90 L53_58 0.0839
K517 L88_90 L42_47 0.0907
K518 L88_90 L78_80 0.0285
K519 L88_90 L59_62 0.0268
K520 L88_90 L10_13 0.1212
K521 L88_90 L13_26 0.0965
K522 L88_90 L40_45 0.0457
K523 L88_90 L64_67 0.0423
K524 L88_90 L31_33 0.1377
K525 L88_90 L60_63 0.0296
K526 L88_90 L39_44 0.0348
K527 L88_90 L71_74 0.0369
K528 L88_90 L51_56 0.0834
K529 L88_90 L9_12 0.046
K530 L88_90 L36_41 0.047
K531 L88_90 L73_76 0.1028
K532 L88_90 L67_83 0.0628
K533 L88_90 L46_51 0.0817
K534 L88_90 L25_28 0.0442
K535 L88_90 L68_71 0.0367
K536 L88_90 L24_27 0.0367
K537 L88_90 L44_49 0.0382
K538 L88_90 L61_64 0.0383
K539 L88_90 L70_83 0.1273
K540 L88_90 L12_15 0.0717
K541 L22_24 L37_42 0.0445
K542 L22_24 L19_21 0.0526
K543 L22_24 L8_11 0.0411
K544 L22_24 L6_9 0.0244
K545 L22_24 L26_29 0.0582
K546 L22_24 L14_30 0.0369
K547 L22_24 L72_75 0.1042
K548 L22_24 L86_88 0.0367
K549 L22_24 L44_49 0.1
K550 L22_24 L48_53 0.0426
K551 L22_24 L63_66 0.0524
K552 L22_24 L3_6 0.0233
K553 L22_24 L15_31 0.0293
K554 L22_24 L7_10 0.0391
K555 L22_24 L2_5 0.0282
K556 L22_24 L82_85 0.0349
K557 L22_24 L70_73 0.0584
K558 L22_24 L49_54 0.101
K559 L22_24 L38_43 0.0317
K560 L22_24 L47_52 0.0723
K561 L22_24 L5_8 0.0297
K562 L22_24 L4_7 0.0428
K563 L22_24 L67_83 0.039
K564 L22_24 L79_81 0.0296
K565 L22_24 L80_82 0.0243
K566 L22_24 L52_57 0.075
K567 L22_24 L89_91 0.0291
K568 L22_24 L17_19 0.0474
K569 L22_24 L34_39 0.0527
K570 L22_24 L87_89 0.0292
K571 L22_24 L41_46 0.0724
K572 L22_24 L25_28 0.1069
K573 L22_24 L10_13 0.0454
K574 L22_24 L53_58 0.0434
K575 L22_24 L42_47 0.0569
K576 L22_24 L78_80 0.0233
K577 L22_24 L81_84 0.0409
K578 L22_24 L13_26 0.0587
K579 L22_24 L64_67 0.0426
K580 L22_24 L43_48 0.0374
K581 L22_24 L31_33 0.0292
K582 L22_24 L60_63 0.0472
K583 L22_24 L30_32 0.0367
K584 L22_24 L51_56 0.1289
K585 L22_24 L85_87 0.0391
K586 L22_24 L61_64 0.0399
K587 L22_24 L9_12 0.0349
K588 L22_24 L36_41 0.0508
K589 L22_24 L73_76 0.0579
K590 L22_24 L46_51 0.1163
K591 L22_24 L84_86 0.0468
K592 L22_24 L69_72 0.1079
K593 L22_24 L11_14 0.0469
K594 L22_24 L39_44 0.076
K595 L22_24 L70_83 0.0452
K596 L22_24 L12_15 0.0392
K597 L70_73 L37_42 0.0547
K598 L70_73 L19_21 0.0482
K599 L70_73 L8_11 0.0652
K600 L70_73 L6_9 0.0386
K601 L70_73 L60_63 0.0447
K602 L70_73 L14_30 0.1
K603 L70_73 L72_75 0.0735
K604 L70_73 L16_18 0.0399
K605 L70_73 L44_49 0.0556
K606 L70_73 L63_66 0.0484
K607 L70_73 L3_6 0.0351
K608 L70_73 L15_31 0.0693
K609 L70_73 L48_53 0.0689
K610 L70_73 L84_86 0.0957
K611 L70_73 L2_5 0.0421
K612 L70_73 L38_43 0.0407
K613 L70_73 L50_55 0.0768
K614 L70_73 L47_52 0.1352
K615 L70_73 L5_8 0.0468
K616 L70_73 L45_50 0.0765
K617 L70_73 L79_81 0.0471
K618 L70_73 L80_82 0.0388
K619 L70_73 L62_65 0.0428
K620 L70_73 L89_91 0.0688
K621 L70_73 L17_19 0.0445
K622 L70_73 L52_57 0.1534
K623 L70_73 L87_89 0.0704
K624 L70_73 L41_46 0.1007
K625 L70_73 L18_20 0.0426
K626 L70_73 L86_88 0.1028
K627 L70_73 L34_39 0.0424
K628 L70_73 L53_58 0.0719
K629 L70_73 L42_47 0.0793
K630 L70_73 L78_80 0.0353
K631 L70_73 L59_62 0.04
K632 L70_73 L49_54 0.0558
K633 L70_73 L40_45 0.0676
K634 L70_73 L69_72 0.0746
K635 L70_73 L43_48 0.053
K636 L70_73 L31_33 0.0678
K637 L70_73 L82_85 0.056
K638 L70_73 L30_32 0.0965
K639 L70_73 L71_74 0.0582
K640 L70_73 L51_56 0.1406
K641 L70_73 L85_87 0.0765
K642 L70_73 L81_84 0.0656
K643 L70_73 L9_12 0.0557
K644 L70_73 L36_41 0.0679
K645 L70_73 L46_51 0.1389
K646 L70_73 L25_28 0.0728
K647 L70_73 L68_71 0.0587
K648 L70_73 L24_27 0.0579
K649 L70_73 L11_14 0.0945
K650 L70_73 L39_44 0.0506
K651 L70_73 L12_15 0.0758
K652 L5_6 L2_3 0.2525
K653 L5_6 L52_53 0.0711
K654 L5_6 L32_33 0.027
K655 L5_6 L81_82 0.1632
K656 L5_6 L70_86 0.0493
K657 L5_6 L16_17 0.056
K658 L5_6 L41_42 0.1254
K659 L5_6 L7_8 0.1598
K660 L5_6 L86_87 0.0497
K661 L5_6 L14_15 0.0501
K662 L5_6 L8_9 0.1795
K663 L5_6 L28_29 0.0355
K664 L5_6 L40_41 0.0795
K665 L5_6 L57_58 0.0395
K666 L5_6 L74_75 0.029
K667 L5_6 L20_21 0.0393
K668 L5_6 L73_88 0.0339
K669 L5_6 L55_56 0.0319
K670 L5_6 L75_76 0.0354
K671 L5_6 L50_51 0.0477
K672 L5_6 L22_23 0.0314
K673 L5_6 L67_81 0.1482
K674 L5_6 L36_37 0.0804
K675 L5_6 L34_35 0.0416
K676 L5_6 L25_26 0.0418
K677 L5_6 L60_61 0.1206
K678 L5_6 L83_84 0.0879
K679 L5_6 L46_47 0.0956
K680 L5_6 L1_17 0.1259
K681 L5_6 L10_11 0.0896
K682 L5_6 L56_57 0.0372
K683 L5_6 L66_67 0.0628
K684 L5_6 L76_90 0.0267
K685 L5_6 L35_36 0.059
K686 L5_6 L42_43 0.1314
K687 L5_6 L37_38 0.0826
K688 L5_6 L49_50 0.0369
K689 L5_6 L13_23 0.0401
K690 L5_6 L68_69 0.0314
K691 L5_6 L88_89 0.0341
K692 L5_6 L26_30 0.034
K693 L5_6 L7_21 0.0634
K694 L5_6 L69_70 0.04
K695 L5_6 L45_46 0.0582
K696 L5_6 L59_60 0.0556
K697 L5_6 L30_31 0.0343
K698 L5_6 L51_52 0.0626
K699 L5_6 L71_72 0.0332
K700 L5_6 L39_40 0.0523
K701 L5_6 L27_28 0.029
K702 L5_6 L61_77 0.1588
K703 L5_6 L44_45 0.0411
K704 L5_6 L84_85 0.0902
K705 L5_6 L47_48 0.1377
K706 L5_6 L29_32 0.0268
K707 L5_6 L11_12 0.0921
K708 L5_6 L90_91 0.0269
K709 L5_6 L24_25 0.0333
K710 L5_6 L54_55 0.0267
K711 L5_6 L1_2 0.1891
K712 L22_23 L2_3 0.0272
K713 L22_23 L52_53 0.0988
K714 L22_23 L54_55 0.0946
K715 L22_23 L32_33 0.0478
K716 L22_23 L81_82 0.0381
K717 L22_23 L16_17 0.0678
K718 L22_23 L41_42 0.0714
K719 L22_23 L4_19 0.0699
K720 L22_23 L63_64 0.0696
K721 L22_23 L8_9 0.0382
K722 L22_23 L40_41 0.0757
K723 L22_23 L83_84 0.0496
K724 L22_23 L57_58 0.0652
K725 L22_23 L64_79 0.0333
K726 L22_23 L20_21 0.084
K727 L22_23 L74_75 0.2236
K728 L22_23 L73_88 0.0643
K729 L22_23 L55_56 0.1201
K730 L22_23 L50_51 0.3604
K731 L22_23 L46_47 0.1093
K732 L22_23 L67_81 0.0407
K733 L22_23 L36_37 0.0534
K734 L22_23 L79_80 0.0314
K735 L22_23 L4_5 0.0334
K736 L22_23 L34_35 0.0534
K737 L22_23 L25_26 0.1825
K738 L22_23 L60_61 0.0615
K739 L22_23 L62_63 0.0768
K740 L22_23 L1_17 0.0618
K741 L22_23 L10_11 0.0498
K742 L22_23 L56_57 0.0946
K743 L22_23 L66_67 0.0731
K744 L22_23 L76_90 0.0544
K745 L22_23 L35_36 0.0559
K746 L22_23 L42_43 0.0605
K747 L22_23 L37_38 0.0466
K748 L22_23 L49_50 0.2029
K749 L22_23 L28_29 0.1405
K750 L22_23 L1_2 0.0288
K751 L22_23 L75_76 0.1366
K752 L22_23 L88_89 0.0556
K753 L22_23 L26_30 0.0649
K754 L22_23 L7_21 0.0736
K755 L22_23 L45_46 0.1259
K756 L22_23 L59_60 0.0675
K757 L22_23 L30_31 0.056
K758 L22_23 L51_52 0.2029
K759 L22_23 L71_72 0.351
K760 L22_23 L39_40 0.0714
K761 L22_23 L27_28 0.238
K762 L22_23 L61_77 0.0287
K763 L22_23 L44_45 0.1093
K764 L22_23 L84_85 0.046
K765 L22_23 L47_48 0.0791
K766 L22_23 L29_32 0.0548
K767 L22_23 L11_12 0.0461
K768 L22_23 L90_91 0.0475
K769 L22_23 L24_25 0.4206
K770 L22_23 L18_19 0.0772
K771 L22_23 L7_8 0.0408
K772 L5_8 L37_42 0.1408
K773 L5_8 L19_21 0.0444
K774 L5_8 L82_85 0.1401
K775 L5_8 L6_9 0.1544
K776 L5_8 L26_29 0.0423
K777 L5_8 L85_87 0.0717
K778 L5_8 L72_75 0.0314
K779 L5_8 L16_18 0.0367
K780 L5_8 L63_66 0.0442
K781 L5_8 L3_6 0.1344
K782 L5_8 L15_31 0.0363
K783 L5_8 L7_10 0.3014
K784 L5_8 L48_53 0.0673
K785 L5_8 L69_72 0.0334
K786 L5_8 L49_54 0.0348
K787 L5_8 L38_43 0.0572
K788 L5_8 L50_55 0.0457
K789 L5_8 L47_52 0.1928
K790 L5_8 L43_48 0.0839
K791 L5_8 L4_7 0.1028
K792 L5_8 L45_50 0.0512
K793 L5_8 L80_82 0.1377
K794 L5_8 L62_65 0.0367
K795 L5_8 L89_91 0.0318
K796 L5_8 L17_19 0.0441
K797 L5_8 L52_57 0.0907
K798 L5_8 L87_89 0.0361
K799 L5_8 L41_46 0.0834
K800 L5_8 L18_20 0.0369
K801 L5_8 L34_39 0.0372
K802 L5_8 L53_58 0.0456
K803 L5_8 L42_47 0.2115
K804 L5_8 L78_80 0.1228
K805 L5_8 L59_62 0.0365
K806 L5_8 L10_13 0.1273
K807 L5_8 L13_26 0.0471
K808 L5_8 L40_45 0.0517
K809 L5_8 L64_67 0.1
K810 L5_8 L31_33 0.032
K811 L5_8 L60_63 0.0439
K812 L5_8 L39_44 0.0384
K813 L5_8 L71_74 0.0281
K814 L5_8 L51_56 0.0638
K815 L5_8 L9_12 0.1492
K816 L5_8 L36_41 0.0756
K817 L5_8 L73_76 0.0421
K818 L5_8 L67_83 0.2439
K819 L5_8 L46_51 0.0817
K820 L5_8 L25_28 0.0315
K821 L5_8 L68_71 0.0296
K822 L5_8 L24_27 0.0282
K823 L5_8 L44_49 0.0382
K824 L5_8 L61_64 0.0965
K825 L5_8 L70_83 0.1212
K826 L5_8 L12_15 0.0728
K827 L4_7 L37_42 0.0959
K828 L4_7 L19_21 0.0746
K829 L4_7 L8_11 0.1234
K830 L4_7 L6_9 0.0704
K831 L4_7 L60_63 0.0728
K832 L4_7 L14_30 0.0471
K833 L4_7 L72_75 0.0445
K834 L4_7 L16_18 0.0582
K835 L4_7 L44_49 0.0552
K836 L4_7 L63_66 0.0738
K837 L4_7 L3_6 0.0688
K838 L4_7 L15_31 0.0388
K839 L4_7 L48_53 0.0657
K840 L4_7 L84_86 0.083
K841 L4_7 L2_5 0.099
K842 L4_7 L38_43 0.0591
K843 L4_7 L50_55 0.065
K844 L4_7 L47_52 0.1196
K845 L4_7 L45_50 0.0756
K846 L4_7 L79_81 0.1
K847 L4_7 L80_82 0.0693
K848 L4_7 L62_65 0.0584
K849 L4_7 L89_91 0.0351
K850 L4_7 L17_19 0.0735
K851 L4_7 L52_57 0.0729
K852 L4_7 L87_89 0.0386
K853 L4_7 L41_46 0.1389
K854 L4_7 L18_20 0.0587
K855 L4_7 L86_88 0.0468
K856 L4_7 L34_39 0.0533
K857 L4_7 L53_58 0.0502
K858 L4_7 L42_47 0.1733
K859 L4_7 L78_80 0.0678
K860 L4_7 L59_62 0.0579
K861 L4_7 L49_54 0.049
K862 L4_7 L40_45 0.0765
K863 L4_7 L69_72 0.0482
K864 L4_7 L43_48 0.0745
K865 L4_7 L31_33 0.0353
K866 L4_7 L82_85 0.0908
K867 L4_7 L30_32 0.0423
K868 L4_7 L71_74 0.0399
K869 L4_7 L51_56 0.0926
K870 L4_7 L85_87 0.0683
K871 L4_7 L81_84 0.1208
K872 L4_7 L9_12 0.092
K873 L4_7 L36_41 0.1183
K874 L4_7 L46_51 0.134
K875 L4_7 L25_28 0.0447
K876 L4_7 L68_71 0.0426
K877 L4_7 L24_27 0.04
K878 L4_7 L11_14 0.0838
K879 L4_7 L39_44 0.0556
K880 L4_7 L12_15 0.0689
K881 L4_5 L2_3 0.1891
K882 L4_5 L52_53 0.0686
K883 L4_5 L32_33 0.0268
K884 L4_5 L81_82 0.1482
K885 L4_5 L70_86 0.0497
K886 L4_5 L16_17 0.0649
K887 L4_5 L41_42 0.1314
K888 L4_5 L7_8 0.1795
K889 L4_5 L86_87 0.0493
K890 L4_5 L14_15 0.0496
K891 L4_5 L8_9 0.1598
K892 L4_5 L28_29 0.0371
K893 L4_5 L40_41 0.0877
K894 L4_5 L57_58 0.0388
K895 L4_5 L74_75 0.0305
K896 L4_5 L20_21 0.0435
K897 L4_5 L73_88 0.0341
K898 L4_5 L55_56 0.033
K899 L4_5 L75_76 0.037
K900 L4_5 L50_51 0.0504
K901 L4_5 L67_81 0.1632
K902 L4_5 L36_37 0.0826
K903 L4_5 L34_35 0.0444
K904 L4_5 L25_26 0.044
K905 L4_5 L60_61 0.1634
K906 L4_5 L83_84 0.0902
K907 L4_5 L46_47 0.1079
K908 L4_5 L1_17 0.1805
K909 L4_5 L10_11 0.0921
K910 L4_5 L56_57 0.038
K911 L4_5 L66_67 0.0738
K912 L4_5 L76_90 0.0269
K913 L4_5 L35_36 0.0635
K914 L4_5 L42_43 0.1336
K915 L4_5 L37_38 0.0834
K916 L4_5 L49_50 0.0387
K917 L4_5 L13_23 0.0426
K918 L4_5 L68_69 0.0333
K919 L4_5 L88_89 0.0339
K920 L4_5 L26_30 0.0343
K921 L4_5 L7_21 0.0747
K922 L4_5 L69_70 0.0424
K923 L4_5 L45_46 0.0634
K924 L4_5 L59_60 0.0643
K925 L4_5 L30_31 0.034
K926 L4_5 L51_52 0.0657
K927 L4_5 L71_72 0.0352
K928 L4_5 L39_40 0.0563
K929 L4_5 L27_28 0.0305
K930 L4_5 L61_77 0.1927
K931 L4_5 L44_45 0.0437
K932 L4_5 L84_85 0.0879
K933 L4_5 L47_48 0.1222
K934 L4_5 L29_32 0.027
K935 L4_5 L11_12 0.0896
K936 L4_5 L90_91 0.0267
K937 L4_5 L24_25 0.0352
K938 L4_5 L54_55 0.0277
K939 L4_5 L1_2 0.2525
K940 L34_35 L2_3 0.0374
K941 L34_35 L54_55 0.054
K942 L34_35 L32_33 0.0252
K943 L34_35 L81_82 0.0466
K944 L34_35 L70_86 0.0393
K945 L34_35 L16_17 0.1053
K946 L34_35 L41_42 0.1179
K947 L34_35 L4_19 0.0809
K948 L34_35 L86_87 0.0379
K949 L34_35 L14_15 0.0379
K950 L34_35 L8_9 0.0466
K951 L34_35 L28_29 0.0442
K952 L34_35 L40_41 0.1871
K953 L34_35 L57_58 0.0434
K954 L34_35 L64_79 0.0444
K955 L34_35 L20_21 0.0883
K956 L34_35 L74_75 0.0482
K957 L34_35 L73_88 0.0309
K958 L34_35 L55_56 0.0524
K959 L34_35 L68_69 0.0534
K960 L34_35 L67_81 0.0494
K961 L34_35 L50_51 0.0814
K962 L34_35 L79_80 0.0416
K963 L34_35 L52_53 0.0609
K964 L34_35 L25_26 0.0509
K965 L34_35 L60_61 0.077
K966 L34_35 L63_64 0.0809
K967 L34_35 L62_63 0.1071
K968 L34_35 L46_47 0.0917
K969 L34_35 L1_17 0.077
K970 L34_35 L10_11 0.0499
K971 L34_35 L56_57 0.0484
K972 L34_35 L83_84 0.0499
K973 L34_35 L66_67 0.0695
K974 L34_35 L76_90 0.026
K975 L34_35 L42_43 0.0826
K976 L34_35 L49_50 0.0856
K977 L34_35 L13_23 0.0481
K978 L34_35 L1_2 0.0401
K979 L34_35 L75_76 0.0442
K980 L34_35 L88_89 0.0299
K981 L34_35 L26_30 0.0309
K982 L34_35 L7_21 0.0695
K983 L34_35 L69_70 0.0481
K984 L34_35 L45_46 0.1152
K985 L34_35 L59_60 0.1053
K986 L34_35 L30_31 0.0299
K987 L34_35 L51_52 0.0716
K988 L34_35 L71_72 0.056
K989 L34_35 L39_40 0.2499
K990 L34_35 L27_28 0.0482
K991 L34_35 L61_77 0.0401
K992 L34_35 L44_45 0.1278
K993 L34_35 L84_85 0.0475
K994 L34_35 L47_48 0.072
K995 L34_35 L29_32 0.026
K996 L34_35 L11_12 0.0475
K997 L34_35 L90_91 0.0252
K998 L34_35 L24_25 0.056
K999 L34_35 L18_19 0.1071
K1000 L34_35 L7_8 0.0494
K1001 L41_42 L52_53 0.1078
K1002 L41_42 L54_55 0.0617
K1003 L41_42 L32_33 0.0419
K1004 L41_42 L81_82 0.1199
K1005 L41_42 L70_86 0.0699
K1006 L41_42 L4_19 0.1987
K1007 L41_42 L86_87 0.0691
K1008 L41_42 L14_15 0.0691
K1009 L41_42 L8_9 0.1199
K1010 L41_42 L28_29 0.0668
K1011 L41_42 L83_84 0.1024
K1012 L41_42 L57_58 0.0677
K1013 L41_42 L74_75 0.0637
K1014 L41_42 L20_21 0.1262
K1015 L41_42 L73_88 0.0517
K1016 L41_42 L55_56 0.0677
K1017 L41_42 L75_76 0.0668
K1018 L41_42 L50_51 0.1078
K1019 L41_42 L67_81 0.1238
K1020 L41_42 L36_37 0.2499
K1021 L41_42 L79_80 0.1254
K1022 L41_42 L25_26 0.0786
K1023 L41_42 L63_64 0.1987
K1024 L41_42 L62_63 0.1553
K1025 L41_42 L46_47 0.1835
K1026 L41_42 L10_11 0.1024
K1027 L41_42 L90_91 0.0419
K1028 L41_42 L66_67 0.1527
K1029 L41_42 L76_90 0.0422
K1030 L41_42 L35_36 0.1871
K1031 L41_42 L56_57 0.0701
K1032 L41_42 L37_38 0.1871
K1033 L41_42 L49_50 0.0923
K1034 L41_42 L13_23 0.0757
K1035 L41_42 L64_79 0.1314
K1036 L41_42 L68_69 0.0714
K1037 L41_42 L88_89 0.0512
K1038 L41_42 L26_30 0.0517
K1039 L41_42 L7_21 0.1527
K1040 L41_42 L69_70 0.0757
K1041 L41_42 L45_46 0.159
K1042 L41_42 L7_8 0.1238
K1043 L41_42 L30_31 0.0512
K1044 L41_42 L51_52 0.1149
K1045 L41_42 L71_72 0.0745
K1046 L41_42 L27_28 0.0637
K1047 L41_42 L44_45 0.1191
K1048 L41_42 L84_85 0.1005
K1049 L41_42 L47_48 0.159
K1050 L41_42 L29_32 0.0422
K1051 L41_42 L11_12 0.1005
K1052 L41_42 L24_25 0.0745
K1053 L41_42 L18_19 0.1553
K1054 L41_46 L37_42 0.159
K1055 L41_46 L19_21 0.1862
K1056 L41_46 L8_11 0.1148
K1057 L41_46 L82_85 0.0932
K1058 L41_46 L6_9 0.0652
K1059 L41_46 L26_29 0.0926
K1060 L41_46 L14_30 0.0678
K1061 L41_46 L72_75 0.0715
K1062 L41_46 L16_18 0.1529
K1063 L41_46 L44_49 0.1152
K1064 L41_46 L63_66 0.1862
K1065 L41_46 L3_6 0.0641
K1066 L41_46 L15_31 0.0549
K1067 L41_46 L7_10 0.1137
K1068 L41_46 L84_86 0.1043
K1069 L41_46 L2_5 0.0817
K1070 L41_46 L69_72 0.0781
K1071 L41_46 L49_54 0.0917
K1072 L41_46 L38_43 0.0903
K1073 L41_46 L50_55 0.1191
K1074 L41_46 L47_52 0.159
K1075 L41_46 L45_50 0.159
K1076 L41_46 L79_81 0.0834
K1077 L41_46 L80_82 0.0652
K1078 L41_46 L62_65 0.1416
K1079 L41_46 L89_91 0.0522
K1080 L41_46 L17_19 0.213
K1081 L41_46 L34_39 0.1152
K1082 L41_46 L87_89 0.0549
K1083 L41_46 L18_20 0.1416
K1084 L41_46 L86_88 0.0678
K1085 L41_46 L10_13 0.1018
K1086 L41_46 L53_58 0.0775
K1087 L41_46 L42_47 0.1835
K1088 L41_46 L78_80 0.0641
K1089 L41_46 L81_84 0.1148
K1090 L41_46 L59_62 0.1529
K1091 L41_46 L13_26 0.1007
K1092 L41_46 L40_45 0.1835
K1093 L41_46 L64_67 0.1389
K1094 L41_46 L43_48 0.0962
K1095 L41_46 L31_33 0.0522
K1096 L41_46 L60_63 0.213
K1097 L41_46 L30_32 0.0638
K1098 L41_46 L71_74 0.0668
K1099 L41_46 L85_87 0.0862
K1100 L41_46 L61_64 0.134
K1101 L41_46 L9_12 0.0932
K1102 L41_46 L48_53 0.0903
K1103 L41_46 L73_76 0.0926
K1104 L41_46 L67_83 0.1137
K1105 L41_46 L52_57 0.1191
K1106 L41_46 L25_28 0.0715
K1107 L41_46 L68_71 0.0724
K1108 L41_46 L24_27 0.0668
K1109 L41_46 L11_14 0.1043
K1110 L41_46 L39_44 0.1278
K1111 L41_46 L70_83 0.1018
K1112 L41_46 L12_15 0.0862
K1113 L34_39 L37_42 0.0856
K1114 L34_39 L19_21 0.0687
K1115 L34_39 L8_11 0.0494
K1116 L34_39 L82_85 0.0424
K1117 L34_39 L6_9 0.0307
K1118 L34_39 L26_29 0.0408
K1119 L34_39 L14_30 0.0309
K1120 L34_39 L72_75 0.0457
K1121 L34_39 L16_18 0.0928
K1122 L34_39 L48_53 0.0484
K1123 L34_39 L63_66 0.0687
K1124 L34_39 L3_6 0.0311
K1125 L34_39 L15_31 0.026
K1126 L34_39 L7_10 0.0467
K1127 L34_39 L84_86 0.0455
K1128 L34_39 L2_5 0.0378
K1129 L34_39 L69_72 0.0482
K1130 L34_39 L38_43 0.054
K1131 L34_39 L50_55 0.0826
K1132 L34_39 L47_52 0.0716
K1133 L34_39 L45_50 0.1179
K1134 L34_39 L79_81 0.0372
K1135 L34_39 L80_82 0.0307
K1136 L34_39 L62_65 0.0875
K1137 L34_39 L89_91 0.0252
K1138 L34_39 L17_19 0.0712
K1139 L34_39 L52_57 0.0609
K1140 L34_39 L87_89 0.026
K1141 L34_39 L18_20 0.0875
K1142 L34_39 L86_88 0.0309
K1143 L34_39 L10_13 0.0429
K1144 L34_39 L53_58 0.0434
K1145 L34_39 L42_47 0.0814
K1146 L34_39 L78_80 0.0311
K1147 L34_39 L59_62 0.0928
K1148 L34_39 L13_26 0.0424
K1149 L34_39 L40_45 0.1871
K1150 L34_39 L64_67 0.0533
K1151 L34_39 L43_48 0.0524
K1152 L34_39 L31_33 0.0252
K1153 L34_39 L60_63 0.0712
K1154 L34_39 L30_32 0.0299
K1155 L34_39 L71_74 0.0493
K1156 L34_39 L51_56 0.072
K1157 L34_39 L85_87 0.0395
K1158 L34_39 L81_84 0.0494
K1159 L34_39 L9_12 0.0424
K1160 L34_39 L36_41 0.1278
K1161 L34_39 L73_76 0.0408
K1162 L34_39 L67_83 0.0467
K1163 L34_39 L46_51 0.0917
K1164 L34_39 L25_28 0.0457
K1165 L34_39 L68_71 0.0527
K1166 L34_39 L24_27 0.0493
K1167 L34_39 L11_14 0.0455
K1168 L34_39 L61_64 0.0544
K1169 L34_39 L70_83 0.0429
K1170 L34_39 L12_15 0.0395
K1171 L53_58 L37_42 0.0758
K1172 L53_58 L19_21 0.0395
K1173 L53_58 L8_11 0.0734
K1174 L53_58 L82_85 0.0717
K1175 L53_58 L6_9 0.0421
K1176 L53_58 L26_29 0.0745
K1177 L53_58 L14_30 0.0785
K1178 L53_58 L72_75 0.0496
K1179 L53_58 L16_18 0.0351
K1180 L53_58 L44_49 0.0524
K1181 L53_58 L63_66 0.0395
K1182 L53_58 L3_6 0.0391
K1183 L53_58 L15_31 0.0815
K1184 L53_58 L7_10 0.0656
K1185 L53_58 L2_5 0.0426
K1186 L53_58 L69_72 0.0488
K1187 L53_58 L49_54 0.054
K1188 L53_58 L50_55 0.0701
K1189 L53_58 L47_52 0.133
K1190 L53_58 L45_50 0.0677
K1191 L53_58 L79_81 0.0456
K1192 L53_58 L80_82 0.0421
K1193 L53_58 L52_57 0.1527
K1194 L53_58 L89_91 0.0893
K1195 L53_58 L17_19 0.0381
K1196 L53_58 L87_89 0.0815
K1197 L53_58 L18_20 0.0362
K1198 L53_58 L86_88 0.0785
K1199 L53_58 L10_13 0.0824
K1200 L53_58 L84_86 0.0932
K1201 L53_58 L42_47 0.1
K1202 L53_58 L78_80 0.0391
K1203 L53_58 L81_84 0.0734
K1204 L53_58 L59_62 0.0351
K1205 L53_58 L13_26 0.0719
K1206 L53_58 L40_45 0.0617
K1207 L53_58 L64_67 0.0502
K1208 L53_58 L31_33 0.0893
K1209 L53_58 L85_87 0.0957
K1210 L53_58 L60_63 0.0381
K1211 L53_58 L30_32 0.0839
K1212 L53_58 L71_74 0.0441
K1213 L53_58 L51_56 0.0962
K1214 L53_58 L62_65 0.0362
K1215 L53_58 L61_64 0.0475
K1216 L53_58 L9_12 0.0717
K1217 L53_58 L36_41 0.0645
K1218 L53_58 L73_76 0.0745
K1219 L53_58 L67_83 0.0656
K1220 L53_58 L46_51 0.0903
K1221 L53_58 L25_28 0.0496
K1222 L53_58 L68_71 0.0434
K1223 L53_58 L24_27 0.0441
K1224 L53_58 L11_14 0.0932
K1225 L53_58 L39_44 0.0484
K1226 L53_58 L70_83 0.0824
K1227 L53_58 L12_15 0.0957
K1228 L76_90 L2_3 0.0227
K1229 L76_90 L81_82 0.034
K1230 L76_90 L70_86 0.0772
K1231 L76_90 L16_17 0.0303
K1232 L76_90 L4_19 0.0394
K1233 L76_90 L86_87 0.0749
K1234 L76_90 L14_15 0.0733
K1235 L76_90 L8_9 0.0338
K1236 L76_90 L40_41 0.0389
K1237 L76_90 L83_84 0.0473
K1238 L76_90 L57_58 0.0815
K1239 L76_90 L64_79 0.027
K1240 L76_90 L20_21 0.0343
K1241 L76_90 L73_88 0.1544
K1242 L76_90 L55_56 0.0457
K1243 L76_90 L68_69 0.0548
K1244 L76_90 L67_81 0.0342
K1245 L76_90 L36_37 0.0316
K1246 L76_90 L79_80 0.0268
K1247 L76_90 L25_26 0.1342
K1248 L76_90 L60_61 0.035
K1249 L76_90 L62_63 0.0341
K1250 L76_90 L46_47 0.0652
K1251 L76_90 L1_17 0.0349
K1252 L76_90 L10_11 0.0469
K1253 L76_90 L56_57 0.0737
K1254 L76_90 L66_67 0.0414
K1255 L76_90 L35_36 0.0296
K1256 L76_90 L42_43 0.0423
K1257 L76_90 L37_38 0.0317
K1258 L76_90 L13_23 0.1133
K1259 L76_90 L1_2 0.0228
K1260 L76_90 L88_89 0.1344
K1261 L76_90 L26_30 0.1377
K1262 L76_90 L7_21 0.0412
K1263 L76_90 L69_70 0.1184
K1264 L76_90 L45_46 0.0549
K1265 L76_90 L59_60 0.0304
K1266 L76_90 L30_31 0.1228
K1267 L76_90 L63_64 0.0395
K1268 L76_90 L71_72 0.0609
K1269 L76_90 L39_40 0.0333
K1270 L76_90 L54_55 0.0319
K1271 L76_90 L61_77 0.0229
K1272 L76_90 L44_45 0.0419
K1273 L76_90 L84_85 0.0468
K1274 L76_90 L47_48 0.0656
K1275 L76_90 L11_12 0.0465
K1276 L76_90 L24_25 0.0603
K1277 L76_90 L18_19 0.034
K1278 L76_90 L7_8 0.034
K1279 L26_30 L2_3 0.0288
K1280 L26_30 L52_53 0.218
K1281 L26_30 L54_55 0.0353
K1282 L26_30 L32_33 0.1344
K1283 L26_30 L81_82 0.0433
K1284 L26_30 L16_17 0.0372
K1285 L26_30 L60_61 0.0438
K1286 L26_30 L4_19 0.0498
K1287 L26_30 L86_87 0.1078
K1288 L26_30 L14_15 0.1118
K1289 L26_30 L8_9 0.0435
K1290 L26_30 L28_29 0.0747
K1291 L26_30 L40_41 0.0472
K1292 L26_30 L57_58 0.0785
K1293 L26_30 L64_79 0.0341
K1294 L26_30 L20_21 0.0423
K1295 L26_30 L74_75 0.0433
K1296 L26_30 L55_56 0.0491
K1297 L26_30 L68_69 0.0643
K1298 L26_30 L67_81 0.0436
K1299 L26_30 L36_37 0.0384
K1300 L26_30 L79_80 0.0339
K1301 L26_30 L63_64 0.0496
K1302 L26_30 L62_63 0.0416
K1303 L26_30 L46_47 0.0834
K1304 L26_30 L1_17 0.044
K1305 L26_30 L10_11 0.0625
K1306 L26_30 L56_57 0.0729
K1307 L26_30 L83_84 0.0619
K1308 L26_30 L66_67 0.0526
K1309 L26_30 L35_36 0.0357
K1310 L26_30 L42_43 0.0518
K1311 L26_30 L37_38 0.0385
K1312 L26_30 L49_50 0.0599
K1313 L26_30 L13_23 0.1805
K1314 L26_30 L1_2 0.029
K1315 L26_30 L75_76 0.0738
K1316 L26_30 L7_21 0.0529
K1317 L26_30 L69_70 0.1634
K1318 L26_30 L70_86 0.1133
K1319 L26_30 L59_60 0.0371
K1320 L26_30 L50_51 0.1035
K1321 L26_30 L51_52 0.2115
K1322 L26_30 L39_40 0.0397
K1323 L26_30 L27_28 0.0435
K1324 L26_30 L61_77 0.0288
K1325 L26_30 L44_45 0.0499
K1326 L26_30 L84_85 0.0611
K1327 L26_30 L47_48 0.084
K1328 L26_30 L29_32 0.1544
K1329 L26_30 L11_12 0.0617
K1330 L26_30 L90_91 0.1228
K1331 L26_30 L45_46 0.0678
K1332 L26_30 L18_19 0.0418
K1333 L26_30 L7_8 0.0438
K1334 L69_72 L62_65 0.0526
K1335 L69_72 L8_11 0.0463
K1336 L69_72 L82_85 0.0394
K1337 L69_72 L6_9 0.0274
K1338 L69_72 L26_29 0.0728
K1339 L69_72 L14_30 0.0442
K1340 L69_72 L37_42 0.0476
K1341 L69_72 L16_18 0.0472
K1342 L69_72 L44_49 0.0743
K1343 L69_72 L48_53 0.0477
K1344 L69_72 L3_6 0.026
K1345 L69_72 L15_31 0.0345
K1346 L69_72 L7_10 0.0442
K1347 L69_72 L84_86 0.0549
K1348 L69_72 L2_5 0.0314
K1349 L69_72 L49_54 0.0747
K1350 L69_72 L38_43 0.0341
K1351 L69_72 L50_55 0.1097
K1352 L69_72 L47_52 0.0835
K1353 L69_72 L45_50 0.1088
K1354 L69_72 L79_81 0.0335
K1355 L69_72 L80_82 0.0275
K1356 L69_72 L52_57 0.0876
K1357 L69_72 L89_91 0.0345
K1358 L69_72 L87_89 0.0347
K1359 L69_72 L18_20 0.0524
K1360 L69_72 L86_88 0.0444
K1361 L69_72 L10_13 0.0532
K1362 L69_72 L42_47 0.0627
K1363 L69_72 L78_80 0.026
K1364 L69_72 L81_84 0.0464
K1365 L69_72 L59_62 0.0474
K1366 L69_72 L13_26 0.0738
K1367 L69_72 L40_45 0.0859
K1368 L69_72 L43_48 0.041
K1369 L69_72 L31_33 0.0343
K1370 L69_72 L64_67 0.0484
K1371 L69_72 L30_32 0.0439
K1372 L69_72 L71_74 0.1069
K1373 L69_72 L51_56 0.16
K1374 L69_72 L85_87 0.0454
K1375 L69_72 L61_64 0.0447
K1376 L69_72 L9_12 0.0393
K1377 L69_72 L36_41 0.0534
K1378 L69_72 L73_76 0.0735
K1379 L69_72 L67_83 0.0443
K1380 L69_72 L46_51 0.1381
K1381 L69_72 L68_71 0.1108
K1382 L69_72 L24_27 0.1042
K1383 L69_72 L11_14 0.0547
K1384 L69_72 L39_44 0.0629
K1385 L69_72 L70_83 0.0535
K1386 L69_72 L12_15 0.0453
K1387 L69_70 L2_3 0.0343
K1388 L69_70 L52_53 0.1688
K1389 L69_70 L54_55 0.0701
K1390 L69_70 L32_33 0.0923
K1391 L69_70 L81_82 0.0499
K1392 L69_70 L16_17 0.0615
K1393 L69_70 L4_19 0.0768
K1394 L69_70 L63_64 0.0772
K1395 L69_70 L8_9 0.0497
K1396 L69_70 L40_41 0.073
K1397 L69_70 L83_84 0.0697
K1398 L69_70 L57_58 0.0878
K1399 L69_70 L64_79 0.0426
K1400 L69_70 L20_21 0.0731
K1401 L69_70 L74_75 0.1405
K1402 L69_70 L73_88 0.1805
K1403 L69_70 L55_56 0.1015
K1404 L69_70 L50_51 0.2468
K1405 L69_70 L46_47 0.1259
K1406 L69_70 L67_81 0.0532
K1407 L69_70 L36_37 0.0559
K1408 L69_70 L79_80 0.0401
K1409 L69_70 L25_26 0.351
K1410 L69_70 L60_61 0.0678
K1411 L69_70 L62_63 0.0699
K1412 L69_70 L1_17 0.0675
K1413 L69_70 L10_11 0.0693
K1414 L69_70 L56_57 0.1178
K1415 L69_70 L66_67 0.084
K1416 L69_70 L35_36 0.0544
K1417 L69_70 L42_43 0.0695
K1418 L69_70 L37_38 0.0523
K1419 L69_70 L49_50 0.1104
K1420 L69_70 L28_29 0.2236
K1421 L69_70 L1_2 0.0362
K1422 L69_70 L75_76 0.238
K1423 L69_70 L88_89 0.1259
K1424 L69_70 L7_21 0.0833
K1425 L69_70 L45_46 0.1152
K1426 L69_70 L59_60 0.0618
K1427 L69_70 L30_31 0.1206
K1428 L69_70 L51_52 0.3604
K1429 L69_70 L71_72 0.1825
K1430 L69_70 L39_40 0.0628
K1431 L69_70 L27_28 0.1366
K1432 L69_70 L61_77 0.0363
K1433 L69_70 L44_45 0.0845
K1434 L69_70 L84_85 0.0639
K1435 L69_70 L47_48 0.103
K1436 L69_70 L29_32 0.1133
K1437 L69_70 L11_12 0.0636
K1438 L69_70 L90_91 0.0949
K1439 L69_70 L24_25 0.1727
K1440 L69_70 L18_19 0.0696
K1441 L69_70 L7_8 0.053
K1442 L88_89 L2_3 0.0288
K1443 L88_89 L52_53 0.2115
K1444 L88_89 L54_55 0.0334
K1445 L88_89 L32_33 0.1377
K1446 L88_89 L81_82 0.0438
K1447 L88_89 L16_17 0.0352
K1448 L88_89 L60_61 0.0426
K1449 L88_89 L4_19 0.048
K1450 L88_89 L86_87 0.118
K1451 L88_89 L14_15 0.1133
K1452 L88_89 L8_9 0.0436
K1453 L88_89 L28_29 0.0628
K1454 L88_89 L40_41 0.0457
K1455 L88_89 L57_58 0.0839
K1456 L88_89 L64_79 0.034
K1457 L88_89 L20_21 0.0394
K1458 L88_89 L74_75 0.0393
K1459 L88_89 L55_56 0.0456
K1460 L88_89 L68_69 0.056
K1461 L88_89 L67_81 0.0435
K1462 L88_89 L36_37 0.0382
K1463 L88_89 L79_80 0.0343
K1464 L88_89 L63_64 0.0482
K1465 L88_89 L62_63 0.0395
K1466 L88_89 L46_47 0.0817
K1467 L88_89 L1_17 0.0425
K1468 L88_89 L10_11 0.0611
K1469 L88_89 L56_57 0.0673
K1470 L88_89 L83_84 0.0617
K1471 L88_89 L66_67 0.0506
K1472 L88_89 L35_36 0.0348
K1473 L88_89 L42_43 0.0517
K1474 L88_89 L37_38 0.0384
K1475 L88_89 L49_50 0.0551
K1476 L88_89 L13_23 0.1206
K1477 L88_89 L1_2 0.0287
K1478 L88_89 L75_76 0.0634
K1479 L88_89 L7_21 0.0504
K1480 L88_89 L70_86 0.1118
K1481 L88_89 L59_60 0.0353
K1482 L88_89 L50_51 0.0907
K1483 L88_89 L51_52 0.1928
K1484 L88_89 L39_40 0.0382
K1485 L88_89 L27_28 0.0392
K1486 L88_89 L61_77 0.0288
K1487 L88_89 L44_45 0.047
K1488 L88_89 L84_85 0.0625
K1489 L88_89 L47_48 0.0834
K1490 L88_89 L29_32 0.1228
K1491 L88_89 L11_12 0.0619
K1492 L88_89 L90_91 0.1544
K1493 L88_89 L45_46 0.0638
K1494 L88_89 L18_19 0.0394
K1495 L88_89 L7_8 0.0433
K1496 L31_33 L19_21 0.026
K1497 L31_33 L8_11 0.059
K1498 L31_33 L26_29 0.0704
K1499 L31_33 L14_30 0.1344
K1500 L31_33 L72_75 0.0345
K1501 L31_33 L16_18 0.0222
K1502 L31_33 L48_53 0.0665
K1503 L31_33 L63_66 0.026
K1504 L31_33 L7_10 0.0528
K1505 L31_33 L2_5 0.0285
K1506 L31_33 L49_54 0.0316
K1507 L31_33 L38_43 0.0301
K1508 L31_33 L50_55 0.0422
K1509 L31_33 L81_84 0.0584
K1510 L31_33 L45_50 0.0419
K1511 L31_33 L79_81 0.0318
K1512 L31_33 L62_65 0.0233
K1513 L31_33 L17_19 0.0246
K1514 L31_33 L18_20 0.0233
K1515 L31_33 L86_88 0.1228
K1516 L31_33 L84_86 0.1059
K1517 L31_33 L10_13 0.094
K1518 L31_33 L13_26 0.0688
K1519 L31_33 L40_45 0.0379
K1520 L31_33 L64_67 0.0351
K1521 L31_33 L43_48 0.0421
K1522 L31_33 L59_62 0.0222
K1523 L31_33 L60_63 0.0246
K1524 L31_33 L30_32 0.1544
K1525 L31_33 L71_74 0.0292
K1526 L31_33 L51_56 0.0652
K1527 L31_33 L61_64 0.0321
K1528 L31_33 L36_41 0.0397
K1529 L31_33 L73_76 0.0693
K1530 L31_33 L67_83 0.0523
K1531 L31_33 L46_51 0.0641
K1532 L31_33 L25_28 0.0347
K1533 L31_33 L68_71 0.0291
K1534 L31_33 L24_27 0.0293
K1535 L31_33 L44_49 0.0314
K1536 L31_33 L39_44 0.029
K1537 L31_33 L70_83 0.0911
K1538 L31_33 L11_14 0.1098
K1539 L30_31 L2_3 0.029
K1540 L30_31 L52_53 0.2115
K1541 L30_31 L54_55 0.0334
K1542 L30_31 L32_33 0.1544
K1543 L30_31 L81_82 0.0436
K1544 L30_31 L16_17 0.0353
K1545 L30_31 L60_61 0.0425
K1546 L30_31 L4_19 0.0482
K1547 L30_31 L86_87 0.1133
K1548 L30_31 L14_15 0.118
K1549 L30_31 L8_9 0.0438
K1550 L30_31 L28_29 0.0634
K1551 L30_31 L40_41 0.0457
K1552 L30_31 L57_58 0.0839
K1553 L30_31 L64_79 0.0339
K1554 L30_31 L20_21 0.0395
K1555 L30_31 L74_75 0.0392
K1556 L30_31 L55_56 0.0456
K1557 L30_31 L68_69 0.0556
K1558 L30_31 L67_81 0.0433
K1559 L30_31 L36_37 0.0382
K1560 L30_31 L79_80 0.0341
K1561 L30_31 L63_64 0.048
K1562 L30_31 L62_63 0.0394
K1563 L30_31 L46_47 0.0817
K1564 L30_31 L1_17 0.0426
K1565 L30_31 L10_11 0.0617
K1566 L30_31 L56_57 0.0673
K1567 L30_31 L83_84 0.0611
K1568 L30_31 L66_67 0.0504
K1569 L30_31 L35_36 0.0348
K1570 L30_31 L42_43 0.0517
K1571 L30_31 L37_38 0.0384
K1572 L30_31 L49_50 0.0551
K1573 L30_31 L13_23 0.1259
K1574 L30_31 L1_2 0.0288
K1575 L30_31 L75_76 0.0628
K1576 L30_31 L7_21 0.0506
K1577 L30_31 L70_86 0.1078
K1578 L30_31 L59_60 0.0352
K1579 L30_31 L50_51 0.0907
K1580 L30_31 L51_52 0.1928
K1581 L30_31 L39_40 0.0382
K1582 L30_31 L27_28 0.0393
K1583 L30_31 L61_77 0.0287
K1584 L30_31 L44_45 0.047
K1585 L30_31 L84_85 0.0619
K1586 L30_31 L47_48 0.0834
K1587 L30_31 L29_32 0.1344
K1588 L30_31 L11_12 0.0625
K1589 L30_31 L90_91 0.1377
K1590 L30_31 L45_46 0.0638
K1591 L30_31 L18_19 0.0395
K1592 L30_31 L7_8 0.0435
K1593 L30_32 L37_42 0.0551
K1594 L30_32 L19_21 0.0315
K1595 L30_32 L82_85 0.046
K1596 L30_32 L6_9 0.032
K1597 L30_32 L26_29 0.1028
K1598 L30_32 L85_87 0.0717
K1599 L30_32 L72_75 0.0442
K1600 L30_32 L16_18 0.0268
K1601 L30_32 L63_66 0.0314
K1602 L30_32 L3_6 0.0285
K1603 L30_32 L15_31 0.1344
K1604 L30_32 L7_10 0.0628
K1605 L30_32 L48_53 0.0673
K1606 L30_32 L49_54 0.0384
K1607 L30_32 L38_43 0.0334
K1608 L30_32 L50_55 0.0517
K1609 L30_32 L47_52 0.1928
K1610 L30_32 L43_48 0.0456
K1611 L30_32 L45_50 0.0512
K1612 L30_32 L80_82 0.0318
K1613 L30_32 L62_65 0.0281
K1614 L30_32 L89_91 0.1377
K1615 L30_32 L17_19 0.0296
K1616 L30_32 L52_57 0.2115
K1617 L30_32 L87_89 0.1228
K1618 L30_32 L18_20 0.0282
K1619 L30_32 L42_47 0.0907
K1620 L30_32 L78_80 0.0284
K1621 L30_32 L59_62 0.0267
K1622 L30_32 L10_13 0.1273
K1623 L30_32 L13_26 0.099
K1624 L30_32 L40_45 0.0457
K1625 L30_32 L64_67 0.0421
K1626 L30_32 L60_63 0.0296
K1627 L30_32 L39_44 0.0348
K1628 L30_32 L71_74 0.0367
K1629 L30_32 L51_56 0.0834
K1630 L30_32 L9_12 0.0463
K1631 L30_32 L36_41 0.047
K1632 L30_32 L73_76 0.1
K1633 L30_32 L67_83 0.0621
K1634 L30_32 L46_51 0.0817
K1635 L30_32 L25_28 0.0444
K1636 L30_32 L68_71 0.0365
K1637 L30_32 L24_27 0.0369
K1638 L30_32 L44_49 0.0382
K1639 L30_32 L61_64 0.0381
K1640 L30_32 L70_83 0.1212
K1641 L30_32 L12_15 0.0728
K1642 L50_51 L2_3 0.0412
K1643 L50_51 L81_82 0.0579
K1644 L50_51 L70_86 0.0764
K1645 L50_51 L16_17 0.0995
K1646 L50_51 L4_19 0.102
K1647 L50_51 L86_87 0.07
K1648 L50_51 L14_15 0.07
K1649 L50_51 L8_9 0.0579
K1650 L50_51 L40_41 0.1149
K1651 L50_51 L83_84 0.0748
K1652 L50_51 L57_58 0.1
K1653 L50_51 L64_79 0.0504
K1654 L50_51 L20_21 0.1206
K1655 L50_51 L73_88 0.1035
K1656 L50_51 L55_56 0.1527
K1657 L50_51 L68_69 0.3604
K1658 L50_51 L67_81 0.0614
K1659 L50_51 L36_37 0.0814
K1660 L50_51 L79_80 0.0477
K1661 L50_51 L25_26 0.236
K1662 L50_51 L60_61 0.0905
K1663 L50_51 L62_63 0.1128
K1664 L50_51 L46_47 0.159
K1665 L50_51 L1_17 0.0905
K1666 L50_51 L10_11 0.0748
K1667 L50_51 L56_57 0.133
K1668 L50_51 L66_67 0.1057
K1669 L50_51 L35_36 0.0856
K1670 L50_51 L42_43 0.0923
K1671 L50_51 L37_38 0.0716
K1672 L50_51 L13_23 0.2468
K1673 L50_51 L1_2 0.0435
K1674 L50_51 L7_21 0.1057
K1675 L50_51 L45_46 0.1835
K1676 L50_51 L59_60 0.0995
K1677 L50_51 L63_64 0.102
K1678 L50_51 L71_72 0.3174
K1679 L50_51 L39_40 0.1078
K1680 L50_51 L54_55 0.133
K1681 L50_51 L61_77 0.0435
K1682 L50_51 L44_45 0.159
K1683 L50_51 L84_85 0.0699
K1684 L50_51 L47_48 0.1191
K1685 L50_51 L11_12 0.0699
K1686 L50_51 L24_25 0.3174
K1687 L50_51 L18_19 0.1128
K1688 L50_51 L7_8 0.0614
K1689 L73_76 L37_42 0.0515
K1690 L73_76 L19_21 0.0445
K1691 L73_76 L8_11 0.0585
K1692 L73_76 L6_9 0.0351
K1693 L73_76 L60_63 0.0413
K1694 L73_76 L14_30 0.0965
K1695 L73_76 L72_75 0.0746
K1696 L73_76 L16_18 0.0373
K1697 L73_76 L44_49 0.0552
K1698 L73_76 L63_66 0.0447
K1699 L73_76 L3_6 0.0321
K1700 L73_76 L15_31 0.0678
K1701 L73_76 L48_53 0.0657
K1702 L73_76 L84_86 0.0838
K1703 L73_76 L2_5 0.0381
K1704 L73_76 L38_43 0.0388
K1705 L73_76 L50_55 0.0765
K1706 L73_76 L47_52 0.1196
K1707 L73_76 L45_50 0.0756
K1708 L73_76 L79_81 0.0423
K1709 L73_76 L80_82 0.0353
K1710 L73_76 L62_65 0.04
K1711 L73_76 L89_91 0.0704
K1712 L73_76 L17_19 0.0412
K1713 L73_76 L52_57 0.1733
K1714 L73_76 L87_89 0.0688
K1715 L73_76 L18_20 0.0399
K1716 L73_76 L86_88 0.099
K1717 L73_76 L42_47 0.0729
K1718 L73_76 L78_80 0.0322
K1719 L73_76 L59_62 0.0374
K1720 L73_76 L49_54 0.0556
K1721 L73_76 L40_45 0.065
K1722 L73_76 L43_48 0.0502
K1723 L73_76 L82_85 0.0508
K1724 L73_76 L71_74 0.0587
K1725 L73_76 L51_56 0.1389
K1726 L73_76 L85_87 0.0689
K1727 L73_76 L81_84 0.0588
K1728 L73_76 L9_12 0.0506
K1729 L73_76 L36_41 0.0634
K1730 L73_76 L46_51 0.134
K1731 L73_76 L25_28 0.0738
K1732 L73_76 L68_71 0.0582
K1733 L73_76 L24_27 0.0584
K1734 L73_76 L11_14 0.083
K1735 L73_76 L39_44 0.049
K1736 L73_76 L12_15 0.0683
K1737 L79_80 L2_3 0.1927
K1738 L79_80 L52_53 0.0711
K1739 L79_80 L32_33 0.0269
K1740 L79_80 L81_82 0.1795
K1741 L79_80 L70_86 0.0496
K1742 L79_80 L16_17 0.0556
K1743 L79_80 L7_8 0.1482
K1744 L79_80 L86_87 0.0501
K1745 L79_80 L14_15 0.0497
K1746 L79_80 L8_9 0.1632
K1747 L79_80 L28_29 0.0354
K1748 L79_80 L40_41 0.0795
K1749 L79_80 L57_58 0.0395
K1750 L79_80 L74_75 0.029
K1751 L79_80 L20_21 0.0392
K1752 L79_80 L73_88 0.034
K1753 L79_80 L55_56 0.0319
K1754 L79_80 L75_76 0.0355
K1755 L79_80 L67_81 0.1598
K1756 L79_80 L36_37 0.0804
K1757 L79_80 L25_26 0.0416
K1758 L79_80 L60_61 0.1259
K1759 L79_80 L83_84 0.0896
K1760 L79_80 L46_47 0.0956
K1761 L79_80 L1_17 0.1206
K1762 L79_80 L10_11 0.0879
K1763 L79_80 L56_57 0.0372
K1764 L79_80 L66_67 0.0634
K1765 L79_80 L35_36 0.059
K1766 L79_80 L42_43 0.1314
K1767 L79_80 L37_38 0.0826
K1768 L79_80 L49_50 0.0369
K1769 L79_80 L13_23 0.04
K1770 L79_80 L68_69 0.0314
K1771 L79_80 L7_21 0.0628
K1772 L79_80 L45_46 0.0582
K1773 L79_80 L59_60 0.056
K1774 L79_80 L51_52 0.0626
K1775 L79_80 L71_72 0.0333
K1776 L79_80 L39_40 0.0523
K1777 L79_80 L27_28 0.029
K1778 L79_80 L61_77 0.1891
K1779 L79_80 L44_45 0.0411
K1780 L79_80 L84_85 0.0921
K1781 L79_80 L47_48 0.1377
K1782 L79_80 L29_32 0.0267
K1783 L79_80 L11_12 0.0902
K1784 L79_80 L90_91 0.027
K1785 L79_80 L24_25 0.0332
K1786 L79_80 L54_55 0.0267
K1787 L79_80 L1_2 0.1588
K1788 L46_51 L37_42 0.1191
K1789 L46_51 L19_21 0.1206
K1790 L46_51 L8_11 0.1125
K1791 L46_51 L82_85 0.0917
K1792 L46_51 L6_9 0.0641
K1793 L46_51 L26_29 0.134
K1794 L46_51 L14_30 0.0834
K1795 L46_51 L72_75 0.1206
K1796 L46_51 L16_18 0.0949
K1797 L46_51 L44_49 0.1278
K1798 L46_51 L63_66 0.1206
K1799 L46_51 L3_6 0.0624
K1800 L46_51 L15_31 0.0652
K1801 L46_51 L7_10 0.111
K1802 L46_51 L84_86 0.1148
K1803 L46_51 L2_5 0.079
K1804 L46_51 L49_54 0.1152
K1805 L46_51 L38_43 0.0775
K1806 L46_51 L50_55 0.159
K1807 L46_51 L47_52 0.1835
K1808 L46_51 L45_50 0.1835
K1809 L46_51 L79_81 0.0817
K1810 L46_51 L80_82 0.0641
K1811 L46_51 L62_65 0.1049
K1812 L46_51 L89_91 0.0641
K1813 L46_51 L17_19 0.1065
K1814 L46_51 L87_89 0.0652
K1815 L46_51 L18_20 0.1049
K1816 L46_51 L86_88 0.0834
K1817 L46_51 L10_13 0.1137
K1818 L46_51 L42_47 0.159
K1819 L46_51 L78_80 0.0624
K1820 L46_51 L81_84 0.1125
K1821 L46_51 L59_62 0.0949
K1822 L46_51 L13_26 0.1389
K1823 L46_51 L40_45 0.159
K1824 L46_51 L64_67 0.134
K1825 L46_51 L43_48 0.0903
K1826 L46_51 L60_63 0.1065
K1827 L46_51 L71_74 0.1049
K1828 L46_51 L85_87 0.0932
K1829 L46_51 L61_64 0.1268
K1830 L46_51 L9_12 0.0917
K1831 L46_51 L48_53 0.0962
K1832 L46_51 L67_83 0.111
K1833 L46_51 L52_57 0.159
K1834 L46_51 L25_28 0.1206
K1835 L46_51 L68_71 0.1163
K1836 L46_51 L24_27 0.1049
K1837 L46_51 L11_14 0.1148
K1838 L46_51 L39_44 0.1152
K1839 L46_51 L70_83 0.1137
K1840 L46_51 L12_15 0.0932
K1841 L81_82 L52_53 0.0899
K1842 L81_82 L54_55 0.0322
K1843 L81_82 L32_33 0.034
K1844 L81_82 L16_17 0.0629
K1845 L81_82 L4_19 0.1356
K1846 L81_82 L86_87 0.0655
K1847 L81_82 L84_85 0.1303
K1848 L81_82 L14_15 0.0649
K1849 L81_82 L70_86 0.0647
K1850 L81_82 L13_23 0.0497
K1851 L81_82 L40_41 0.0851
K1852 L81_82 L57_58 0.0488
K1853 L81_82 L74_75 0.0353
K1854 L81_82 L2_3 0.1248
K1855 L81_82 L73_88 0.0435
K1856 L81_82 L55_56 0.0387
K1857 L81_82 L75_76 0.0439
K1858 L81_82 L36_37 0.0803
K1859 L81_82 L25_26 0.0516
K1860 L81_82 L60_61 0.1208
K1861 L81_82 L63_64 0.1396
K1862 L81_82 L62_63 0.0701
K1863 L81_82 L46_47 0.1189
K1864 L81_82 L1_17 0.1178
K1865 L81_82 L10_11 0.1217
K1866 L81_82 L56_57 0.0457
K1867 L81_82 L83_84 0.1251
K1868 L81_82 L35_36 0.0631
K1869 L81_82 L42_43 0.1238
K1870 L81_82 L37_38 0.082
K1871 L81_82 L49_50 0.0443
K1872 L81_82 L28_29 0.0438
K1873 L81_82 L64_79 0.1598
K1874 L81_82 L68_69 0.0382
K1875 L81_82 L45_46 0.07
K1876 L81_82 L59_60 0.0633
K1877 L81_82 L51_52 0.0778
K1878 L81_82 L71_72 0.0405
K1879 L81_82 L39_40 0.059
K1880 L81_82 L27_28 0.0353
K1881 L81_82 L61_77 0.1226
K1882 L81_82 L44_45 0.0489
K1883 L81_82 L47_48 0.1844
K1884 L81_82 L29_32 0.0338
K1885 L81_82 L11_12 0.1264
K1886 L81_82 L90_91 0.0342
K1887 L81_82 L24_25 0.0404
K1888 L81_82 L18_19 0.0696
K1889 L81_82 L1_2 0.1158
K1890 L81_84 L37_42 0.1448
K1891 L81_84 L19_21 0.0591
K1892 L81_84 L82_85 0.2651
K1893 L81_84 L6_9 0.1767
K1894 L81_84 L26_29 0.0585
K1895 L81_84 L85_87 0.1624
K1896 L81_84 L72_75 0.0437
K1897 L81_84 L16_18 0.0483
K1898 L81_84 L63_66 0.0594
K1899 L81_84 L3_6 0.1643
K1900 L81_84 L15_31 0.0692
K1901 L81_84 L7_10 0.316
K1902 L81_84 L48_53 0.1085
K1903 L81_84 L49_54 0.0482
K1904 L81_84 L38_43 0.0794
K1905 L81_84 L50_55 0.0632
K1906 L81_84 L47_52 0.2631
K1907 L81_84 L43_48 0.1156
K1908 L81_84 L45_50 0.0707
K1909 L81_84 L80_82 0.1951
K1910 L81_84 L62_65 0.0498
K1911 L81_84 L89_91 0.059
K1912 L81_84 L17_19 0.0571
K1913 L81_84 L52_57 0.1266
K1914 L81_84 L87_89 0.0702
K1915 L81_84 L18_20 0.0496
K1916 L81_84 L42_47 0.2868
K1917 L81_84 L78_80 0.1798
K1918 L81_84 L59_62 0.0485
K1919 L81_84 L10_13 0.1756
K1920 L81_84 L13_26 0.0652
K1921 L81_84 L40_45 0.0713
K1922 L81_84 L64_67 0.1234
K1923 L81_84 L60_63 0.0574
K1924 L81_84 L39_44 0.0531
K1925 L81_84 L71_74 0.039
K1926 L81_84 L51_56 0.0883
K1927 L81_84 L9_12 0.2416
K1928 L81_84 L36_41 0.0937
K1929 L81_84 L67_83 0.386
K1930 L81_84 L25_28 0.0435
K1931 L81_84 L68_71 0.0411
K1932 L81_84 L24_27 0.0389
K1933 L81_84 L44_49 0.0527
K1934 L81_84 L61_64 0.1094
K1935 L81_84 L70_83 0.1887
K1936 L81_84 L12_15 0.1554
K1937 L1_2 L52_53 0.0584
K1938 L1_2 L54_55 0.024
K1939 L1_2 L32_33 0.0228
K1940 L1_2 L70_86 0.0417
K1941 L1_2 L4_19 0.0743
K1942 L1_2 L86_87 0.0413
K1943 L1_2 L14_15 0.0416
K1944 L1_2 L8_9 0.1226
K1945 L1_2 L28_29 0.0317
K1946 L1_2 L83_84 0.0735
K1947 L1_2 L57_58 0.0334
K1948 L1_2 L74_75 0.0263
K1949 L1_2 L20_21 0.0379
K1950 L1_2 L73_88 0.0288
K1951 L1_2 L55_56 0.0285
K1952 L1_2 L75_76 0.0317
K1953 L1_2 L67_81 0.1248
K1954 L1_2 L36_37 0.0801
K1955 L1_2 L25_26 0.0376
K1956 L1_2 L63_64 0.0732
K1957 L1_2 L62_63 0.042
K1958 L1_2 L46_47 0.0914
K1959 L1_2 L10_11 0.0748
K1960 L1_2 L90_91 0.0227
K1961 L1_2 L66_67 0.0634
K1962 L1_2 L35_36 0.0591
K1963 L1_2 L56_57 0.0327
K1964 L1_2 L37_38 0.081
K1965 L1_2 L49_50 0.0337
K1966 L1_2 L13_23 0.0363
K1967 L1_2 L64_79 0.1927
K1968 L1_2 L68_69 0.0287
K1969 L1_2 L7_21 0.0642
K1970 L1_2 L45_46 0.055
K1971 L1_2 L7_8 0.1335
K1972 L1_2 L51_52 0.056
K1973 L1_2 L71_72 0.0303
K1974 L1_2 L27_28 0.0264
K1975 L1_2 L44_45 0.0382
K1976 L1_2 L84_85 0.0719
K1977 L1_2 L47_48 0.1024
K1978 L1_2 L29_32 0.0229
K1979 L1_2 L11_12 0.0731
K1980 L1_2 L24_25 0.0304
K1981 L1_2 L18_19 0.0422
K1982 L19_21 L62_65 0.1079
K1983 L19_21 L8_11 0.0594
K1984 L19_21 L82_85 0.0482
K1985 L19_21 L6_9 0.0347
K1986 L19_21 L26_29 0.0447
K1987 L19_21 L14_30 0.0335
K1988 L19_21 L37_42 0.0705
K1989 L19_21 L16_18 0.1069
K1990 L19_21 L44_49 0.0731
K1991 L19_21 L48_53 0.0465
K1992 L19_21 L3_6 0.0345
K1993 L19_21 L15_31 0.0275
K1994 L19_21 L7_10 0.0586
K1995 L19_21 L84_86 0.0519
K1996 L19_21 L2_5 0.0441
K1997 L19_21 L49_54 0.0598
K1998 L19_21 L38_43 0.0438
K1999 L19_21 L50_55 0.0804
K2000 L19_21 L47_52 0.0791
K2001 L19_21 L45_50 0.1061
K2002 L19_21 L79_81 0.0442
K2003 L19_21 L80_82 0.0345
K2004 L19_21 L52_57 0.0591
K2005 L19_21 L89_91 0.026
K2006 L19_21 L87_89 0.0274
K2007 L19_21 L18_20 0.1108
K2008 L19_21 L86_88 0.0334
K2009 L19_21 L10_13 0.0505
K2010 L19_21 L42_47 0.0913
K2011 L19_21 L78_80 0.0343
K2012 L19_21 L59_62 0.1042
K2013 L19_21 L13_26 0.0484
K2014 L19_21 L40_45 0.1088
K2015 L19_21 L43_48 0.0496
K2016 L19_21 L64_67 0.0738
K2017 L19_21 L71_74 0.0472
K2018 L19_21 L51_56 0.0715
K2019 L19_21 L85_87 0.0434
K2020 L19_21 L61_64 0.0728
K2021 L19_21 L9_12 0.0484
K2022 L19_21 L36_41 0.0952
K2023 L19_21 L67_83 0.0582
K2024 L19_21 L68_71 0.0524
K2025 L19_21 L24_27 0.0474
K2026 L19_21 L11_14 0.0521
K2027 L19_21 L39_44 0.0743
K2028 L19_21 L70_83 0.0502
K2029 L19_21 L12_15 0.0435
K2030 L8_11 L37_42 0.1448
K2031 L8_11 L82_85 0.2416
K2032 L8_11 L6_9 0.1951
K2033 L8_11 L26_29 0.0588
K2034 L8_11 L85_87 0.1554
K2035 L8_11 L72_75 0.0435
K2036 L8_11 L16_18 0.0485
K2037 L8_11 L63_66 0.0591
K2038 L8_11 L3_6 0.1798
K2039 L8_11 L15_31 0.0702
K2040 L8_11 L7_10 0.386
K2041 L8_11 L48_53 0.1085
K2042 L8_11 L49_54 0.0482
K2043 L8_11 L38_43 0.0794
K2044 L8_11 L50_55 0.0632
K2045 L8_11 L47_52 0.2631
K2046 L8_11 L43_48 0.1156
K2047 L8_11 L45_50 0.0707
K2048 L8_11 L80_82 0.1767
K2049 L8_11 L62_65 0.0496
K2050 L8_11 L89_91 0.0584
K2051 L8_11 L17_19 0.0574
K2052 L8_11 L52_57 0.1266
K2053 L8_11 L87_89 0.0692
K2054 L8_11 L18_20 0.0498
K2055 L8_11 L42_47 0.2868
K2056 L8_11 L78_80 0.1643
K2057 L8_11 L59_62 0.0483
K2058 L8_11 L10_13 0.1887
K2059 L8_11 L13_26 0.0656
K2060 L8_11 L40_45 0.0713
K2061 L8_11 L64_67 0.1208
K2062 L8_11 L60_63 0.0571
K2063 L8_11 L39_44 0.0531
K2064 L8_11 L71_74 0.0389
K2065 L8_11 L51_56 0.0883
K2066 L8_11 L9_12 0.2651
K2067 L8_11 L36_41 0.0937
K2068 L8_11 L67_83 0.316
K2069 L8_11 L25_28 0.0437
K2070 L8_11 L68_71 0.0409
K2071 L8_11 L24_27 0.039
K2072 L8_11 L44_49 0.0527
K2073 L8_11 L61_64 0.1076
K2074 L8_11 L70_83 0.1756
K2075 L8_11 L12_15 0.1624
K2076 L26_29 L37_42 0.0515
K2077 L26_29 L6_9 0.0353
K2078 L26_29 L60_63 0.0412
K2079 L26_29 L14_30 0.099
K2080 L26_29 L72_75 0.0738
K2081 L26_29 L16_18 0.0374
K2082 L26_29 L44_49 0.0552
K2083 L26_29 L63_66 0.0445
K2084 L26_29 L3_6 0.0322
K2085 L26_29 L15_31 0.0688
K2086 L26_29 L48_53 0.0657
K2087 L26_29 L84_86 0.083
K2088 L26_29 L2_5 0.0383
K2089 L26_29 L38_43 0.0388
K2090 L26_29 L50_55 0.0765
K2091 L26_29 L47_52 0.1196
K2092 L26_29 L45_50 0.0756
K2093 L26_29 L79_81 0.0421
K2094 L26_29 L80_82 0.0351
K2095 L26_29 L62_65 0.0399
K2096 L26_29 L89_91 0.0693
K2097 L26_29 L17_19 0.0413
K2098 L26_29 L52_57 0.1733
K2099 L26_29 L87_89 0.0678
K2100 L26_29 L18_20 0.04
K2101 L26_29 L86_88 0.0965
K2102 L26_29 L42_47 0.0729
K2103 L26_29 L78_80 0.0321
K2104 L26_29 L59_62 0.0373
K2105 L26_29 L49_54 0.0556
K2106 L26_29 L40_45 0.065
K2107 L26_29 L43_48 0.0502
K2108 L26_29 L82_85 0.0506
K2109 L26_29 L71_74 0.0584
K2110 L26_29 L51_56 0.1389
K2111 L26_29 L85_87 0.0683
K2112 L26_29 L9_12 0.0508
K2113 L26_29 L36_41 0.0634
K2114 L26_29 L25_28 0.0746
K2115 L26_29 L68_71 0.0579
K2116 L26_29 L24_27 0.0587
K2117 L26_29 L11_14 0.0838
K2118 L26_29 L39_44 0.049
K2119 L26_29 L12_15 0.0689
K2120 L60_61 L52_53 0.0828
K2121 L60_61 L54_55 0.0459
K2122 L60_61 L32_33 0.034
K2123 L60_61 L70_86 0.0625
K2124 L60_61 L4_19 0.351
K2125 L60_61 L86_87 0.0598
K2126 L60_61 L14_15 0.0595
K2127 L60_61 L8_9 0.1178
K2128 L60_61 L28_29 0.0566
K2129 L60_61 L83_84 0.1032
K2130 L60_61 L57_58 0.05
K2131 L60_61 L74_75 0.0531
K2132 L60_61 L20_21 0.1366
K2133 L60_61 L73_88 0.044
K2134 L60_61 L55_56 0.0523
K2135 L60_61 L75_76 0.0568
K2136 L60_61 L67_81 0.1472
K2137 L60_61 L36_37 0.1263
K2138 L60_61 L25_26 0.0686
K2139 L60_61 L63_64 0.4206
K2140 L60_61 L62_63 0.1825
K2141 L60_61 L46_47 0.2003
K2142 L60_61 L10_11 0.1019
K2143 L60_61 L90_91 0.0341
K2144 L60_61 L66_67 0.238
K2145 L60_61 L35_36 0.1126
K2146 L60_61 L56_57 0.0544
K2147 L60_61 L37_38 0.0977
K2148 L60_61 L49_50 0.0709
K2149 L60_61 L13_23 0.0675
K2150 L60_61 L64_79 0.1805
K2151 L60_61 L68_69 0.0618
K2152 L60_61 L7_21 0.2236
K2153 L60_61 L45_46 0.1543
K2154 L60_61 L7_8 0.1418
K2155 L60_61 L51_52 0.0985
K2156 L60_61 L71_72 0.0635
K2157 L60_61 L27_28 0.0529
K2158 L60_61 L44_45 0.0918
K2159 L60_61 L84_85 0.0943
K2160 L60_61 L47_48 0.1237
K2161 L60_61 L29_32 0.0349
K2162 L60_61 L11_12 0.0933
K2163 L60_61 L24_25 0.0632
K2164 L60_61 L18_19 0.1727
K2165 L4_19 L2_3 0.0623
K2166 L4_19 L52_53 0.0928
K2167 L4_19 L32_33 0.0385
K2168 L4_19 L70_86 0.0708
K2169 L4_19 L16_17 0.1825
K2170 L4_19 L7_8 0.1756
K2171 L4_19 L86_87 0.0675
K2172 L4_19 L14_15 0.0679
K2173 L4_19 L8_9 0.1396
K2174 L4_19 L28_29 0.0642
K2175 L4_19 L40_41 0.1697
K2176 L4_19 L57_58 0.0558
K2177 L4_19 L74_75 0.0596
K2178 L4_19 L20_21 0.1626
K2179 L4_19 L73_88 0.0496
K2180 L4_19 L55_56 0.0584
K2181 L4_19 L75_76 0.064
K2182 L4_19 L67_81 0.1675
K2183 L4_19 L36_37 0.1252
K2184 L4_19 L25_26 0.0781
K2185 L4_19 L83_84 0.118
K2186 L4_19 L46_47 0.2352
K2187 L4_19 L1_17 0.4206
K2188 L4_19 L10_11 0.1198
K2189 L4_19 L56_57 0.0609
K2190 L4_19 L66_67 0.2746
K2191 L4_19 L35_36 0.1135
K2192 L4_19 L42_43 0.1411
K2193 L4_19 L37_38 0.1003
K2194 L4_19 L49_50 0.079
K2195 L4_19 L13_23 0.0772
K2196 L4_19 L68_69 0.0696
K2197 L4_19 L7_21 0.299
K2198 L4_19 L45_46 0.1763
K2199 L4_19 L59_60 0.1727
K2200 L4_19 L51_52 0.1116
K2201 L4_19 L71_72 0.0713
K2202 L4_19 L39_40 0.1063
K2203 L4_19 L27_28 0.0597
K2204 L4_19 L61_77 0.0732
K2205 L4_19 L44_45 0.1019
K2206 L4_19 L84_85 0.107
K2207 L4_19 L47_48 0.139
K2208 L4_19 L29_32 0.0395
K2209 L4_19 L11_12 0.1083
K2210 L4_19 L90_91 0.0383
K2211 L4_19 L24_25 0.0716
K2212 L4_19 L54_55 0.051
K2213 L37_42 L14_30 0.0599
K2214 L37_42 L72_75 0.0453
K2215 L37_42 L16_18 0.0661
K2216 L37_42 L48_53 0.1
K2217 L37_42 L63_66 0.0705
K2218 L37_42 L7_10 0.1386
K2219 L37_42 L2_5 0.1665
K2220 L37_42 L49_54 0.0609
K2221 L37_42 L38_43 0.1527
K2222 L37_42 L50_55 0.0767
K2223 L37_42 L45_50 0.0923
K2224 L37_42 L79_81 0.1408
K2225 L37_42 L62_65 0.063
K2226 L37_42 L17_19 0.0748
K2227 L37_42 L18_20 0.063
K2228 L37_42 L86_88 0.0599
K2229 L37_42 L84_86 0.1006
K2230 L37_42 L10_13 0.0937
K2231 L37_42 L13_26 0.0547
K2232 L37_42 L40_45 0.1078
K2233 L37_42 L64_67 0.0959
K2234 L37_42 L43_48 0.133
K2235 L37_42 L59_62 0.0661
K2236 L37_42 L60_63 0.0748
K2237 L37_42 L71_74 0.0425
K2238 L37_42 L51_56 0.0901
K2239 L37_42 L61_64 0.1067
K2240 L37_42 L36_41 0.1835
K2241 L37_42 L67_83 0.1386
K2242 L37_42 L25_28 0.0453
K2243 L37_42 L68_71 0.0445
K2244 L37_42 L24_27 0.0425
K2245 L37_42 L44_49 0.0716
K2246 L37_42 L39_44 0.0814
K2247 L37_42 L70_83 0.0937
K2248 L37_42 L11_14 0.1006
K2249 L66_67 L52_53 0.0941
K2250 L66_67 L54_55 0.0499
K2251 L66_67 L32_33 0.0398
K2252 L66_67 L16_17 0.1366
K2253 L66_67 L86_87 0.0731
K2254 L66_67 L84_85 0.1218
K2255 L66_67 L14_15 0.0725
K2256 L66_67 L70_86 0.0782
K2257 L66_67 L13_23 0.0833
K2258 L66_67 L40_41 0.1353
K2259 L66_67 L57_58 0.0553
K2260 L66_67 L74_75 0.0618
K2261 L66_67 L2_3 0.0544
K2262 L66_67 L73_88 0.0529
K2263 L66_67 L55_56 0.0584
K2264 L66_67 L75_76 0.0678
K2265 L66_67 L36_37 0.1003
K2266 L66_67 L25_26 0.0834
K2267 L66_67 L63_64 0.299
K2268 L66_67 L62_63 0.1626
K2269 L66_67 L46_47 0.3016
K2270 L66_67 L1_17 0.2236
K2271 L66_67 L10_11 0.1388
K2272 L66_67 L56_57 0.0613
K2273 L66_67 L83_84 0.1426
K2274 L66_67 L35_36 0.0927
K2275 L66_67 L42_43 0.1168
K2276 L66_67 L37_38 0.0836
K2277 L66_67 L49_50 0.0777
K2278 L66_67 L28_29 0.0675
K2279 L66_67 L64_79 0.0747
K2280 L66_67 L68_69 0.0736
K2281 L66_67 L45_46 0.1935
K2282 L66_67 L59_60 0.1405
K2283 L66_67 L51_52 0.1188
K2284 L66_67 L71_72 0.0748
K2285 L66_67 L39_40 0.0916
K2286 L66_67 L27_28 0.0615
K2287 L66_67 L61_77 0.0642
K2288 L66_67 L44_45 0.0979
K2289 L66_67 L47_48 0.1406
K2290 L66_67 L29_32 0.0412
K2291 L66_67 L11_12 0.1194
K2292 L66_67 L90_91 0.04
K2293 L66_67 L24_25 0.0745
K2294 L66_67 L18_19 0.1571
K2295 L8_9 L52_53 0.0899
K2296 L8_9 L54_55 0.0322
K2297 L8_9 L32_33 0.0342
K2298 L8_9 L16_17 0.0633
K2299 L8_9 L86_87 0.0649
K2300 L8_9 L84_85 0.1264
K2301 L8_9 L14_15 0.0655
K2302 L8_9 L70_86 0.0641
K2303 L8_9 L13_23 0.0499
K2304 L8_9 L40_41 0.0851
K2305 L8_9 L57_58 0.0488
K2306 L8_9 L74_75 0.0353
K2307 L8_9 L2_3 0.1335
K2308 L8_9 L73_88 0.0433
K2309 L8_9 L55_56 0.0387
K2310 L8_9 L75_76 0.0438
K2311 L8_9 L36_37 0.0803
K2312 L8_9 L25_26 0.0518
K2313 L8_9 L63_64 0.1356
K2314 L8_9 L62_63 0.0696
K2315 L8_9 L46_47 0.1189
K2316 L8_9 L1_17 0.1208
K2317 L8_9 L10_11 0.1251
K2318 L8_9 L56_57 0.0457
K2319 L8_9 L83_84 0.1217
K2320 L8_9 L35_36 0.0631
K2321 L8_9 L42_43 0.1238
K2322 L8_9 L37_38 0.082
K2323 L8_9 L49_50 0.0443
K2324 L8_9 L28_29 0.0439
K2325 L8_9 L64_79 0.1482
K2326 L8_9 L68_69 0.0381
K2327 L8_9 L45_46 0.07
K2328 L8_9 L59_60 0.0629
K2329 L8_9 L51_52 0.0778
K2330 L8_9 L71_72 0.0404
K2331 L8_9 L39_40 0.059
K2332 L8_9 L27_28 0.0353
K2333 L8_9 L61_77 0.1158
K2334 L8_9 L44_45 0.0489
K2335 L8_9 L47_48 0.1844
K2336 L8_9 L29_32 0.034
K2337 L8_9 L11_12 0.1303
K2338 L8_9 L90_91 0.034
K2339 L8_9 L24_25 0.0405
K2340 L8_9 L18_19 0.0701
K2341 L72_75 L62_65 0.0474
K2342 L72_75 L82_85 0.0373
K2343 L72_75 L6_9 0.026
K2344 L72_75 L14_30 0.0439
K2345 L72_75 L16_18 0.0429
K2346 L72_75 L44_49 0.0731
K2347 L72_75 L48_53 0.0465
K2348 L72_75 L3_6 0.0246
K2349 L72_75 L15_31 0.0343
K2350 L72_75 L7_10 0.0413
K2351 L72_75 L84_86 0.0521
K2352 L72_75 L2_5 0.0296
K2353 L72_75 L49_54 0.0743
K2354 L72_75 L38_43 0.0329
K2355 L72_75 L50_55 0.1088
K2356 L72_75 L47_52 0.0791
K2357 L72_75 L45_50 0.1061
K2358 L72_75 L79_81 0.0315
K2359 L72_75 L80_82 0.026
K2360 L72_75 L52_57 0.0913
K2361 L72_75 L89_91 0.0347
K2362 L72_75 L87_89 0.0345
K2363 L72_75 L18_20 0.0472
K2364 L72_75 L86_88 0.0441
K2365 L72_75 L10_13 0.0502
K2366 L72_75 L42_47 0.0591
K2367 L72_75 L78_80 0.0246
K2368 L72_75 L59_62 0.0431
K2369 L72_75 L13_26 0.0728
K2370 L72_75 L40_45 0.0804
K2371 L72_75 L43_48 0.0395
K2372 L72_75 L64_67 0.0447
K2373 L72_75 L71_74 0.1108
K2374 L72_75 L51_56 0.1862
K2375 L72_75 L85_87 0.0435
K2376 L72_75 L61_64 0.0413
K2377 L72_75 L9_12 0.0372
K2378 L72_75 L36_41 0.0502
K2379 L72_75 L67_83 0.0415
K2380 L72_75 L68_71 0.1069
K2381 L72_75 L24_27 0.1079
K2382 L72_75 L11_14 0.0519
K2383 L72_75 L39_44 0.0598
K2384 L72_75 L70_83 0.0505
K2385 L72_75 L12_15 0.0434
K2386 L63_66 L62_65 0.1108
K2387 L63_66 L82_85 0.0484
K2388 L63_66 L6_9 0.0345
K2389 L63_66 L14_30 0.0334
K2390 L63_66 L16_18 0.1042
K2391 L63_66 L44_49 0.0731
K2392 L63_66 L48_53 0.0465
K2393 L63_66 L3_6 0.0343
K2394 L63_66 L15_31 0.0274
K2395 L63_66 L7_10 0.0582
K2396 L63_66 L84_86 0.0521
K2397 L63_66 L2_5 0.0439
K2398 L63_66 L49_54 0.0598
K2399 L63_66 L38_43 0.0438
K2400 L63_66 L50_55 0.0804
K2401 L63_66 L47_52 0.0791
K2402 L63_66 L45_50 0.1061
K2403 L63_66 L79_81 0.0444
K2404 L63_66 L80_82 0.0347
K2405 L63_66 L52_57 0.0591
K2406 L63_66 L89_91 0.026
K2407 L63_66 L87_89 0.0275
K2408 L63_66 L18_20 0.1079
K2409 L63_66 L86_88 0.0335
K2410 L63_66 L10_13 0.0502
K2411 L63_66 L42_47 0.0913
K2412 L63_66 L78_80 0.0345
K2413 L63_66 L59_62 0.1069
K2414 L63_66 L13_26 0.0482
K2415 L63_66 L40_45 0.1088
K2416 L63_66 L43_48 0.0496
K2417 L63_66 L64_67 0.0746
K2418 L63_66 L71_74 0.0474
K2419 L63_66 L51_56 0.0715
K2420 L63_66 L85_87 0.0435
K2421 L63_66 L61_64 0.0735
K2422 L63_66 L9_12 0.0482
K2423 L63_66 L36_41 0.0952
K2424 L63_66 L67_83 0.0586
K2425 L63_66 L68_71 0.0526
K2426 L63_66 L24_27 0.0472
K2427 L63_66 L11_14 0.0519
K2428 L63_66 L39_44 0.0743
K2429 L63_66 L70_83 0.0505
K2430 L63_66 L12_15 0.0434
K2431 L63_64 L2_3 0.0618
K2432 L63_64 L52_53 0.0928
K2433 L63_64 L32_33 0.0383
K2434 L63_64 L70_86 0.0713
K2435 L63_64 L16_17 0.1727
K2436 L63_64 L7_8 0.1675
K2437 L63_64 L86_87 0.0679
K2438 L63_64 L14_15 0.0675
K2439 L63_64 L28_29 0.064
K2440 L63_64 L40_41 0.1697
K2441 L63_64 L57_58 0.0558
K2442 L63_64 L74_75 0.0597
K2443 L63_64 L20_21 0.1571
K2444 L63_64 L73_88 0.0498
K2445 L63_64 L55_56 0.0584
K2446 L63_64 L75_76 0.0642
K2447 L63_64 L67_81 0.1756
K2448 L63_64 L36_37 0.1252
K2449 L63_64 L25_26 0.0778
K2450 L63_64 L83_84 0.1198
K2451 L63_64 L46_47 0.2352
K2452 L63_64 L1_17 0.351
K2453 L63_64 L10_11 0.118
K2454 L63_64 L56_57 0.0609
K2455 L63_64 L35_36 0.1135
K2456 L63_64 L42_43 0.1411
K2457 L63_64 L37_38 0.1003
K2458 L63_64 L49_50 0.079
K2459 L63_64 L13_23 0.0768
K2460 L63_64 L68_69 0.0699
K2461 L63_64 L7_21 0.2746
K2462 L63_64 L45_46 0.1763
K2463 L63_64 L59_60 0.1825
K2464 L63_64 L51_52 0.1116
K2465 L63_64 L71_72 0.0716
K2466 L63_64 L39_40 0.1063
K2467 L63_64 L27_28 0.0596
K2468 L63_64 L61_77 0.0743
K2469 L63_64 L44_45 0.1019
K2470 L63_64 L84_85 0.1083
K2471 L63_64 L47_48 0.139
K2472 L63_64 L29_32 0.0394
K2473 L63_64 L11_12 0.107
K2474 L63_64 L90_91 0.0385
K2475 L63_64 L24_25 0.0713
K2476 L63_64 L54_55 0.051
K2477 L15_31 L14_30 0.1544
K2478 L15_31 L16_18 0.0233
K2479 L15_31 L48_53 0.0737
K2480 L15_31 L7_10 0.0624
K2481 L15_31 L2_5 0.032
K2482 L15_31 L49_54 0.0317
K2483 L15_31 L38_43 0.0319
K2484 L15_31 L50_55 0.0423
K2485 L15_31 L45_50 0.0422
K2486 L15_31 L79_81 0.0361
K2487 L15_31 L62_65 0.0243
K2488 L15_31 L17_19 0.026
K2489 L15_31 L18_20 0.0244
K2490 L15_31 L86_88 0.1377
K2491 L15_31 L84_86 0.1351
K2492 L15_31 L10_13 0.1182
K2493 L15_31 L13_26 0.0704
K2494 L15_31 L40_45 0.0389
K2495 L15_31 L64_67 0.0386
K2496 L15_31 L43_48 0.0457
K2497 L15_31 L59_62 0.0233
K2498 L15_31 L60_63 0.026
K2499 L15_31 L71_74 0.0291
K2500 L15_31 L51_56 0.0656
K2501 L15_31 L61_64 0.0351
K2502 L15_31 L36_41 0.0419
K2503 L15_31 L67_83 0.0615
K2504 L15_31 L25_28 0.0345
K2505 L15_31 L68_71 0.0292
K2506 L15_31 L24_27 0.0292
K2507 L15_31 L44_49 0.0316
K2508 L15_31 L39_44 0.0296
K2509 L15_31 L70_83 0.1125
K2510 L15_31 L11_14 0.1439
K2511 L7_10 L6_9 0.1513
K2512 L7_10 L60_63 0.056
K2513 L7_10 L14_30 0.0756
K2514 L7_10 L16_18 0.0472
K2515 L7_10 L44_49 0.0502
K2516 L7_10 L3_6 0.1415
K2517 L7_10 L48_53 0.0949
K2518 L7_10 L84_86 0.1756
K2519 L7_10 L2_5 0.268
K2520 L7_10 L38_43 0.0707
K2521 L7_10 L50_55 0.0599
K2522 L7_10 L47_52 0.2898
K2523 L7_10 L45_50 0.0678
K2524 L7_10 L79_81 0.2439
K2525 L7_10 L80_82 0.1408
K2526 L7_10 L62_65 0.0483
K2527 L7_10 L89_91 0.0523
K2528 L7_10 L17_19 0.0563
K2529 L7_10 L52_57 0.1197
K2530 L7_10 L87_89 0.0615
K2531 L7_10 L18_20 0.0485
K2532 L7_10 L86_88 0.0744
K2533 L7_10 L42_47 0.3239
K2534 L7_10 L78_80 0.1325
K2535 L7_10 L59_62 0.047
K2536 L7_10 L49_54 0.0455
K2537 L7_10 L40_45 0.0684
K2538 L7_10 L43_48 0.1007
K2539 L7_10 L82_85 0.194
K2540 L7_10 L71_74 0.0369
K2541 L7_10 L51_56 0.0844
K2542 L7_10 L85_87 0.1327
K2543 L7_10 L9_12 0.2075
K2544 L7_10 L36_41 0.0902
K2545 L7_10 L25_28 0.0415
K2546 L7_10 L68_71 0.039
K2547 L7_10 L24_27 0.037
K2548 L7_10 L11_14 0.1887
K2549 L7_10 L39_44 0.0506
K2550 L7_10 L12_15 0.1375
K2551 L20_21 L52_53 0.0729
K2552 L20_21 L54_55 0.0569
K2553 L20_21 L32_33 0.0324
K2554 L20_21 L16_17 0.238
K2555 L20_21 L86_87 0.052
K2556 L20_21 L84_85 0.0684
K2557 L20_21 L14_15 0.0522
K2558 L20_21 L70_86 0.0566
K2559 L20_21 L13_23 0.0736
K2560 L20_21 L40_41 0.1527
K2561 L20_21 L57_58 0.048
K2562 L20_21 L74_75 0.0675
K2563 L20_21 L2_3 0.0344
K2564 L20_21 L73_88 0.0421
K2565 L20_21 L55_56 0.0617
K2566 L20_21 L75_76 0.0615
K2567 L20_21 L36_37 0.0883
K2568 L20_21 L25_26 0.0748
K2569 L20_21 L62_63 0.2746
K2570 L20_21 L46_47 0.1636
K2571 L20_21 L1_17 0.1405
K2572 L20_21 L10_11 0.0778
K2573 L20_21 L56_57 0.0569
K2574 L20_21 L83_84 0.0773
K2575 L20_21 L35_36 0.1003
K2576 L20_21 L42_43 0.0848
K2577 L20_21 L37_38 0.0652
K2578 L20_21 L49_50 0.1
K2579 L20_21 L28_29 0.0618
K2580 L20_21 L64_79 0.0433
K2581 L20_21 L68_69 0.0833
K2582 L20_21 L45_46 0.3211
K2583 L20_21 L59_60 0.2236
K2584 L20_21 L51_52 0.1
K2585 L20_21 L71_72 0.0834
K2586 L20_21 L39_40 0.1262
K2587 L20_21 L27_28 0.0678
K2588 L20_21 L61_77 0.0378
K2589 L20_21 L44_45 0.1636
K2590 L20_21 L47_48 0.0887
K2591 L20_21 L29_32 0.0344
K2592 L20_21 L11_12 0.0688
K2593 L20_21 L90_91 0.0323
K2594 L20_21 L24_25 0.0839
K2595 L20_21 L18_19 0.299
K2596 L82_85 L14_30 0.0523
K2597 L82_85 L16_18 0.0402
K2598 L82_85 L48_53 0.1169
K2599 L82_85 L2_5 0.1098
K2600 L82_85 L49_54 0.0415
K2601 L82_85 L38_43 0.0786
K2602 L82_85 L50_55 0.0543
K2603 L82_85 L45_50 0.0599
K2604 L82_85 L79_81 0.1492
K2605 L82_85 L62_65 0.0412
K2606 L82_85 L17_19 0.0469
K2607 L82_85 L18_20 0.041
K2608 L82_85 L86_88 0.0527
K2609 L82_85 L84_86 0.1624
K2610 L82_85 L10_13 0.1327
K2611 L82_85 L13_26 0.0557
K2612 L82_85 L40_45 0.0604
K2613 L82_85 L64_67 0.092
K2614 L82_85 L43_48 0.1276
K2615 L82_85 L59_62 0.0403
K2616 L82_85 L60_63 0.0471
K2617 L82_85 L71_74 0.0334
K2618 L82_85 L51_56 0.0748
K2619 L82_85 L61_64 0.0846
K2620 L82_85 L36_41 0.0787
K2621 L82_85 L67_83 0.2075
K2622 L82_85 L25_28 0.0372
K2623 L82_85 L68_71 0.0349
K2624 L82_85 L24_27 0.0333
K2625 L82_85 L44_49 0.045
K2626 L82_85 L39_44 0.0453
K2627 L82_85 L70_83 0.1375
K2628 L82_85 L11_14 0.1554
K2629 L46_47 L2_3 0.0816
K2630 L46_47 L52_53 0.159
K2631 L46_47 L54_55 0.0775
K2632 L46_47 L32_33 0.0641
K2633 L46_47 L16_17 0.1381
K2634 L46_47 L86_87 0.1199
K2635 L46_47 L14_15 0.1199
K2636 L46_47 L28_29 0.1031
K2637 L46_47 L40_41 0.159
K2638 L46_47 L57_58 0.0903
K2639 L46_47 L64_79 0.1079
K2640 L46_47 L74_75 0.0932
K2641 L46_47 L73_88 0.0834
K2642 L46_47 L55_56 0.0903
K2643 L46_47 L75_76 0.1031
K2644 L46_47 L67_81 0.1366
K2645 L46_47 L36_37 0.1278
K2646 L46_47 L25_26 0.1266
K2647 L46_47 L62_63 0.1564
K2648 L46_47 L1_17 0.2003
K2649 L46_47 L90_91 0.0641
K2650 L46_47 L35_36 0.1152
K2651 L46_47 L42_43 0.159
K2652 L46_47 L37_38 0.1152
K2653 L46_47 L49_50 0.1191
K2654 L46_47 L13_23 0.1259
K2655 L46_47 L68_69 0.1093
K2656 L46_47 L7_21 0.3016
K2657 L46_47 L70_86 0.1238
K2658 L46_47 L59_60 0.1381
K2659 L46_47 L71_72 0.1119
K2660 L46_47 L39_40 0.1191
K2661 L46_47 L27_28 0.0932
K2662 L46_47 L61_77 0.0914
K2663 L46_47 L51_52 0.1835
K2664 L46_47 L29_32 0.0652
K2665 L46_47 L56_57 0.0962
K2666 L46_47 L24_25 0.1119
K2667 L46_47 L18_19 0.1564
K2668 L46_47 L7_8 0.1366
K2669 L43_48 L6_9 0.0893
K2670 L43_48 L14_30 0.0491
K2671 L43_48 L16_18 0.0445
K2672 L43_48 L44_49 0.0524
K2673 L43_48 L3_6 0.0962
K2674 L43_48 L2_5 0.0883
K2675 L43_48 L49_54 0.0484
K2676 L43_48 L50_55 0.0617
K2677 L43_48 L47_52 0.133
K2678 L43_48 L45_50 0.0677
K2679 L43_48 L79_81 0.0839
K2680 L43_48 L80_82 0.0893
K2681 L43_48 L52_57 0.1
K2682 L43_48 L89_91 0.0421
K2683 L43_48 L17_19 0.0503
K2684 L43_48 L87_89 0.0457
K2685 L43_48 L18_20 0.0441
K2686 L43_48 L86_88 0.0491
K2687 L43_48 L10_13 0.0824
K2688 L43_48 L84_86 0.0932
K2689 L43_48 L42_47 0.1527
K2690 L43_48 L78_80 0.0962
K2691 L43_48 L59_62 0.0445
K2692 L43_48 L13_26 0.053
K2693 L43_48 L40_45 0.0701
K2694 L43_48 L64_67 0.0745
K2695 L43_48 L85_87 0.0957
K2696 L43_48 L60_63 0.0503
K2697 L43_48 L71_74 0.0362
K2698 L43_48 L51_56 0.0775
K2699 L43_48 L62_65 0.0441
K2700 L43_48 L61_64 0.0765
K2701 L43_48 L9_12 0.1276
K2702 L43_48 L36_41 0.0903
K2703 L43_48 L67_83 0.1007
K2704 L43_48 L25_28 0.0395
K2705 L43_48 L68_71 0.0374
K2706 L43_48 L24_27 0.0362
K2707 L43_48 L11_14 0.0932
K2708 L43_48 L39_44 0.054
K2709 L43_48 L70_83 0.0824
K2710 L43_48 L12_15 0.0957
K2711 L18_20 L6_9 0.0293
K2712 L18_20 L14_30 0.0297
K2713 L18_20 L86_88 0.0296
K2714 L18_20 L44_49 0.0971
K2715 L18_20 L48_53 0.0417
K2716 L18_20 L3_6 0.0292
K2717 L18_20 L2_5 0.0367
K2718 L18_20 L49_54 0.0705
K2719 L18_20 L38_43 0.0397
K2720 L18_20 L47_52 0.0693
K2721 L18_20 L67_83 0.0483
K2722 L18_20 L79_81 0.0367
K2723 L18_20 L80_82 0.0292
K2724 L18_20 L52_57 0.0541
K2725 L18_20 L89_91 0.0233
K2726 L18_20 L17_19 0.1069
K2727 L18_20 L87_89 0.0243
K2728 L18_20 L25_28 0.0474
K2729 L18_20 L10_13 0.0434
K2730 L18_20 L42_47 0.0774
K2731 L18_20 L78_80 0.0291
K2732 L18_20 L13_26 0.0428
K2733 L18_20 L64_67 0.0584
K2734 L18_20 L60_63 0.1042
K2735 L18_20 L51_56 0.0668
K2736 L18_20 L85_87 0.0378
K2737 L18_20 L61_64 0.0579
K2738 L18_20 L9_12 0.0412
K2739 L18_20 L36_41 0.0862
K2740 L18_20 L84_86 0.0449
K2741 L18_20 L11_14 0.0451
K2742 L18_20 L39_44 0.1
K2743 L18_20 L70_83 0.0433
K2744 L18_20 L12_15 0.0379
K2745 L84_86 L6_9 0.1059
K2746 L84_86 L85_87 0.2651
K2747 L84_86 L16_18 0.043
K2748 L84_86 L3_6 0.0842
K2749 L84_86 L48_53 0.1253
K2750 L84_86 L49_54 0.0514
K2751 L84_86 L38_43 0.0633
K2752 L84_86 L50_55 0.0685
K2753 L84_86 L47_52 0.2868
K2754 L84_86 L45_50 0.0713
K2755 L84_86 L80_82 0.1098
K2756 L84_86 L62_65 0.0451
K2757 L84_86 L89_91 0.1098
K2758 L84_86 L17_19 0.0491
K2759 L84_86 L52_57 0.1969
K2760 L84_86 L87_89 0.1439
K2761 L84_86 L42_47 0.1969
K2762 L84_86 L78_80 0.0861
K2763 L84_86 L59_62 0.0431
K2764 L84_86 L10_13 0.316
K2765 L84_86 L13_26 0.0945
K2766 L84_86 L40_45 0.0685
K2767 L84_86 L64_67 0.0838
K2768 L84_86 L60_63 0.0493
K2769 L84_86 L39_44 0.0514
K2770 L84_86 L71_74 0.0451
K2771 L84_86 L51_56 0.1043
K2772 L84_86 L9_12 0.1554
K2773 L84_86 L36_41 0.078
K2774 L84_86 L67_83 0.1887
K2775 L84_86 L25_28 0.0519
K2776 L84_86 L68_71 0.0469
K2777 L84_86 L24_27 0.0449
K2778 L84_86 L44_49 0.0531
K2779 L84_86 L61_64 0.0738
K2780 L84_86 L70_83 0.386
K2781 L84_86 L12_15 0.2416
K2782 L78_80 L14_30 0.0318
K2783 L78_80 L16_18 0.0292
K2784 L78_80 L48_53 0.0601
K2785 L78_80 L2_5 0.1377
K2786 L78_80 L49_54 0.0283
K2787 L78_80 L38_43 0.0601
K2788 L78_80 L50_55 0.0368
K2789 L78_80 L45_50 0.0413
K2790 L78_80 L79_81 0.1344
K2791 L78_80 L62_65 0.0292
K2792 L78_80 L17_19 0.0345
K2793 L78_80 L86_88 0.032
K2794 L78_80 L10_13 0.074
K2795 L78_80 L13_26 0.0351
K2796 L78_80 L40_45 0.0419
K2797 L78_80 L64_67 0.0688
K2798 L78_80 L59_62 0.0293
K2799 L78_80 L60_63 0.0347
K2800 L78_80 L71_74 0.0222
K2801 L78_80 L51_56 0.0494
K2802 L78_80 L61_64 0.0704
K2803 L78_80 L36_41 0.0624
K2804 L78_80 L67_83 0.1415
K2805 L78_80 L25_28 0.0246
K2806 L78_80 L68_71 0.0233
K2807 L78_80 L24_27 0.0222
K2808 L78_80 L44_49 0.0311
K2809 L78_80 L39_44 0.0314
K2810 L78_80 L70_83 0.0756
K2811 L78_80 L11_14 0.0842
K2812 L56_57 L2_3 0.032
K2813 L56_57 L52_53 0.133
K2814 L56_57 L32_33 0.0665
K2815 L56_57 L70_86 0.0687
K2816 L56_57 L16_17 0.0512
K2817 L56_57 L86_87 0.0652
K2818 L56_57 L14_15 0.0652
K2819 L56_57 L28_29 0.1541
K2820 L56_57 L40_41 0.0677
K2821 L56_57 L64_79 0.038
K2822 L56_57 L74_75 0.1117
K2823 L56_57 L73_88 0.0729
K2824 L56_57 L75_76 0.1541
K2825 L56_57 L67_81 0.0469
K2826 L56_57 L36_37 0.054
K2827 L56_57 L25_26 0.1354
K2828 L56_57 L62_63 0.0572
K2829 L56_57 L1_17 0.0544
K2830 L56_57 L10_11 0.059
K2831 L56_57 L90_91 0.0665
K2832 L56_57 L83_84 0.059
K2833 L56_57 L35_36 0.0524
K2834 L56_57 L42_43 0.0677
K2835 L56_57 L37_38 0.0524
K2836 L56_57 L49_50 0.1
K2837 L56_57 L13_23 0.1178
K2838 L56_57 L68_69 0.0946
K2839 L56_57 L7_21 0.0613
K2840 L56_57 L45_46 0.0903
K2841 L56_57 L59_60 0.0512
K2842 L56_57 L51_52 0.1527
K2843 L56_57 L71_72 0.1069
K2844 L56_57 L39_40 0.0617
K2845 L56_57 L27_28 0.1117
K2846 L56_57 L61_77 0.0327
K2847 L56_57 L44_45 0.0775
K2848 L56_57 L84_85 0.0572
K2849 L56_57 L47_48 0.0903
K2850 L56_57 L29_32 0.0737
K2851 L56_57 L11_12 0.0572
K2852 L56_57 L24_25 0.1069
K2853 L56_57 L18_19 0.0572
K2854 L56_57 L7_8 0.0469
K2855 L37_38 L2_3 0.0801
K2856 L37_38 L54_55 0.0434
K2857 L37_38 L32_33 0.0316
K2858 L37_38 L70_86 0.0512
K2859 L37_38 L16_17 0.0713
K2860 L37_38 L86_87 0.0511
K2861 L37_38 L14_15 0.0511
K2862 L37_38 L28_29 0.0474
K2863 L37_38 L40_41 0.1179
K2864 L37_38 L57_58 0.054
K2865 L37_38 L64_79 0.0834
K2866 L37_38 L74_75 0.043
K2867 L37_38 L73_88 0.0385
K2868 L37_38 L55_56 0.0484
K2869 L37_38 L68_69 0.0466
K2870 L37_38 L67_81 0.0826
K2871 L37_38 L52_53 0.0856
K2872 L37_38 L25_26 0.0549
K2873 L37_38 L62_63 0.0753
K2874 L37_38 L1_17 0.0977
K2875 L37_38 L10_11 0.0722
K2876 L37_38 L83_84 0.0722
K2877 L37_38 L42_43 0.2499
K2878 L37_38 L49_50 0.0609
K2879 L37_38 L13_23 0.0523
K2880 L37_38 L75_76 0.0474
K2881 L37_38 L7_21 0.0836
K2882 L37_38 L45_46 0.0917
K2883 L37_38 L59_60 0.0713
K2884 L37_38 L51_52 0.0814
K2885 L37_38 L71_72 0.0494
K2886 L37_38 L39_40 0.0826
K2887 L37_38 L27_28 0.043
K2888 L37_38 L61_77 0.081
K2889 L37_38 L44_45 0.072
K2890 L37_38 L84_85 0.0719
K2891 L37_38 L47_48 0.1278
K2892 L37_38 L29_32 0.0317
K2893 L37_38 L11_12 0.0719
K2894 L37_38 L90_91 0.0316
K2895 L37_38 L24_25 0.0494
K2896 L37_38 L18_19 0.0753
K2897 L37_38 L7_8 0.0826
K2898 L40_41 L52_53 0.0923
K2899 L40_41 L54_55 0.0677
K2900 L40_41 L32_33 0.0379
K2901 L40_41 L70_86 0.0621
K2902 L40_41 L86_87 0.0598
K2903 L40_41 L14_15 0.0598
K2904 L40_41 L28_29 0.0649
K2905 L40_41 L83_84 0.0851
K2906 L40_41 L57_58 0.0617
K2907 L40_41 L74_75 0.0668
K2908 L40_41 L73_88 0.0472
K2909 L40_41 L55_56 0.0701
K2910 L40_41 L75_76 0.0649
K2911 L40_41 L67_81 0.0921
K2912 L40_41 L36_37 0.1871
K2913 L40_41 L25_26 0.0761
K2914 L40_41 L62_63 0.1987
K2915 L40_41 L10_11 0.0851
K2916 L40_41 L90_91 0.0379
K2917 L40_41 L35_36 0.2499
K2918 L40_41 L49_50 0.1078
K2919 L40_41 L13_23 0.073
K2920 L40_41 L64_79 0.0877
K2921 L40_41 L68_69 0.0757
K2922 L40_41 L7_21 0.1353
K2923 L40_41 L45_46 0.1835
K2924 L40_41 L7_8 0.0921
K2925 L40_41 L51_52 0.1078
K2926 L40_41 L71_72 0.0786
K2927 L40_41 L27_28 0.0668
K2928 L40_41 L44_45 0.159
K2929 L40_41 L84_85 0.0805
K2930 L40_41 L47_48 0.1191
K2931 L40_41 L29_32 0.0389
K2932 L40_41 L11_12 0.0805
K2933 L40_41 L24_25 0.0786
K2934 L40_41 L18_19 0.1987
K2935 L75_76 L2_3 0.0303
K2936 L75_76 L70_86 0.0727
K2937 L75_76 L16_17 0.0529
K2938 L75_76 L86_87 0.0647
K2939 L75_76 L14_15 0.0643
K2940 L75_76 L83_84 0.0598
K2941 L75_76 L57_58 0.101
K2942 L75_76 L64_79 0.0371
K2943 L75_76 L73_88 0.0747
K2944 L75_76 L55_56 0.1233
K2945 L75_76 L68_69 0.1405
K2946 L75_76 L67_81 0.0462
K2947 L75_76 L36_37 0.0501
K2948 L75_76 L25_26 0.2746
K2949 L75_76 L62_63 0.0597
K2950 L75_76 L1_17 0.0566
K2951 L75_76 L10_11 0.0595
K2952 L75_76 L35_36 0.0489
K2953 L75_76 L42_43 0.0623
K2954 L75_76 L13_23 0.2236
K2955 L75_76 L7_21 0.0675
K2956 L75_76 L45_46 0.0969
K2957 L75_76 L59_60 0.0531
K2958 L75_76 L71_72 0.1626
K2959 L75_76 L39_40 0.0574
K2960 L75_76 L54_55 0.0761
K2961 L75_76 L61_77 0.0317
K2962 L75_76 L44_45 0.0763
K2963 L75_76 L84_85 0.056
K2964 L75_76 L47_48 0.0891
K2965 L75_76 L11_12 0.0558
K2966 L75_76 L24_25 0.1571
K2967 L75_76 L18_19 0.0596
K2968 L75_76 L7_8 0.046
K2969 L13_26 L6_9 0.0388
K2970 L13_26 L60_63 0.0445
K2971 L13_26 L14_30 0.1028
K2972 L13_26 L16_18 0.04
K2973 L13_26 L44_49 0.0556
K2974 L13_26 L3_6 0.0353
K2975 L13_26 L48_53 0.0689
K2976 L13_26 L2_5 0.0423
K2977 L13_26 L38_43 0.0407
K2978 L13_26 L50_55 0.0768
K2979 L13_26 L47_52 0.1352
K2980 L13_26 L45_50 0.0765
K2981 L13_26 L79_81 0.0468
K2982 L13_26 L80_82 0.0386
K2983 L13_26 L62_65 0.0426
K2984 L13_26 L89_91 0.0678
K2985 L13_26 L17_19 0.0447
K2986 L13_26 L52_57 0.1534
K2987 L13_26 L87_89 0.0693
K2988 L13_26 L86_88 0.1
K2989 L13_26 L42_47 0.0793
K2990 L13_26 L59_62 0.0399
K2991 L13_26 L49_54 0.0558
K2992 L13_26 L40_45 0.0676
K2993 L13_26 L71_74 0.0579
K2994 L13_26 L51_56 0.1406
K2995 L13_26 L85_87 0.0758
K2996 L13_26 L9_12 0.056
K2997 L13_26 L36_41 0.0679
K2998 L13_26 L25_28 0.0735
K2999 L13_26 L68_71 0.0584
K3000 L13_26 L24_27 0.0582
K3001 L13_26 L11_14 0.0957
K3002 L13_26 L39_44 0.0506
K3003 L13_26 L12_15 0.0765
K3004 L40_45 L6_9 0.0422
K3005 L40_45 L14_30 0.0472
K3006 L40_45 L86_88 0.0472
K3007 L40_45 L44_49 0.1871
K3008 L40_45 L48_53 0.0677
K3009 L40_45 L3_6 0.0419
K3010 L40_45 L2_5 0.0512
K3011 L40_45 L49_54 0.1179
K3012 L40_45 L38_43 0.0677
K3013 L40_45 L47_52 0.1078
K3014 L40_45 L67_83 0.0684
K3015 L40_45 L79_81 0.0517
K3016 L40_45 L80_82 0.0422
K3017 L40_45 L52_57 0.0923
K3018 L40_45 L89_91 0.0379
K3019 L40_45 L17_19 0.1061
K3020 L40_45 L87_89 0.0389
K3021 L40_45 L25_28 0.0804
K3022 L40_45 L10_13 0.0654
K3023 L40_45 L42_47 0.1149
K3024 L40_45 L64_67 0.0765
K3025 L40_45 L60_63 0.1061
K3026 L40_45 L51_56 0.1191
K3027 L40_45 L85_87 0.0582
K3028 L40_45 L61_64 0.0756
K3029 L40_45 L9_12 0.0604
K3030 L40_45 L36_41 0.159
K3031 L40_45 L11_14 0.0685
K3032 L40_45 L39_44 0.2499
K3033 L40_45 L70_83 0.0654
K3034 L40_45 L12_15 0.0582
K3035 L45_46 L2_3 0.0506
K3036 L45_46 L52_53 0.1191
K3037 L45_46 L54_55 0.0903
K3038 L45_46 L32_33 0.0522
K3039 L45_46 L16_17 0.2074
K3040 L45_46 L86_87 0.0851
K3041 L45_46 L14_15 0.0851
K3042 L45_46 L28_29 0.0969
K3043 L45_46 L57_58 0.0775
K3044 L45_46 L64_79 0.0634
K3045 L45_46 L74_75 0.1031
K3046 L45_46 L73_88 0.0678
K3047 L45_46 L55_56 0.0962
K3048 L45_46 L67_81 0.0764
K3049 L45_46 L36_37 0.1152
K3050 L45_46 L25_26 0.1172
K3051 L45_46 L62_63 0.2445
K3052 L45_46 L1_17 0.1543
K3053 L45_46 L90_91 0.0522
K3054 L45_46 L35_36 0.1278
K3055 L45_46 L42_43 0.1191
K3056 L45_46 L49_50 0.159
K3057 L45_46 L13_23 0.1152
K3058 L45_46 L68_69 0.1259
K3059 L45_46 L7_21 0.1935
K3060 L45_46 L70_86 0.0921
K3061 L45_46 L59_60 0.2074
K3062 L45_46 L71_72 0.1266
K3063 L45_46 L39_40 0.159
K3064 L45_46 L27_28 0.1031
K3065 L45_46 L61_77 0.055
K3066 L45_46 L51_52 0.159
K3067 L45_46 L29_32 0.0549
K3068 L45_46 L24_25 0.1266
K3069 L45_46 L18_19 0.2445
K3070 L45_46 L7_8 0.0764
K3071 L59_62 L6_9 0.0291
K3072 L59_62 L14_30 0.0281
K3073 L59_62 L86_88 0.0282
K3074 L59_62 L44_49 0.0928
K3075 L59_62 L48_53 0.0407
K3076 L59_62 L3_6 0.0292
K3077 L59_62 L2_5 0.0367
K3078 L59_62 L49_54 0.0654
K3079 L59_62 L38_43 0.0407
K3080 L59_62 L47_52 0.0661
K3081 L59_62 L67_83 0.0472
K3082 L59_62 L79_81 0.0367
K3083 L59_62 L80_82 0.0292
K3084 L59_62 L52_57 0.0515
K3085 L59_62 L89_91 0.0222
K3086 L59_62 L17_19 0.1079
K3087 L59_62 L87_89 0.0233
K3088 L59_62 L25_28 0.0429
K3089 L59_62 L10_13 0.0412
K3090 L59_62 L42_47 0.0793
K3091 L59_62 L64_67 0.0582
K3092 L59_62 L60_63 0.1108
K3093 L59_62 L51_56 0.062
K3094 L59_62 L85_87 0.0364
K3095 L59_62 L61_64 0.0587
K3096 L59_62 L9_12 0.0402
K3097 L59_62 L36_41 0.0949
K3098 L59_62 L11_14 0.043
K3099 L59_62 L39_44 0.0971
K3100 L59_62 L70_83 0.0413
K3101 L59_62 L12_15 0.0364
K3102 L59_60 L52_53 0.0673
K3103 L59_60 L54_55 0.0512
K3104 L59_60 L32_33 0.029
K3105 L59_60 L70_86 0.0499
K3106 L59_60 L86_87 0.0466
K3107 L59_60 L14_15 0.0465
K3108 L59_60 L28_29 0.0529
K3109 L59_60 L83_84 0.0691
K3110 L59_60 L57_58 0.0444
K3111 L59_60 L74_75 0.0568
K3112 L59_60 L73_88 0.0372
K3113 L59_60 L55_56 0.0546
K3114 L59_60 L67_81 0.0723
K3115 L59_60 L36_37 0.1053
K3116 L59_60 L25_26 0.0632
K3117 L59_60 L62_63 0.4206
K3118 L59_60 L10_11 0.0687
K3119 L59_60 L90_91 0.029
K3120 L59_60 L35_36 0.1263
K3121 L59_60 L49_50 0.0868
K3122 L59_60 L13_23 0.0615
K3123 L59_60 L64_79 0.0649
K3124 L59_60 L68_69 0.0678
K3125 L59_60 L7_21 0.1366
K3126 L59_60 L7_8 0.0717
K3127 L59_60 L51_52 0.0868
K3128 L59_60 L71_72 0.0689
K3129 L59_60 L27_28 0.0566
K3130 L59_60 L44_45 0.1381
K3131 L59_60 L84_85 0.0625
K3132 L59_60 L47_48 0.0842
K3133 L59_60 L29_32 0.0303
K3134 L59_60 L11_12 0.0622
K3135 L59_60 L24_25 0.0686
K3136 L59_60 L18_19 0.351
K3137 L51_52 L2_3 0.0535
K3138 L51_52 L70_86 0.1366
K3139 L51_52 L16_17 0.0868
K3140 L51_52 L86_87 0.1189
K3141 L51_52 L14_15 0.1189
K3142 L51_52 L83_84 0.1081
K3143 L51_52 L57_58 0.133
K3144 L51_52 L64_79 0.0657
K3145 L51_52 L73_88 0.2115
K3146 L51_52 L55_56 0.133
K3147 L51_52 L68_69 0.2029
K3148 L51_52 L67_81 0.0822
K3149 L51_52 L36_37 0.0856
K3150 L51_52 L25_26 0.3174
K3151 L51_52 L62_63 0.0975
K3152 L51_52 L1_17 0.0985
K3153 L51_52 L10_11 0.1081
K3154 L51_52 L35_36 0.0814
K3155 L51_52 L42_43 0.1078
K3156 L51_52 L13_23 0.3604
K3157 L51_52 L7_21 0.1188
K3158 L51_52 L71_72 0.202
K3159 L51_52 L39_40 0.0923
K3160 L51_52 L54_55 0.1
K3161 L51_52 L61_77 0.056
K3162 L51_52 L44_45 0.1191
K3163 L51_52 L84_85 0.1004
K3164 L51_52 L47_48 0.159
K3165 L51_52 L11_12 0.1004
K3166 L51_52 L24_25 0.202
K3167 L51_52 L18_19 0.0975
K3168 L51_52 L7_8 0.0822
K3169 L71_74 L6_9 0.0233
K3170 L71_74 L14_30 0.0365
K3171 L71_74 L86_88 0.0367
K3172 L71_74 L44_49 0.0971
K3173 L71_74 L48_53 0.0417
K3174 L71_74 L3_6 0.0222
K3175 L71_74 L2_5 0.0267
K3176 L71_74 L49_54 0.1
K3177 L71_74 L38_43 0.0307
K3178 L71_74 L47_52 0.0693
K3179 L71_74 L67_83 0.037
K3180 L71_74 L79_81 0.0282
K3181 L71_74 L80_82 0.0233
K3182 L71_74 L52_57 0.0774
K3183 L71_74 L89_91 0.0293
K3184 L71_74 L17_19 0.0429
K3185 L71_74 L87_89 0.0292
K3186 L71_74 L25_28 0.1079
K3187 L71_74 L10_13 0.0433
K3188 L71_74 L42_47 0.0541
K3189 L71_74 L64_67 0.04
K3190 L71_74 L60_63 0.0431
K3191 L71_74 L51_56 0.1416
K3192 L71_74 L85_87 0.0379
K3193 L71_74 L61_64 0.0374
K3194 L71_74 L9_12 0.0333
K3195 L71_74 L36_41 0.0478
K3196 L71_74 L11_14 0.0449
K3197 L71_74 L39_44 0.0705
K3198 L71_74 L70_83 0.0434
K3199 L71_74 L12_15 0.0378
K3200 L51_56 L6_9 0.0522
K3201 L51_56 L14_30 0.084
K3202 L51_56 L16_18 0.062
K3203 L51_56 L44_49 0.1152
K3204 L51_56 L3_6 0.0494
K3205 L51_56 L2_5 0.06
K3206 L51_56 L49_54 0.1278
K3207 L51_56 L38_43 0.0645
K3208 L51_56 L50_55 0.1835
K3209 L51_56 L47_52 0.159
K3210 L51_56 L45_50 0.159
K3211 L51_56 L79_81 0.0638
K3212 L51_56 L80_82 0.0522
K3213 L51_56 L62_65 0.0668
K3214 L51_56 L89_91 0.0652
K3215 L51_56 L17_19 0.066
K3216 L51_56 L87_89 0.0656
K3217 L51_56 L86_88 0.084
K3218 L51_56 L10_13 0.1018
K3219 L51_56 L42_47 0.1191
K3220 L51_56 L64_67 0.0926
K3221 L51_56 L60_63 0.066
K3222 L51_56 L85_87 0.0862
K3223 L51_56 L61_64 0.0853
K3224 L51_56 L9_12 0.0748
K3225 L51_56 L48_53 0.0903
K3226 L51_56 L67_83 0.0844
K3227 L51_56 L52_57 0.1835
K3228 L51_56 L25_28 0.1862
K3229 L51_56 L68_71 0.1289
K3230 L51_56 L24_27 0.1416
K3231 L51_56 L11_14 0.1043
K3232 L51_56 L39_44 0.0917
K3233 L51_56 L70_83 0.1018
K3234 L51_56 L12_15 0.0862
K3235 L27_28 L2_3 0.0251
K3236 L27_28 L70_86 0.0476
K3237 L27_28 L16_17 0.0568
K3238 L27_28 L86_87 0.0436
K3239 L27_28 L14_15 0.0437
K3240 L27_28 L83_84 0.0456
K3241 L27_28 L57_58 0.07
K3242 L27_28 L64_79 0.0305
K3243 L27_28 L73_88 0.0433
K3244 L27_28 L55_56 0.1587
K3245 L27_28 L68_69 0.2236
K3246 L27_28 L67_81 0.0373
K3247 L27_28 L36_37 0.0482
K3248 L27_28 L25_26 0.1626
K3249 L27_28 L62_63 0.064
K3250 L27_28 L1_17 0.0531
K3251 L27_28 L10_11 0.0458
K3252 L27_28 L35_36 0.0501
K3253 L27_28 L42_43 0.0556
K3254 L27_28 L13_23 0.1405
K3255 L27_28 L7_21 0.0618
K3256 L27_28 L71_72 0.2746
K3257 L27_28 L39_40 0.0637
K3258 L27_28 L54_55 0.1117
K3259 L27_28 L61_77 0.0263
K3260 L27_28 L44_45 0.0932
K3261 L27_28 L84_85 0.0428
K3262 L27_28 L47_48 0.0722
K3263 L27_28 L11_12 0.0429
K3264 L27_28 L24_25 0.299
K3265 L27_28 L18_19 0.0642
K3266 L27_28 L7_8 0.0373
K3267 L48_53 L6_9 0.0665
K3268 L48_53 L14_30 0.0729
K3269 L48_53 L16_18 0.0407
K3270 L48_53 L44_49 0.054
K3271 L48_53 L3_6 0.0601
K3272 L48_53 L2_5 0.062
K3273 L48_53 L49_54 0.0524
K3274 L48_53 L50_55 0.0677
K3275 L48_53 L47_52 0.1527
K3276 L48_53 L45_50 0.0701
K3277 L48_53 L79_81 0.0673
K3278 L48_53 L80_82 0.0665
K3279 L48_53 L52_57 0.133
K3280 L48_53 L89_91 0.0665
K3281 L48_53 L17_19 0.0452
K3282 L48_53 L87_89 0.0737
K3283 L48_53 L86_88 0.0729
K3284 L48_53 L10_13 0.1084
K3285 L48_53 L42_47 0.133
K3286 L48_53 L64_67 0.0657
K3287 L48_53 L85_87 0.1432
K3288 L48_53 L60_63 0.0452
K3289 L48_53 L62_65 0.0417
K3290 L48_53 L61_64 0.0624
K3291 L48_53 L9_12 0.1169
K3292 L48_53 L36_41 0.0775
K3293 L48_53 L67_83 0.0949
K3294 L48_53 L25_28 0.0465
K3295 L48_53 L68_71 0.0426
K3296 L48_53 L24_27 0.0417
K3297 L48_53 L11_14 0.1253
K3298 L48_53 L39_44 0.0524
K3299 L48_53 L70_83 0.1084
K3300 L48_53 L12_15 0.1432
K3301 L44_45 L2_3 0.0359
K3302 L44_45 L52_53 0.0901
K3303 L44_45 L54_55 0.0962
K3304 L44_45 L32_33 0.0397
K3305 L44_45 L16_17 0.1381
K3306 L44_45 L86_87 0.059
K3307 L44_45 L14_15 0.059
K3308 L44_45 L28_29 0.0763
K3309 L44_45 L57_58 0.0645
K3310 L44_45 L64_79 0.0437
K3311 L44_45 L74_75 0.0932
K3312 L44_45 L73_88 0.0499
K3313 L44_45 L55_56 0.0903
K3314 L44_45 L67_81 0.0521
K3315 L44_45 L36_37 0.0917
K3316 L44_45 L25_26 0.0887
K3317 L44_45 L62_63 0.1564
K3318 L44_45 L1_17 0.0918
K3319 L44_45 L90_91 0.0397
K3320 L44_45 L35_36 0.1152
K3321 L44_45 L42_43 0.0901
K3322 L44_45 L49_50 0.1835
K3323 L44_45 L13_23 0.0845
K3324 L44_45 L68_69 0.1093
K3325 L44_45 L7_21 0.0979
K3326 L44_45 L70_86 0.0631
K3327 L44_45 L71_72 0.1119
K3328 L44_45 L39_40 0.1835
K3329 L44_45 L61_77 0.0382
K3330 L44_45 L29_32 0.0419
K3331 L44_45 L24_25 0.1119
K3332 L44_45 L18_19 0.1564
K3333 L44_45 L7_8 0.0521
K3334 L47_48 L2_3 0.114
K3335 L47_48 L52_53 0.1835
K3336 L47_48 L54_55 0.0645
K3337 L47_48 L32_33 0.0652
K3338 L47_48 L16_17 0.0842
K3339 L47_48 L86_87 0.1238
K3340 L47_48 L14_15 0.1238
K3341 L47_48 L28_29 0.0891
K3342 L47_48 L57_58 0.0962
K3343 L47_48 L64_79 0.1222
K3344 L47_48 L74_75 0.0722
K3345 L47_48 L73_88 0.084
K3346 L47_48 L55_56 0.0775
K3347 L47_48 L67_81 0.1585
K3348 L47_48 L36_37 0.1152
K3349 L47_48 L25_26 0.1062
K3350 L47_48 L62_63 0.0932
K3351 L47_48 L1_17 0.1237
K3352 L47_48 L90_91 0.0652
K3353 L47_48 L35_36 0.0917
K3354 L47_48 L42_43 0.1835
K3355 L47_48 L49_50 0.0901
K3356 L47_48 L13_23 0.103
K3357 L47_48 L68_69 0.0791
K3358 L47_48 L7_21 0.1406
K3359 L47_48 L70_86 0.1252
K3360 L47_48 L71_72 0.0834
K3361 L47_48 L39_40 0.0901
K3362 L47_48 L61_77 0.1024
K3363 L47_48 L29_32 0.0656
K3364 L47_48 L24_25 0.0834
K3365 L47_48 L18_19 0.0932
K3366 L47_48 L7_8 0.1585
K3367 L29_32 L2_3 0.0228
K3368 L29_32 L70_86 0.0755
K3369 L29_32 L16_17 0.0304
K3370 L29_32 L86_87 0.0733
K3371 L29_32 L14_15 0.0749
K3372 L29_32 L83_84 0.0469
K3373 L29_32 L57_58 0.0815
K3374 L29_32 L64_79 0.0269
K3375 L29_32 L73_88 0.1377
K3376 L29_32 L55_56 0.0457
K3377 L29_32 L68_69 0.0544
K3378 L29_32 L67_81 0.034
K3379 L29_32 L36_37 0.0316
K3380 L29_32 L25_26 0.1419
K3381 L29_32 L62_63 0.034
K3382 L29_32 L1_17 0.035
K3383 L29_32 L10_11 0.0473
K3384 L29_32 L35_36 0.0296
K3385 L29_32 L42_43 0.0423
K3386 L29_32 L13_23 0.1184
K3387 L29_32 L7_21 0.0414
K3388 L29_32 L71_72 0.0603
K3389 L29_32 L39_40 0.0333
K3390 L29_32 L54_55 0.0319
K3391 L29_32 L61_77 0.0228
K3392 L29_32 L84_85 0.0465
K3393 L29_32 L11_12 0.0468
K3394 L29_32 L24_25 0.0609
K3395 L29_32 L18_19 0.0341
K3396 L29_32 L7_8 0.0342
K3397 L44_49 L6_9 0.0314
K3398 L44_49 L14_30 0.0384
K3399 L44_49 L16_18 0.0928
K3400 L44_49 L3_6 0.0311
K3401 L44_49 L2_5 0.0378
K3402 L44_49 L38_43 0.0484
K3403 L44_49 L50_55 0.1871
K3404 L44_49 L47_52 0.0856
K3405 L44_49 L45_50 0.2499
K3406 L44_49 L79_81 0.0382
K3407 L44_49 L80_82 0.0314
K3408 L44_49 L62_65 0.0971
K3409 L44_49 L89_91 0.0314
K3410 L44_49 L17_19 0.0712
K3411 L44_49 L52_57 0.0814
K3412 L44_49 L87_89 0.0316
K3413 L44_49 L86_88 0.0384
K3414 L44_49 L10_13 0.0506
K3415 L44_49 L42_47 0.0814
K3416 L44_49 L64_67 0.0552
K3417 L44_49 L60_63 0.0712
K3418 L44_49 L85_87 0.0453
K3419 L44_49 L9_12 0.045
K3420 L44_49 L36_41 0.0917
K3421 L44_49 L67_83 0.0502
K3422 L44_49 L25_28 0.0731
K3423 L44_49 L68_71 0.1
K3424 L44_49 L24_27 0.0971
K3425 L44_49 L11_14 0.0531
K3426 L44_49 L61_64 0.0544
K3427 L44_49 L70_83 0.0506
K3428 L44_49 L12_15 0.0453
K3429 L16_17 L52_53 0.0673
K3430 L16_17 L54_55 0.0512
K3431 L16_17 L32_33 0.029
K3432 L16_17 L70_86 0.0497
K3433 L16_17 L86_87 0.0465
K3434 L16_17 L14_15 0.0466
K3435 L16_17 L28_29 0.0531
K3436 L16_17 L83_84 0.0687
K3437 L16_17 L57_58 0.0444
K3438 L16_17 L74_75 0.0566
K3439 L16_17 L73_88 0.0371
K3440 L16_17 L55_56 0.0546
K3441 L16_17 L67_81 0.0717
K3442 L16_17 L36_37 0.1053
K3443 L16_17 L25_26 0.0635
K3444 L16_17 L62_63 0.351
K3445 L16_17 L10_11 0.0691
K3446 L16_17 L90_91 0.029
K3447 L16_17 L35_36 0.1263
K3448 L16_17 L49_50 0.0868
K3449 L16_17 L13_23 0.0618
K3450 L16_17 L64_79 0.0643
K3451 L16_17 L68_69 0.0675
K3452 L16_17 L7_21 0.1405
K3453 L16_17 L7_8 0.0723
K3454 L16_17 L71_72 0.0686
K3455 L16_17 L84_85 0.0622
K3456 L16_17 L11_12 0.0625
K3457 L16_17 L24_25 0.0689
K3458 L16_17 L18_19 0.4206
K3459 L14_30 L6_9 0.0363
K3460 L14_30 L85_87 0.0873
K3461 L14_30 L16_18 0.0282
K3462 L14_30 L3_6 0.032
K3463 L14_30 L49_54 0.0385
K3464 L14_30 L38_43 0.0353
K3465 L14_30 L50_55 0.0518
K3466 L14_30 L47_52 0.2115
K3467 L14_30 L45_50 0.0517
K3468 L14_30 L80_82 0.0361
K3469 L14_30 L62_65 0.0296
K3470 L14_30 L89_91 0.1228
K3471 L14_30 L17_19 0.0315
K3472 L14_30 L52_57 0.218
K3473 L14_30 L87_89 0.1377
K3474 L14_30 L42_47 0.1035
K3475 L14_30 L10_13 0.1872
K3476 L14_30 L64_67 0.0468
K3477 L14_30 L60_63 0.0314
K3478 L14_30 L39_44 0.0357
K3479 L14_30 L9_12 0.0527
K3480 L14_30 L36_41 0.0499
K3481 L14_30 L67_83 0.0744
K3482 L14_30 L25_28 0.0441
K3483 L14_30 L68_71 0.0367
K3484 L14_30 L24_27 0.0367
K3485 L14_30 L61_64 0.0421
K3486 L14_30 L70_83 0.1673
K3487 L14_30 L12_15 0.0893
K3488 L86_87 L2_3 0.0417
K3489 L86_87 L52_53 0.1844
K3490 L86_87 L54_55 0.0372
K3491 L86_87 L32_33 0.0755
K3492 L86_87 L83_84 0.0987
K3493 L86_87 L57_58 0.075
K3494 L86_87 L64_79 0.0496
K3495 L86_87 L74_75 0.0437
K3496 L86_87 L73_88 0.1118
K3497 L86_87 L55_56 0.0487
K3498 L86_87 L67_81 0.0647
K3499 L86_87 L36_37 0.0506
K3500 L86_87 L25_26 0.0754
K3501 L86_87 L62_63 0.0522
K3502 L86_87 L1_17 0.0595
K3503 L86_87 L10_11 0.0971
K3504 L86_87 L35_36 0.0453
K3505 L86_87 L42_43 0.0699
K3506 L86_87 L49_50 0.0489
K3507 L86_87 L28_29 0.0643
K3508 L86_87 L7_21 0.0725
K3509 L86_87 L71_72 0.0493
K3510 L86_87 L39_40 0.0483
K3511 L86_87 L61_77 0.0416
K3512 L86_87 L84_85 0.1011
K3513 L86_87 L11_12 0.0993
K3514 L86_87 L90_91 0.0772
K3515 L86_87 L24_25 0.0491
K3516 L86_87 L18_19 0.052
K3517 L86_87 L7_8 0.0641
K3518 L86_88 L6_9 0.0361
K3519 L86_88 L85_87 0.0893
K3520 L86_88 L16_18 0.0281
K3521 L86_88 L3_6 0.0318
K3522 L86_88 L49_54 0.0385
K3523 L86_88 L38_43 0.0353
K3524 L86_88 L50_55 0.0518
K3525 L86_88 L47_52 0.2115
K3526 L86_88 L45_50 0.0517
K3527 L86_88 L80_82 0.0363
K3528 L86_88 L62_65 0.0297
K3529 L86_88 L89_91 0.1344
K3530 L86_88 L17_19 0.0314
K3531 L86_88 L52_57 0.218
K3532 L86_88 L87_89 0.1544
K3533 L86_88 L42_47 0.1035
K3534 L86_88 L10_13 0.1673
K3535 L86_88 L64_67 0.0471
K3536 L86_88 L60_63 0.0315
K3537 L86_88 L39_44 0.0357
K3538 L86_88 L9_12 0.0523
K3539 L86_88 L36_41 0.0499
K3540 L86_88 L67_83 0.0756
K3541 L86_88 L25_28 0.0439
K3542 L86_88 L68_71 0.0369
K3543 L86_88 L24_27 0.0365
K3544 L86_88 L61_64 0.0423
K3545 L86_88 L70_83 0.1872
K3546 L86_88 L12_15 0.0873
K3547 L16_18 L6_9 0.0292
K3548 L16_18 L3_6 0.0293
K3549 L16_18 L2_5 0.0369
K3550 L16_18 L49_54 0.0654
K3551 L16_18 L38_43 0.0407
K3552 L16_18 L47_52 0.0661
K3553 L16_18 L67_83 0.047
K3554 L16_18 L79_81 0.0365
K3555 L16_18 L80_82 0.0291
K3556 L16_18 L52_57 0.0515
K3557 L16_18 L89_91 0.0222
K3558 L16_18 L17_19 0.1108
K3559 L16_18 L87_89 0.0233
K3560 L16_18 L25_28 0.0431
K3561 L16_18 L10_13 0.0413
K3562 L16_18 L42_47 0.0793
K3563 L16_18 L64_67 0.0579
K3564 L16_18 L60_63 0.1079
K3565 L16_18 L85_87 0.0364
K3566 L16_18 L61_64 0.0584
K3567 L16_18 L9_12 0.0403
K3568 L16_18 L36_41 0.0949
K3569 L16_18 L11_14 0.0431
K3570 L16_18 L39_44 0.0971
K3571 L16_18 L70_83 0.0412
K3572 L16_18 L12_15 0.0364
K3573 L73_88 L2_3 0.0287
K3574 L73_88 L52_53 0.218
K3575 L73_88 L54_55 0.0353
K3576 L73_88 L32_33 0.1228
K3577 L73_88 L14_15 0.1078
K3578 L73_88 L28_29 0.0738
K3579 L73_88 L57_58 0.0785
K3580 L73_88 L64_79 0.0343
K3581 L73_88 L74_75 0.0435
K3582 L73_88 L55_56 0.0491
K3583 L73_88 L68_69 0.0649
K3584 L73_88 L67_81 0.0438
K3585 L73_88 L36_37 0.0384
K3586 L73_88 L62_63 0.0418
K3587 L73_88 L1_17 0.0438
K3588 L73_88 L10_11 0.0619
K3589 L73_88 L83_84 0.0625
K3590 L73_88 L35_36 0.0357
K3591 L73_88 L42_43 0.0518
K3592 L73_88 L49_50 0.0599
K3593 L73_88 L13_23 0.1634
K3594 L73_88 L7_21 0.0526
K3595 L73_88 L70_86 0.118
K3596 L73_88 L39_40 0.0397
K3597 L73_88 L61_77 0.029
K3598 L73_88 L84_85 0.0617
K3599 L73_88 L11_12 0.0611
K3600 L73_88 L90_91 0.1344
K3601 L73_88 L18_19 0.0416
K3602 L73_88 L7_8 0.0436
K3603 L13_23 L2_3 0.0344
K3604 L13_23 L52_53 0.1688
K3605 L13_23 L54_55 0.0701
K3606 L13_23 L32_33 0.0949
K3607 L13_23 L83_84 0.0693
K3608 L13_23 L57_58 0.0878
K3609 L13_23 L64_79 0.0424
K3610 L13_23 L74_75 0.1366
K3611 L13_23 L55_56 0.1015
K3612 L13_23 L67_81 0.053
K3613 L13_23 L36_37 0.0559
K3614 L13_23 L25_26 0.4206
K3615 L13_23 L62_63 0.0696
K3616 L13_23 L1_17 0.0678
K3617 L13_23 L10_11 0.0697
K3618 L13_23 L35_36 0.0544
K3619 L13_23 L42_43 0.0695
K3620 L13_23 L49_50 0.1104
K3621 L13_23 L28_29 0.238
K3622 L13_23 L7_21 0.084
K3623 L13_23 L71_72 0.1727
K3624 L13_23 L39_40 0.0628
K3625 L13_23 L61_77 0.0362
K3626 L13_23 L84_85 0.0636
K3627 L13_23 L11_12 0.0639
K3628 L13_23 L90_91 0.0923
K3629 L13_23 L24_25 0.1825
K3630 L13_23 L18_19 0.0699
K3631 L13_23 L7_8 0.0532
K3632 L3_6 L2_5 0.1544
K3633 L3_6 L49_54 0.0283
K3634 L3_6 L38_43 0.0601
K3635 L3_6 L50_55 0.0368
K3636 L3_6 L45_50 0.0413
K3637 L3_6 L79_81 0.1228
K3638 L3_6 L62_65 0.0291
K3639 L3_6 L17_19 0.0347
K3640 L3_6 L10_13 0.0756
K3641 L3_6 L64_67 0.0678
K3642 L3_6 L60_63 0.0345
K3643 L3_6 L61_64 0.0693
K3644 L3_6 L36_41 0.0624
K3645 L3_6 L67_83 0.1325
K3646 L3_6 L25_28 0.0246
K3647 L3_6 L68_71 0.0233
K3648 L3_6 L24_27 0.0222
K3649 L3_6 L39_44 0.0314
K3650 L3_6 L70_83 0.074
K3651 L3_6 L11_14 0.0861
K3652 L2_3 L52_53 0.0604
K3653 L2_3 L54_55 0.0232
K3654 L2_3 L32_33 0.0229
K3655 L2_3 L70_86 0.0413
K3656 L2_3 L14_15 0.042
K3657 L2_3 L28_29 0.0304
K3658 L2_3 L83_84 0.0719
K3659 L2_3 L57_58 0.0339
K3660 L2_3 L74_75 0.025
K3661 L2_3 L55_56 0.0276
K3662 L2_3 L67_81 0.1158
K3663 L2_3 L36_37 0.0775
K3664 L2_3 L25_26 0.0358
K3665 L2_3 L62_63 0.038
K3666 L2_3 L10_11 0.0731
K3667 L2_3 L90_91 0.0228
K3668 L2_3 L35_36 0.0545
K3669 L2_3 L49_50 0.0321
K3670 L2_3 L64_79 0.1588
K3671 L2_3 L68_69 0.0271
K3672 L2_3 L7_21 0.0548
K3673 L2_3 L7_8 0.1226
K3674 L2_3 L71_72 0.0287
K3675 L2_3 L84_85 0.0735
K3676 L2_3 L11_12 0.0748
K3677 L2_3 L24_25 0.0288
K3678 L2_3 L18_19 0.0381
K3679 L2_5 L6_9 0.1344
K3680 L2_5 L85_87 0.0606
K3681 L2_5 L49_54 0.0339
K3682 L2_5 L38_43 0.062
K3683 L2_5 L50_55 0.0443
K3684 L2_5 L47_52 0.1665
K3685 L2_5 L45_50 0.0505
K3686 L2_5 L80_82 0.1228
K3687 L2_5 L62_65 0.0365
K3688 L2_5 L89_91 0.0284
K3689 L2_5 L17_19 0.0444
K3690 L2_5 L52_57 0.0805
K3691 L2_5 L87_89 0.0318
K3692 L2_5 L42_47 0.1928
K3693 L2_5 L10_13 0.0949
K3694 L2_5 L64_67 0.0965
K3695 L2_5 L60_63 0.0442
K3696 L2_5 L39_44 0.0382
K3697 L2_5 L9_12 0.1139
K3698 L2_5 L36_41 0.079
K3699 L2_5 L67_83 0.2209
K3700 L2_5 L25_28 0.0296
K3701 L2_5 L68_71 0.0281
K3702 L2_5 L24_27 0.0268
K3703 L2_5 L61_64 0.1
K3704 L2_5 L70_83 0.0925
K3705 L2_5 L12_15 0.0612
K3706 L55_56 L52_53 0.1
K3707 L55_56 L32_33 0.0421
K3708 L55_56 L70_86 0.0516
K3709 L55_56 L14_15 0.0487
K3710 L55_56 L28_29 0.1233
K3711 L55_56 L64_79 0.033
K3712 L55_56 L74_75 0.1587
K3713 L55_56 L67_81 0.0401
K3714 L55_56 L36_37 0.0524
K3715 L55_56 L25_26 0.1152
K3716 L55_56 L62_63 0.0612
K3717 L55_56 L1_17 0.0523
K3718 L55_56 L10_11 0.0489
K3719 L55_56 L90_91 0.0421
K3720 L55_56 L83_84 0.0489
K3721 L55_56 L35_36 0.054
K3722 L55_56 L42_43 0.0617
K3723 L55_56 L49_50 0.133
K3724 L55_56 L68_69 0.1201
K3725 L55_56 L7_21 0.0584
K3726 L55_56 L71_72 0.1382
K3727 L55_56 L39_40 0.0677
K3728 L55_56 L61_77 0.0285
K3729 L55_56 L84_85 0.0469
K3730 L55_56 L11_12 0.0469
K3731 L55_56 L24_25 0.1382
K3732 L55_56 L18_19 0.0612
K3733 L55_56 L7_8 0.0401
K3734 L38_43 L6_9 0.0545
K3735 L38_43 L49_54 0.0434
K3736 L38_43 L50_55 0.0545
K3737 L38_43 L47_52 0.1
K3738 L38_43 L45_50 0.0617
K3739 L38_43 L79_81 0.0572
K3740 L38_43 L80_82 0.0545
K3741 L38_43 L52_57 0.0758
K3742 L38_43 L89_91 0.0301
K3743 L38_43 L17_19 0.0452
K3744 L38_43 L87_89 0.0319
K3745 L38_43 L10_13 0.0568
K3746 L38_43 L42_47 0.133
K3747 L38_43 L64_67 0.0591
K3748 L38_43 L85_87 0.0606
K3749 L38_43 L60_63 0.0452
K3750 L38_43 L62_65 0.0397
K3751 L38_43 L61_64 0.0624
K3752 L38_43 L9_12 0.0786
K3753 L38_43 L36_41 0.0962
K3754 L38_43 L67_83 0.0707
K3755 L38_43 L25_28 0.0329
K3756 L38_43 L68_71 0.0317
K3757 L38_43 L24_27 0.0307
K3758 L38_43 L11_14 0.0633
K3759 L38_43 L39_44 0.0524
K3760 L38_43 L70_83 0.0568
K3761 L38_43 L12_15 0.0606
K3762 L47_52 L49_54 0.0814
K3763 L47_52 L50_55 0.1078
K3764 L47_52 L45_50 0.1149
K3765 L47_52 L79_81 0.1928
K3766 L47_52 L62_65 0.0693
K3767 L47_52 L17_19 0.0748
K3768 L47_52 L10_13 0.3239
K3769 L47_52 L64_67 0.1196
K3770 L47_52 L60_63 0.0748
K3771 L47_52 L61_64 0.1067
K3772 L47_52 L36_41 0.1191
K3773 L47_52 L67_83 0.2898
K3774 L47_52 L25_28 0.0791
K3775 L47_52 L68_71 0.0723
K3776 L47_52 L24_27 0.0693
K3777 L47_52 L39_44 0.0814
K3778 L47_52 L70_83 0.3239
K3779 L47_52 L11_14 0.2868
K3780 L67_81 L52_53 0.0863
K3781 L67_81 L54_55 0.0334
K3782 L67_81 L32_33 0.0338
K3783 L67_81 L84_85 0.1251
K3784 L67_81 L14_15 0.0641
K3785 L67_81 L70_86 0.0655
K3786 L67_81 L57_58 0.0479
K3787 L67_81 L74_75 0.0373
K3788 L67_81 L36_37 0.082
K3789 L67_81 L25_26 0.0547
K3790 L67_81 L62_63 0.0804
K3791 L67_81 L1_17 0.1418
K3792 L67_81 L10_11 0.1264
K3793 L67_81 L83_84 0.1303
K3794 L67_81 L35_36 0.067
K3795 L67_81 L42_43 0.1252
K3796 L67_81 L49_50 0.0465
K3797 L67_81 L28_29 0.046
K3798 L67_81 L64_79 0.1795
K3799 L67_81 L68_69 0.0408
K3800 L67_81 L71_72 0.0431
K3801 L67_81 L39_40 0.0631
K3802 L67_81 L61_77 0.1335
K3803 L67_81 L11_12 0.1217
K3804 L67_81 L90_91 0.034
K3805 L67_81 L24_25 0.043
K3806 L67_81 L18_19 0.0797
K3807 L67_83 L6_9 0.1408
K3808 L67_83 L60_63 0.0563
K3809 L67_83 L50_55 0.0599
K3810 L67_83 L45_50 0.0678
K3811 L67_83 L79_81 0.3014
K3812 L67_83 L80_82 0.1513
K3813 L67_83 L62_65 0.0485
K3814 L67_83 L89_91 0.0528
K3815 L67_83 L17_19 0.056
K3816 L67_83 L52_57 0.1197
K3817 L67_83 L87_89 0.0624
K3818 L67_83 L42_47 0.3239
K3819 L67_83 L49_54 0.0455
K3820 L67_83 L85_87 0.1375
K3821 L67_83 L9_12 0.194
K3822 L67_83 L36_41 0.0902
K3823 L67_83 L25_28 0.0413
K3824 L67_83 L68_71 0.0391
K3825 L67_83 L24_27 0.0369
K3826 L67_83 L11_14 0.1756
K3827 L67_83 L39_44 0.0506
K3828 L67_83 L12_15 0.1327
K3829 L80_82 L49_54 0.029
K3830 L80_82 L50_55 0.0379
K3831 L80_82 L45_50 0.0419
K3832 L80_82 L79_81 0.1544
K3833 L80_82 L62_65 0.0293
K3834 L80_82 L17_19 0.0343
K3835 L80_82 L10_13 0.0911
K3836 L80_82 L64_67 0.0704
K3837 L80_82 L60_63 0.0345
K3838 L80_82 L61_64 0.0688
K3839 L80_82 L36_41 0.0602
K3840 L80_82 L25_28 0.026
K3841 L80_82 L68_71 0.0244
K3842 L80_82 L24_27 0.0233
K3843 L80_82 L39_44 0.0316
K3844 L80_82 L70_83 0.094
K3845 L80_82 L11_14 0.1059
K3846 L52_53 L70_86 0.1585
K3847 L52_53 L14_15 0.1844
K3848 L52_53 L83_84 0.1157
K3849 L52_53 L57_58 0.1527
K3850 L52_53 L64_79 0.0686
K3851 L52_53 L68_69 0.0988
K3852 L52_53 L36_37 0.0814
K3853 L52_53 L25_26 0.1731
K3854 L52_53 L62_63 0.0748
K3855 L52_53 L1_17 0.0828
K3856 L52_53 L10_11 0.1157
K3857 L52_53 L35_36 0.0716
K3858 L52_53 L42_43 0.1149
K3859 L52_53 L7_21 0.0941
K3860 L52_53 L71_72 0.1059
K3861 L52_53 L39_40 0.0767
K3862 L52_53 L54_55 0.0758
K3863 L52_53 L61_77 0.0584
K3864 L52_53 L84_85 0.1229
K3865 L52_53 L11_12 0.1229
K3866 L52_53 L24_25 0.1059
K3867 L52_53 L18_19 0.0748
K3868 L52_53 L7_8 0.0863
K3869 L25_26 L54_55 0.078
K3870 L25_26 L32_33 0.1096
K3871 L25_26 L14_15 0.0759
K3872 L25_26 L28_29 0.299
K3873 L25_26 L57_58 0.0987
K3874 L25_26 L64_79 0.0439
K3875 L25_26 L74_75 0.1571
K3876 L25_26 L68_69 0.1727
K3877 L25_26 L36_37 0.0584
K3878 L25_26 L62_63 0.0713
K3879 L25_26 L1_17 0.0689
K3880 L25_26 L10_11 0.0716
K3881 L25_26 L83_84 0.0713
K3882 L25_26 L35_36 0.0569
K3883 L25_26 L42_43 0.0727
K3884 L25_26 L49_50 0.1176
K3885 L25_26 L7_21 0.0839
K3886 L25_26 L70_86 0.0862
K3887 L25_26 L39_40 0.0662
K3888 L25_26 L61_77 0.0375
K3889 L25_26 L84_85 0.066
K3890 L25_26 L11_12 0.0663
K3891 L25_26 L90_91 0.1061
K3892 L25_26 L18_19 0.0716
K3893 L25_26 L7_8 0.0549
K3894 L17_19 L62_65 0.1042
K3895 L17_19 L6_9 0.0345
K3896 L17_19 L49_54 0.0567
K3897 L17_19 L50_55 0.0752
K3898 L17_19 L45_50 0.102
K3899 L17_19 L79_81 0.0439
K3900 L17_19 L52_57 0.0559
K3901 L17_19 L89_91 0.0246
K3902 L17_19 L87_89 0.026
K3903 L17_19 L10_13 0.0473
K3904 L17_19 L42_47 0.0942
K3905 L17_19 L64_67 0.0728
K3906 L17_19 L85_87 0.0413
K3907 L17_19 L61_64 0.0738
K3908 L17_19 L9_12 0.0471
K3909 L17_19 L36_41 0.1065
K3910 L17_19 L68_71 0.0472
K3911 L17_19 L24_27 0.0431
K3912 L17_19 L11_14 0.0493
K3913 L17_19 L39_44 0.0731
K3914 L17_19 L70_83 0.0472
K3915 L17_19 L12_15 0.0415
K3916 L52_57 L49_54 0.0856
K3917 L52_57 L50_55 0.1149
K3918 L52_57 L45_50 0.1078
K3919 L52_57 L79_81 0.0907
K3920 L52_57 L62_65 0.0541
K3921 L52_57 L10_13 0.1992
K3922 L52_57 L64_67 0.0729
K3923 L52_57 L60_63 0.0559
K3924 L52_57 L61_64 0.0674
K3925 L52_57 L36_41 0.0901
K3926 L52_57 L25_28 0.0913
K3927 L52_57 L68_71 0.075
K3928 L52_57 L24_27 0.0774
K3929 L52_57 L39_44 0.0716
K3930 L52_57 L70_83 0.1992
K3931 L52_57 L11_14 0.1969
K3932 L87_89 L49_54 0.0317
K3933 L87_89 L50_55 0.0423
K3934 L87_89 L45_50 0.0422
K3935 L87_89 L79_81 0.0363
K3936 L87_89 L62_65 0.0244
K3937 L87_89 L10_13 0.1125
K3938 L87_89 L64_67 0.0388
K3939 L87_89 L60_63 0.026
K3940 L87_89 L61_64 0.0353
K3941 L87_89 L36_41 0.0419
K3942 L87_89 L25_28 0.0343
K3943 L87_89 L68_71 0.0293
K3944 L87_89 L24_27 0.0291
K3945 L87_89 L39_44 0.0296
K3946 L87_89 L70_83 0.1182
K3947 L87_89 L11_14 0.1351
K3948 L62_63 L32_33 0.0324
K3949 L62_63 L70_86 0.056
K3950 L62_63 L7_8 0.0797
K3951 L62_63 L14_15 0.052
K3952 L62_63 L28_29 0.0596
K3953 L62_63 L57_58 0.0494
K3954 L62_63 L74_75 0.0642
K3955 L62_63 L36_37 0.1071
K3956 L62_63 L83_84 0.0775
K3957 L62_63 L1_17 0.1727
K3958 L62_63 L10_11 0.077
K3959 L62_63 L35_36 0.1252
K3960 L62_63 L42_43 0.0974
K3961 L62_63 L49_50 0.0975
K3962 L62_63 L68_69 0.0772
K3963 L62_63 L7_21 0.1571
K3964 L62_63 L71_72 0.0781
K3965 L62_63 L39_40 0.1553
K3966 L62_63 L61_77 0.0422
K3967 L62_63 L84_85 0.0698
K3968 L62_63 L11_12 0.0695
K3969 L62_63 L90_91 0.0325
K3970 L62_63 L24_25 0.0778
K3971 L62_63 L54_55 0.0572
K3972 L1_17 L54_55 0.0459
K3973 L1_17 L32_33 0.0341
K3974 L1_17 L70_86 0.0622
K3975 L1_17 L14_15 0.0598
K3976 L1_17 L28_29 0.0568
K3977 L1_17 L83_84 0.1019
K3978 L1_17 L57_58 0.05
K3979 L1_17 L74_75 0.0529
K3980 L1_17 L36_37 0.1263
K3981 L1_17 L10_11 0.1032
K3982 L1_17 L90_91 0.034
K3983 L1_17 L35_36 0.1126
K3984 L1_17 L49_50 0.0709
K3985 L1_17 L64_79 0.1634
K3986 L1_17 L68_69 0.0615
K3987 L1_17 L7_21 0.238
K3988 L1_17 L7_8 0.1472
K3989 L1_17 L71_72 0.0632
K3990 L1_17 L84_85 0.0933
K3991 L1_17 L11_12 0.0943
K3992 L1_17 L24_25 0.0635
K3993 L1_17 L18_19 0.1825
K3994 L10_11 L54_55 0.0396
K3995 L10_11 L32_33 0.0468
K3996 L10_11 L14_15 0.0987
K3997 L10_11 L28_29 0.0598
K3998 L10_11 L57_58 0.0607
K3999 L10_11 L64_79 0.0902
K4000 L10_11 L74_75 0.0456
K4001 L10_11 L36_37 0.0719
K4002 L10_11 L90_91 0.0465
K4003 L10_11 L35_36 0.0628
K4004 L10_11 L42_43 0.1031
K4005 L10_11 L49_50 0.0546
K4006 L10_11 L68_69 0.0496
K4007 L10_11 L7_21 0.1426
K4008 L10_11 L70_86 0.0993
K4009 L10_11 L71_72 0.0525
K4010 L10_11 L39_40 0.0641
K4011 L10_11 L61_77 0.0735
K4012 L10_11 L24_25 0.0527
K4013 L10_11 L18_19 0.0775
K4014 L10_11 L7_8 0.1303
K4015 L32_33 L70_86 0.0733
K4016 L32_33 L14_15 0.0772
K4017 L32_33 L83_84 0.0465
K4018 L32_33 L57_58 0.0893
K4019 L32_33 L64_79 0.0267
K4020 L32_33 L68_69 0.0475
K4021 L32_33 L36_37 0.0314
K4022 L32_33 L35_36 0.029
K4023 L32_33 L42_43 0.0422
K4024 L32_33 L7_21 0.04
K4025 L32_33 L71_72 0.0525
K4026 L32_33 L39_40 0.0322
K4027 L32_33 L54_55 0.0301
K4028 L32_33 L61_77 0.0227
K4029 L32_33 L84_85 0.0469
K4030 L32_33 L11_12 0.0473
K4031 L32_33 L24_25 0.0528
K4032 L32_33 L18_19 0.0325
K4033 L32_33 L7_8 0.034
K4034 L42_47 L49_54 0.0716
K4035 L42_47 L50_55 0.0923
K4036 L42_47 L45_50 0.1078
K4037 L42_47 L79_81 0.2115
K4038 L42_47 L62_65 0.0774
K4039 L42_47 L10_13 0.1992
K4040 L42_47 L64_67 0.1733
K4041 L42_47 L60_63 0.0942
K4042 L42_47 L61_64 0.192
K4043 L42_47 L36_41 0.159
K4044 L42_47 L25_28 0.0591
K4045 L42_47 L68_71 0.0569
K4046 L42_47 L24_27 0.0541
K4047 L42_47 L39_44 0.0856
K4048 L42_47 L70_83 0.1992
K4049 L42_47 L11_14 0.1969
K4050 L35_36 L54_55 0.0524
K4051 L35_36 L70_86 0.0466
K4052 L35_36 L14_15 0.0453
K4053 L35_36 L28_29 0.0489
K4054 L35_36 L57_58 0.0484
K4055 L35_36 L64_79 0.0635
K4056 L35_36 L74_75 0.0501
K4057 L35_36 L68_69 0.0559
K4058 L35_36 L83_84 0.0628
K4059 L35_36 L42_43 0.1179
K4060 L35_36 L49_50 0.0814
K4061 L35_36 L7_21 0.0927
K4062 L35_36 L71_72 0.0584
K4063 L35_36 L39_40 0.1871
K4064 L35_36 L61_77 0.0591
K4065 L35_36 L84_85 0.0602
K4066 L35_36 L11_12 0.0602
K4067 L35_36 L90_91 0.029
K4068 L35_36 L24_25 0.0584
K4069 L35_36 L18_19 0.1252
K4070 L35_36 L7_8 0.067
K4071 L42_43 L54_55 0.0545
K4072 L42_43 L70_86 0.0701
K4073 L42_43 L14_15 0.0699
K4074 L42_43 L28_29 0.0623
K4075 L42_43 L83_84 0.1031
K4076 L42_43 L57_58 0.0701
K4077 L42_43 L74_75 0.0556
K4078 L42_43 L36_37 0.1871
K4079 L42_43 L90_91 0.0422
K4080 L42_43 L49_50 0.0767
K4081 L42_43 L64_79 0.1336
K4082 L42_43 L68_69 0.0605
K4083 L42_43 L7_21 0.1168
K4084 L42_43 L7_8 0.1252
K4085 L42_43 L71_72 0.0639
K4086 L42_43 L84_85 0.1024
K4087 L42_43 L11_12 0.1024
K4088 L42_43 L24_25 0.0639
K4089 L42_43 L18_19 0.0974
K4090 L49_50 L70_86 0.0521
K4091 L49_50 L14_15 0.0489
K4092 L49_50 L83_84 0.0546
K4093 L49_50 L57_58 0.0758
K4094 L49_50 L64_79 0.0387
K4095 L49_50 L68_69 0.2029
K4096 L49_50 L36_37 0.0716
K4097 L49_50 L7_21 0.0777
K4098 L49_50 L71_72 0.202
K4099 L49_50 L39_40 0.1149
K4100 L49_50 L54_55 0.1527
K4101 L49_50 L61_77 0.0337
K4102 L49_50 L84_85 0.0517
K4103 L49_50 L11_12 0.0517
K4104 L49_50 L24_25 0.202
K4105 L49_50 L18_19 0.0975
K4106 L49_50 L7_8 0.0465
K4107 L28_29 L70_86 0.0721
K4108 L28_29 L14_15 0.0647
K4109 L28_29 L83_84 0.0595
K4110 L28_29 L57_58 0.101
K4111 L28_29 L64_79 0.037
K4112 L28_29 L68_69 0.1366
K4113 L28_29 L36_37 0.0501
K4114 L28_29 L7_21 0.0678
K4115 L28_29 L71_72 0.1571
K4116 L28_29 L39_40 0.0574
K4117 L28_29 L54_55 0.0761
K4118 L28_29 L61_77 0.0317
K4119 L28_29 L84_85 0.0558
K4120 L28_29 L11_12 0.056
K4121 L28_29 L24_25 0.1626
K4122 L28_29 L18_19 0.0597
K4123 L28_29 L7_8 0.0462
K4124 L64_79 L70_86 0.0501
K4125 L64_79 L7_8 0.1632
K4126 L64_79 L14_15 0.0493
K4127 L64_79 L57_58 0.0388
K4128 L64_79 L74_75 0.0305
K4129 L64_79 L36_37 0.0826
K4130 L64_79 L83_84 0.0921
K4131 L64_79 L68_69 0.0334
K4132 L64_79 L7_21 0.0738
K4133 L64_79 L71_72 0.0352
K4134 L64_79 L39_40 0.0563
K4135 L64_79 L61_77 0.2525
K4136 L64_79 L84_85 0.0896
K4137 L64_79 L11_12 0.0879
K4138 L64_79 L90_91 0.0268
K4139 L64_79 L24_25 0.0352
K4140 L64_79 L54_55 0.0277
K4141 L49_54 L6_9 0.029
K4142 L49_54 L50_55 0.2499
K4143 L49_54 L45_50 0.1871
K4144 L49_54 L79_81 0.0348
K4145 L49_54 L62_65 0.0705
K4146 L49_54 L89_91 0.0316
K4147 L49_54 L10_13 0.0488
K4148 L49_54 L64_67 0.049
K4149 L49_54 L60_63 0.0567
K4150 L49_54 L85_87 0.044
K4151 L49_54 L9_12 0.0415
K4152 L49_54 L36_41 0.072
K4153 L49_54 L25_28 0.0743
K4154 L49_54 L68_71 0.101
K4155 L49_54 L24_27 0.1
K4156 L49_54 L11_14 0.0514
K4157 L49_54 L61_64 0.0474
K4158 L49_54 L70_83 0.0488
K4159 L49_54 L12_15 0.044
K4160 L60_63 L62_65 0.1069
K4161 L60_63 L6_9 0.0343
K4162 L60_63 L50_55 0.0752
K4163 L60_63 L45_50 0.102
K4164 L60_63 L79_81 0.0441
K4165 L60_63 L89_91 0.0246
K4166 L60_63 L10_13 0.0472
K4167 L60_63 L64_67 0.0735
K4168 L60_63 L85_87 0.0415
K4169 L60_63 L61_64 0.0746
K4170 L60_63 L9_12 0.0469
K4171 L60_63 L36_41 0.1065
K4172 L60_63 L68_71 0.0474
K4173 L60_63 L24_27 0.0429
K4174 L60_63 L11_14 0.0491
K4175 L60_63 L39_44 0.0731
K4176 L60_63 L70_83 0.0473
K4177 L60_63 L12_15 0.0413
K4178 L61_64 L6_9 0.0678
K4179 L61_64 L50_55 0.0623
K4180 L61_64 L45_50 0.0741
K4181 L61_64 L79_81 0.099
K4182 L61_64 L62_65 0.0582
K4183 L61_64 L89_91 0.0322
K4184 L61_64 L85_87 0.062
K4185 L61_64 L9_12 0.0836
K4186 L61_64 L36_41 0.1268
K4187 L61_64 L25_28 0.0412
K4188 L61_64 L68_71 0.04
K4189 L61_64 L24_27 0.0373
K4190 L61_64 L11_14 0.0732
K4191 L61_64 L39_44 0.0552
K4192 L61_64 L12_15 0.0616
K4193 L61_77 L54_55 0.024
K4194 L61_77 L70_86 0.042
K4195 L61_77 L14_15 0.0413
K4196 L61_77 L83_84 0.0748
K4197 L61_77 L57_58 0.0334
K4198 L61_77 L74_75 0.0264
K4199 L61_77 L36_37 0.0801
K4200 L61_77 L90_91 0.0228
K4201 L61_77 L68_69 0.0288
K4202 L61_77 L7_21 0.0634
K4203 L61_77 L7_8 0.1248
K4204 L61_77 L71_72 0.0304
K4205 L61_77 L84_85 0.0731
K4206 L61_77 L11_12 0.0719
K4207 L61_77 L24_25 0.0303
K4208 L61_77 L18_19 0.042
K4209 L9_12 L50_55 0.0543
K4210 L9_12 L45_50 0.0599
K4211 L9_12 L79_81 0.1401
K4212 L9_12 L62_65 0.041
K4213 L9_12 L10_13 0.1375
K4214 L9_12 L64_67 0.0908
K4215 L9_12 L36_41 0.0787
K4216 L9_12 L25_28 0.0373
K4217 L9_12 L68_71 0.0349
K4218 L9_12 L24_27 0.0334
K4219 L9_12 L39_44 0.0453
K4220 L9_12 L70_83 0.1327
K4221 L9_12 L11_14 0.1624
K4222 L68_71 L6_9 0.0243
K4223 L68_71 L79_81 0.0297
K4224 L68_71 L89_91 0.0292
K4225 L68_71 L25_28 0.1042
K4226 L68_71 L10_13 0.0452
K4227 L68_71 L64_67 0.0428
K4228 L68_71 L85_87 0.0392
K4229 L68_71 L36_41 0.0508
K4230 L68_71 L11_14 0.0468
K4231 L68_71 L39_44 0.076
K4232 L68_71 L70_83 0.0454
K4233 L68_71 L12_15 0.0391
K4234 L24_27 L6_9 0.0233
K4235 L24_27 L79_81 0.0281
K4236 L24_27 L89_91 0.0292
K4237 L24_27 L25_28 0.1108
K4238 L24_27 L10_13 0.0434
K4239 L24_27 L64_67 0.0399
K4240 L24_27 L85_87 0.0378
K4241 L24_27 L36_41 0.0478
K4242 L24_27 L11_14 0.0451
K4243 L24_27 L39_44 0.0705
K4244 L24_27 L70_83 0.0433
K4245 L24_27 L12_15 0.0379
K4246 L24_25 L54_55 0.1069
K4247 L24_25 L14_15 0.0493
K4248 L24_25 L57_58 0.0724
K4249 L24_25 L74_75 0.2746
K4250 L24_25 L68_69 0.351
K4251 L24_25 L36_37 0.056
K4252 L24_25 L83_84 0.0525
K4253 L24_25 L7_21 0.0748
K4254 L24_25 L70_86 0.0539
K4255 L24_25 L39_40 0.0745
K4256 L24_25 L84_85 0.0489
K4257 L24_25 L11_12 0.049
K4258 L24_25 L90_91 0.0525
K4259 L24_25 L18_19 0.0781
K4260 L24_25 L7_8 0.0431
K4261 L57_58 L70_86 0.0721
K4262 L57_58 L14_15 0.075
K4263 L57_58 L74_75 0.07
K4264 L57_58 L36_37 0.0524
K4265 L57_58 L90_91 0.0893
K4266 L57_58 L83_84 0.0607
K4267 L57_58 L68_69 0.0652
K4268 L57_58 L7_21 0.0553
K4269 L57_58 L71_72 0.0724
K4270 L57_58 L39_40 0.0545
K4271 L57_58 L84_85 0.0621
K4272 L57_58 L11_12 0.0621
K4273 L57_58 L18_19 0.0494
K4274 L57_58 L7_8 0.0479
K4275 L62_65 L6_9 0.0292
K4276 L62_65 L79_81 0.0369
K4277 L62_65 L89_91 0.0233
K4278 L62_65 L25_28 0.0472
K4279 L62_65 L10_13 0.0433
K4280 L62_65 L64_67 0.0587
K4281 L62_65 L85_87 0.0379
K4282 L62_65 L36_41 0.0862
K4283 L62_65 L11_14 0.0449
K4284 L62_65 L39_44 0.1
K4285 L62_65 L70_83 0.0434
K4286 L62_65 L12_15 0.0378
K4287 L6_9 L50_55 0.0379
K4288 L6_9 L45_50 0.0419
K4289 L6_9 L79_81 0.1377
K4290 L6_9 L10_13 0.094
K4291 L6_9 L64_67 0.0693
K4292 L6_9 L36_41 0.0602
K4293 L6_9 L25_28 0.026
K4294 L6_9 L39_44 0.0316
K4295 L6_9 L70_83 0.0911
K4296 L6_9 L11_14 0.1098
K4297 L71_72 L54_55 0.1069
K4298 L71_72 L14_15 0.0491
K4299 L71_72 L74_75 0.299
K4300 L71_72 L68_69 0.4206
K4301 L71_72 L36_37 0.056
K4302 L71_72 L83_84 0.0527
K4303 L71_72 L7_21 0.0745
K4304 L71_72 L70_86 0.0541
K4305 L71_72 L39_40 0.0745
K4306 L71_72 L84_85 0.049
K4307 L71_72 L11_12 0.0489
K4308 L71_72 L90_91 0.0528
K4309 L71_72 L18_19 0.0778
K4310 L71_72 L7_8 0.043
K4311 L64_67 L50_55 0.065
K4312 L64_67 L45_50 0.0756
K4313 L64_67 L79_81 0.1028
K4314 L64_67 L89_91 0.0353
K4315 L64_67 L85_87 0.0689
K4316 L64_67 L36_41 0.1183
K4317 L64_67 L25_28 0.0445
K4318 L64_67 L11_14 0.083
K4319 L64_67 L39_44 0.0556
K4320 L64_67 L12_15 0.0683
K4321 L85_87 L50_55 0.0582
K4322 L85_87 L45_50 0.0604
K4323 L85_87 L79_81 0.0728
K4324 L85_87 L10_13 0.194
K4325 L85_87 L36_41 0.0671
K4326 L85_87 L25_28 0.0434
K4327 L85_87 L39_44 0.044
K4328 L85_87 L70_83 0.2075
K4329 L85_87 L11_14 0.2416
K4330 L7_8 L54_55 0.0334
K4331 L7_8 L84_85 0.1217
K4332 L7_8 L14_15 0.0647
K4333 L7_8 L70_86 0.0649
K4334 L7_8 L74_75 0.0373
K4335 L7_8 L36_37 0.082
K4336 L7_8 L83_84 0.1264
K4337 L7_8 L68_69 0.0407
K4338 L7_8 L39_40 0.0631
K4339 L7_8 L11_12 0.1251
K4340 L7_8 L90_91 0.0338
K4341 L7_8 L18_19 0.0804
K4342 L14_15 L54_55 0.0372
K4343 L14_15 L83_84 0.0971
K4344 L14_15 L74_75 0.0436
K4345 L14_15 L36_37 0.0506
K4346 L14_15 L7_21 0.0731
K4347 L14_15 L39_40 0.0483
K4348 L14_15 L84_85 0.0993
K4349 L14_15 L11_12 0.1011
K4350 L14_15 L90_91 0.0755
K4351 L14_15 L18_19 0.0522
K4352 L74_75 L70_86 0.0477
K4353 L74_75 L83_84 0.0458
K4354 L74_75 L68_69 0.238
K4355 L74_75 L36_37 0.0482
K4356 L74_75 L7_21 0.0615
K4357 L74_75 L39_40 0.0637
K4358 L74_75 L54_55 0.1117
K4359 L74_75 L84_85 0.0429
K4360 L74_75 L11_12 0.0428
K4361 L74_75 L18_19 0.064
K4362 L36_41 L50_55 0.0901
K4363 L36_41 L45_50 0.1191
K4364 L36_41 L79_81 0.0756
K4365 L36_41 L89_91 0.0397
K4366 L36_41 L10_13 0.0738
K4367 L36_41 L25_28 0.0502
K4368 L36_41 L11_14 0.078
K4369 L36_41 L39_44 0.1152
K4370 L36_41 L70_83 0.0738
K4371 L36_41 L12_15 0.0671
K4372 L68_69 L54_55 0.0946
K4373 L68_69 L83_84 0.0498
K4374 L68_69 L36_37 0.0534
K4375 L68_69 L7_21 0.0731
K4376 L68_69 L39_40 0.0714
K4377 L68_69 L84_85 0.0461
K4378 L68_69 L11_12 0.046
K4379 L68_69 L90_91 0.0478
K4380 L68_69 L18_19 0.0768
K4381 L50_55 L79_81 0.0457
K4382 L50_55 L89_91 0.0422
K4383 L50_55 L25_28 0.1088
K4384 L50_55 L10_13 0.0654
K4385 L50_55 L11_14 0.0685
K4386 L50_55 L39_44 0.1179
K4387 L50_55 L70_83 0.0654
K4388 L50_55 L12_15 0.0582
K4389 L36_37 L54_55 0.0484
K4390 L36_37 L70_86 0.0511
K4391 L36_37 L83_84 0.0719
K4392 L36_37 L7_21 0.1003
K4393 L36_37 L39_40 0.1179
K4394 L36_37 L84_85 0.071
K4395 L36_37 L11_12 0.071
K4396 L36_37 L90_91 0.0314
K4397 L36_37 L18_19 0.1071
K4398 L45_50 L79_81 0.0512
K4399 L45_50 L89_91 0.0419
K4400 L45_50 L25_28 0.1061
K4401 L45_50 L10_13 0.0684
K4402 L45_50 L11_14 0.0713
K4403 L45_50 L39_44 0.1871
K4404 L45_50 L70_83 0.0684
K4405 L45_50 L12_15 0.0604
K4406 L79_81 L89_91 0.032
K4407 L79_81 L10_13 0.1212
K4408 L79_81 L39_44 0.0384
K4409 L79_81 L25_28 0.0314
K4410 L79_81 L70_83 0.1273
K4411 L79_81 L12_15 0.0717
K4412 L89_91 L10_13 0.0911
K4413 L89_91 L25_28 0.0345
K4414 L89_91 L39_44 0.029
K4415 L89_91 L70_83 0.094
K4416 L89_91 L11_14 0.1059
K4417 L83_84 L54_55 0.0396
K4418 L83_84 L90_91 0.0468
K4419 L83_84 L7_21 0.1388
K4420 L83_84 L70_86 0.1011
K4421 L83_84 L39_40 0.0641
K4422 L83_84 L18_19 0.077
K4423 L90_91 L70_86 0.0749
K4424 L90_91 L7_21 0.0398
K4425 L90_91 L39_40 0.0322
K4426 L90_91 L54_55 0.0301
K4427 L90_91 L84_85 0.0473
K4428 L90_91 L11_12 0.0469
K4429 L90_91 L18_19 0.0324
K4430 L25_28 L10_13 0.0505
K4431 L25_28 L11_14 0.0521
K4432 L25_28 L39_44 0.0598
K4433 L25_28 L70_83 0.0502
K4434 L25_28 L12_15 0.0435
K4435 L10_13 L11_14 0.386
K4436 L10_13 L39_44 0.0488
K4437 L10_13 L12_15 0.2075
K4438 L7_21 L54_55 0.0499
K4439 L7_21 L84_85 0.1194
K4440 L7_21 L70_86 0.0774
K4441 L7_21 L39_40 0.0916
K4442 L7_21 L11_12 0.1218
K4443 L7_21 L18_19 0.1626
K4444 L70_86 L54_55 0.0391
K4445 L70_86 L39_40 0.0505
K4446 L70_86 L84_85 0.0987
K4447 L70_86 L11_12 0.0971
K4448 L70_86 L18_19 0.0558
K4449 L39_44 L11_14 0.0514
K4450 L39_44 L70_83 0.0488
K4451 L39_44 L12_15 0.044
K4452 L39_40 L54_55 0.0701
K4453 L39_40 L84_85 0.0606
K4454 L39_40 L11_12 0.0606
K4455 L39_40 L18_19 0.1553
K4456 L54_55 L84_85 0.038
K4457 L54_55 L11_12 0.038
K4458 L54_55 L18_19 0.0572
K4459 L84_85 L18_19 0.0695
K4460 L11_12 L18_19 0.0698
K4461 L11_14 L70_83 0.316
K4462 L11_14 L12_15 0.2651
K4463 L70_83 L12_15 0.194
Vs1 236 gnd DC 0 AC 1.0
Rin92 236 92 50.0
Rin123 123 gnd 50.0
.ac lin 1 46415.0Hz 46415.0Hz
.option post=2
.probe i(L1_17) i(L1_2) i(L1_4) i(L2_3) i(L2_5) i(L3_6) i(L4_19) i(L4_5) i(L4_7) i(L5_8) i(L5_6) i(L6_9) i(L7_8) i(L7_10) i(L7_21) i(L8_9) i(L8_11) i(L9_12) i(L10_11) i(L10_13) i(L11_12) i(L11_14) i(L12_15) i(L13_26) i(L13_14) i(L13_23) i(L14_30) i(L14_15) i(L15_31) i(L16_17) i(L16_18) i(L17_19) i(L18_19) i(L18_20) i(L19_21) i(L20_21) i(L22_24) i(L22_23) i(L23_25) i(L24_25) i(L24_27) i(L25_26) i(L25_28) i(L26_30) i(L26_29) i(L27_28) i(L28_29) i(L29_32) i(L30_32) i(L30_31) i(L31_33) i(L32_33) i(L34_35) i(L34_39) i(L35_40) i(L35_36) i(L36_41) i(L36_37) i(L37_42) i(L37_38) i(L38_43) i(L39_40) i(L39_44) i(L40_41) i(L40_45) i(L41_42) i(L41_46) i(L42_43) i(L42_47) i(L43_48) i(L44_49) i(L44_45) i(L45_50) i(L45_46) i(L46_51) i(L46_47) i(L47_48) i(L47_52) i(L48_53) i(L49_50) i(L49_54) i(L50_51) i(L50_55) i(L51_56) i(L51_52) i(L52_57) i(L52_53) i(L53_58) i(L54_55) i(L55_56) i(L56_57) i(L57_58) i(L59_60) i(L59_62) i(L60_61) i(L60_63) i(L61_64) i(L61_77) i(L62_65) i(L62_63) i(L63_64) i(L63_66) i(L64_79) i(L64_67) i(L65_66) i(L66_67) i(L67_81) i(L67_83) i(L68_69) i(L68_71) i(L69_72) i(L69_70) i(L70_73) i(L70_83) i(L70_86) i(L71_72) i(L71_74) i(L72_73) i(L72_75) i(L73_88) i(L73_76) i(L74_75) i(L75_76) i(L76_90) i(L77_78) i(L77_79) i(L78_80) i(L79_81) i(L79_80) i(L80_82) i(L81_82) i(L81_84) i(L82_85) i(L83_84) i(L84_85) i(L84_86) i(L85_87) i(L86_88) i(L86_87) i(L87_89) i(L88_90) i(L88_89) i(L89_91) i(L90_91)
.option GENK=0
.end
